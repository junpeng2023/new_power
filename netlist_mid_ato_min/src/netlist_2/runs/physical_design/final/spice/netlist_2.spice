* NGSPICE file created from netlist_2.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_2 abstract view
.subckt sky130_fd_sc_hd__a41o_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_4 abstract view
.subckt sky130_fd_sc_hd__mux4_4 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_12 abstract view
.subckt sky130_fd_sc_hd__inv_12 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_1 abstract view
.subckt sky130_fd_sc_hd__a41oi_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_1 abstract view
.subckt sky130_fd_sc_hd__dfxbp_1 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_2 abstract view
.subckt sky130_fd_sc_hd__dlxtn_2 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_1 abstract view
.subckt sky130_fd_sc_hd__dlxtn_1 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_2 abstract view
.subckt sky130_fd_sc_hd__dlclkp_2 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_4 abstract view
.subckt sky130_fd_sc_hd__dlclkp_4 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_1 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_4 abstract view
.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_4 abstract view
.subckt sky130_fd_sc_hd__dlxtn_4 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_1 abstract view
.subckt sky130_fd_sc_hd__dlxbn_1 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_4 abstract view
.subckt sky130_fd_sc_hd__o21ba_4 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxtp_1 abstract view
.subckt sky130_fd_sc_hd__sedfxtp_1 CLK D DE SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_2 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_2 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_4 abstract view
.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_2 abstract view
.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtp_1 abstract view
.subckt sky130_fd_sc_hd__dlxtp_1 D GATE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbp_1 CLK D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q
+ Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_4 abstract view
.subckt sky130_fd_sc_hd__a41oi_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__lpflow_inputisolatch_1 abstract view
.subckt sky130_fd_sc_hd__lpflow_inputisolatch_1 D SLEEP_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_2 abstract view
.subckt sky130_fd_sc_hd__a41oi_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_4 abstract view
.subckt sky130_fd_sc_hd__a21bo_4 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_2 abstract view
.subckt sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbp_1 abstract view
.subckt sky130_fd_sc_hd__dlxbp_1 D GATE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_1 abstract view
.subckt sky130_fd_sc_hd__dlclkp_1 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfstp_2 abstract view
.subckt sky130_fd_sc_hd__sdfstp_2 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_2 abstract view
.subckt sky130_fd_sc_hd__dfxbp_2 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_4 abstract view
.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_1 abstract view
.subckt sky130_fd_sc_hd__clkinv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfstp_4 abstract view
.subckt sky130_fd_sc_hd__sdfstp_4 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_4 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_4 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfsbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfsbp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_8 abstract view
.subckt sky130_fd_sc_hd__mux2_8 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxtp_1 abstract view
.subckt sky130_fd_sc_hd__edfxtp_1 CLK D DE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfrbp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_4 abstract view
.subckt sky130_fd_sc_hd__a41o_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_1 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_1 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_1 abstract view
.subckt sky130_fd_sc_hd__dlrbn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtn_1 abstract view
.subckt sky130_fd_sc_hd__dfrtn_1 CLK_N D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbp_2 abstract view
.subckt sky130_fd_sc_hd__dlrbp_2 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtn_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtn_1 CLK_N D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbp_1 abstract view
.subckt sky130_fd_sc_hd__dlrbp_1 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_0 abstract view
.subckt sky130_fd_sc_hd__a21boi_0 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxbp_1 abstract view
.subckt sky130_fd_sc_hd__edfxbp_1 CLK D DE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_1 abstract view
.subckt sky130_fd_sc_hd__dlrtn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfsbp_2 abstract view
.subckt sky130_fd_sc_hd__sdfsbp_2 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_2 abstract view
.subckt sky130_fd_sc_hd__dfsbp_2 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_2 abstract view
.subckt sky130_fd_sc_hd__dlrtp_2 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_1 abstract view
.subckt sky130_fd_sc_hd__dlrtp_1 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_2 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_2 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_2 abstract view
.subckt sky130_fd_sc_hd__dfstp_2 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_0 abstract view
.subckt sky130_fd_sc_hd__o21ai_0 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_4 abstract view
.subckt sky130_fd_sc_hd__dfstp_4 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_4 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_4 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_2 abstract view
.subckt sky130_fd_sc_hd__dfrbp_2 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxtp_4 abstract view
.subckt sky130_fd_sc_hd__sedfxtp_4 CLK D DE SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxbp_2 abstract view
.subckt sky130_fd_sc_hd__sedfxbp_2 CLK D DE SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_2 abstract view
.subckt sky130_fd_sc_hd__dlrbn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_1 abstract view
.subckt sky130_fd_sc_hd__dfsbp_1 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_2 abstract view
.subckt sky130_fd_sc_hd__dlrtn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxbp_1 abstract view
.subckt sky130_fd_sc_hd__sedfxbp_1 CLK D DE SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_16 abstract view
.subckt sky130_fd_sc_hd__buf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_4 abstract view
.subckt sky130_fd_sc_hd__dlrtp_4 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfbbn_1 abstract view
.subckt sky130_fd_sc_hd__dfbbn_1 CLK_N D RESET_B SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

.subckt netlist_2 VGND VPWR clk in0 in1 in10 in11 in12 in13 in14 in15 in16 in17 in18
+ in19 in2 in20 in21 in22 in23 in24 in25 in26 in27 in28 in29 in3 in30 in31 in32 in33
+ in34 in35 in36 in37 in38 in39 in4 in40 in41 in42 in43 in44 in45 in46 in47 in48 in49
+ in5 in50 in51 in6 in7 in8 in9 out0 out1 out10 out11 out12 out13 out14 out15 out16
+ out17 out18 out19 out2 out20 out21 out22 out23 out24 out25 out26 out27 out28 out29
+ out3 out30 out31 out32 out33 out34 out35 out36 out37 out38 out39 out4 out40 out41
+ out42 out43 out44 out45 out46 out47 out48 out49 out5 out50 out51 out6 out7 out8
+ out9 rst
XFILLER_0_94_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net270 clknet_0_net270 VGND VGND VPWR VPWR clknet_1_1__leaf_net270
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s983_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c421_B net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c202_X net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc327 net763 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__clkbuf_1
Xc316 net9 net219 net973 net257 net1056 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__a41o_2
Xc305 clknet_1_0__leaf_net247 net249 net242 net241 net217 net1056 VGND VGND VPWR VPWR
+ net253 sky130_fd_sc_hd__mux4_4
XFILLER_0_13_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc338 net280 net7 net2 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__o21ai_2
Xc349 net746 VGND VGND VPWR VPWR net1001 sky130_fd_sc_hd__inv_12
XFILLER_0_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c676_Y net578 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c431_A1 clknet_1_0__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge815 net129 net112 net1061 net214 net115 net984 VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__mux4_1
XFILLER_0_83_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge804 net1020 clknet_1_0__leaf_net147 net311 net761 net771 VGND VGND VPWR VPWR
+ net712 sky130_fd_sc_hd__a41oi_1
Xmerge826 clknet_1_1__leaf_net464 clknet_1_0__leaf_net463 clknet_1_0__leaf_net458
+ net221 net941 net213 VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__mux4_2
Xmerge837 net401 net408 VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__xor2_4
XFILLER_0_67_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xs932 clknet_4_13_0_clk net33 VGND VGND VPWR VPWR net862 net861 sky130_fd_sc_hd__dfxbp_1
Xs943 net208 clknet_4_15_0_clk VGND VGND VPWR VPWR net1005 sky130_fd_sc_hd__dlxtn_2
Xmerge859 net325 net326 VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__xor2_2
Xmerge848 net520 net524 VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__xnor2_1
XFILLER_0_70_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs976 net615 clknet_4_2_0_clk VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_36_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs965 clknet_4_3_0_clk net494 VGND VGND VPWR VPWR net895 net894 sky130_fd_sc_hd__dfxbp_1
Xs954 clknet_4_1_0_clk net352 VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__dlclkp_2
XTAP_TAPCELL_ROW_11_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs987 clknet_4_4_0_clk net716 VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_63_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c606_A1 net499 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer7 net1074 VGND VGND VPWR VPWR net1075 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c325_A2 net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s965_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout105 net346 VGND VGND VPWR VPWR net1033 sky130_fd_sc_hd__clkbuf_4
Xfanout116 net984 VGND VGND VPWR VPWR net1044 sky130_fd_sc_hd__buf_8
XFILLER_0_96_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c152_X net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge828_A1 net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net860 clknet_0_net860 VGND VGND VPWR VPWR clknet_1_0__leaf_net860
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge920_GATE_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c707_B1 net568 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc102 net955 net46 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__xor2_1
XFILLER_0_60_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc124 net50 net45 net61 net1051 net862 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__a41o_1
Xc113 net672 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__buf_1
Xc135 net952 net937 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__xnor2_4
XFILLER_0_20_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc168 net959 net116 net1061 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__o21a_1
Xc157 net948 net964 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__xor2_1
Xc146 net96 net83 net92 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__o21bai_2
Xc179 net1048 net935 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__xnor2_1
XFILLER_0_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge929_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_99_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c617_A0 net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc691 net797 VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__buf_6
Xc680 net572 net573 clknet_1_0__leaf_net576 VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__o21a_1
XFILLER_0_75_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c502_A3 net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c281_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s938_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge814_A3 net32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_6_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c112_A net672 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c412_A3 net338 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c55_B1 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c437_B1 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge859_X net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c546_RESET_B net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c603_A2 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input10_X net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c216_A4 net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s946_GATE clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout128_X net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input2_X net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c142_A3 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc84 clknet_4_13_0_clk net29 net23 net1043 net12 net24 VGND VGND VPWR VPWR net31 net30
+ sky130_fd_sc_hd__sdfbbn_1
Xc73 net843 VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkinv_4
Xc62 net763 VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__inv_2
Xc95 net9 net5 net964 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__a21boi_4
XTAP_TAPCELL_ROW_26_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c675_S1 net738 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c333_A2 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c630_A0 net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net655 clknet_0_net655 VGND VGND VPWR VPWR clknet_1_1__leaf_net655
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c243_A2 net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c444_A net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c355_SCD net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c232_X net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net867 net867 VGND VGND VPWR VPWR clknet_0_net867 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c52_A1 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold41 net861 VGND VGND VPWR VPWR net1109 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 net196 VGND VGND VPWR VPWR net1098 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c594_SCD net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input18_A in24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c328_A2 net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c625_A0 net522 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c344_A1 net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output86_A clknet_1_0__leaf_net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net452 clknet_0_net452 VGND VGND VPWR VPWR clknet_1_1__leaf_net452
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net463 clknet_0_net463 VGND VGND VPWR VPWR clknet_1_1__leaf_net463
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net474 clknet_0_net474 VGND VGND VPWR VPWR clknet_1_1__leaf_net474
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_37_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c121_CLK_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c63_B1 net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput53 net981 VGND VGND VPWR VPWR out0 sky130_fd_sc_hd__clkbuf_4
Xoutput64 clknet_1_1__leaf_net992 VGND VGND VPWR VPWR out19 sky130_fd_sc_hd__clkbuf_1
Xoutput75 clknet_1_0__leaf_net1003 VGND VGND VPWR VPWR out30 sky130_fd_sc_hd__clkbuf_1
Xoutput86 clknet_1_0__leaf_net1014 VGND VGND VPWR VPWR out42 sky130_fd_sc_hd__clkbuf_1
Xoutput97 clknet_1_0__leaf_net1025 VGND VGND VPWR VPWR out6 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c611_A2 net519 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_RESET_B net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_hold26_A net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c240_A3 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge817_A3 net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_8_0_clk_X clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout110_X net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c265_B1 net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc306 net243 net242 net246 clknet_1_1__leaf_net247 net252 net1024 VGND VGND VPWR VPWR
+ net254 sky130_fd_sc_hd__mux4_2
Xc317 net746 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__clkbuf_2
Xc328 net271 net277 net265 clknet_1_0__leaf_net276 net1041 net772 VGND VGND VPWR VPWR
+ net278 sky130_fd_sc_hd__mux4_1
XFILLER_0_13_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c415_A3 net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc339 net233 net283 clknet_1_1__leaf_net262 net165 clknet_1_1__leaf_net1025 net1006
+ VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__mux4_4
XANTENNA_c397_X net336 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c712_A1 net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c669_Y net570 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge805 net65 net59 net61 net743 VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__a31o_1
Xmerge827 net966 net3 net1026 clknet_1_1__leaf_net276 net261 net250 VGND VGND VPWR
+ VPWR net735 sky130_fd_sc_hd__mux4_4
Xmerge816 net589 net588 clknet_1_0__leaf_net565 net344 net343 net1031 VGND VGND VPWR
+ VPWR net724 sky130_fd_sc_hd__mux4_1
Xs933 clknet_4_15_0_clk net77 VGND VGND VPWR VPWR net864 net863 sky130_fd_sc_hd__dfxbp_1
Xmerge849 clknet_4_14_0_clk net307 net318 VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__dfstp_1
Xmerge838 clknet_4_4_0_clk net369 net377 VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_82_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs944 net225 clknet_4_5_0_clk VGND VGND VPWR VPWR net874 sky130_fd_sc_hd__dlxtn_2
Xs977 net627 clknet_4_2_0_clk VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__dlxtn_4
Xs966 clknet_4_3_0_clk net515 VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__dfxtp_1
Xs955 clknet_4_1_0_clk net355 VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__dlclkp_4
XTAP_TAPCELL_ROW_11_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs988 net724 clknet_4_0_0_clk VGND VGND VPWR VPWR net923 net922 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_36_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s963_SLEEP_B clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c606_A2 net522 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer8 net1074 VGND VGND VPWR VPWR net1076 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c325_A3 net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c622_A1 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c341_A2 net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net316 clknet_0_net316 VGND VGND VPWR VPWR clknet_1_0__leaf_net316
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_19_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout106 net133 VGND VGND VPWR VPWR net1034 sky130_fd_sc_hd__buf_4
Xfanout128 net1107 VGND VGND VPWR VPWR net1056 sky130_fd_sc_hd__buf_6
Xfanout117 net290 VGND VGND VPWR VPWR net1045 sky130_fd_sc_hd__buf_4
XFILLER_0_38_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_1_1__f_net990_A clknet_0_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge828_A2 clknet_1_0__leaf_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c531_B net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c312_X net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c707_A1 net468 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc114 net832 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_1
Xc103 net37 net48 net49 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__o21ba_4
Xc125 net19 net64 net5 net50 net1050 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__a41oi_1
Xc136 net936 net84 net963 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__o21ai_2
XANTENNA_c723_A0 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge922_GATE clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc169 net779 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__buf_1
XANTENNA_c60_A1 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc158 net100 net1049 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__xnor2_4
Xc147 net94 net92 net942 net84 net89 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__a41o_1
XFILLER_0_13_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c442_A1 net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c98_X net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge770_B1 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge865_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge928_Q net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c633_A0 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc670 clknet_4_0_0_clk net563 clknet_1_0__leaf_net565 clknet_1_0__leaf_net566 net570
+ net875 VGND VGND VPWR VPWR net572 net571 sky130_fd_sc_hd__sdfbbn_1
Xc681 clknet_4_0_0_clk clknet_1_0__leaf_net582 clknet_1_0__leaf_net576 net578 net737
+ VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__sedfxtp_1
Xc692 net923 VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_86_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout118_A net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge847_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input48_A in51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c603_A3 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c693_RESET_B net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c689_S0 net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c628_A0 net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge838_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_1_1__f_net786_A clknet_0_net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge829_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c489_CLK_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c704_A2 net468 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c720_A1 net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc74 net19 net16 VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__xnor2_4
Xc52 net931 net929 net1013 VGND VGND VPWR VPWR net0 sky130_fd_sc_hd__a21boi_4
Xc85 net839 VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_4
Xc63 net8 net1038 net0 net973 net955 VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__a41o_1
Xc96 net1091 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_26_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c448_A0 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c333_A3 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net623 clknet_0_net623 VGND VGND VPWR VPWR clknet_1_1__leaf_net623
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c630_A1 net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_72_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c364_SCE net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_9_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c355_SCE net1107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold20 net169 VGND VGND VPWR VPWR net1088 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 net1015 VGND VGND VPWR VPWR net1099 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c594_SCE clknet_1_1__leaf_net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c625_A1 net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c344_A2 net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net453 clknet_0_net453 VGND VGND VPWR VPWR clknet_1_1__leaf_net453
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net464 clknet_0_net464 VGND VGND VPWR VPWR clknet_1_1__leaf_net464
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c238_A3 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_4_0_clk_X clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c429_A2 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net643 net643 VGND VGND VPWR VPWR clknet_0_net643 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c726_A0 net519 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c445_A1 net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput76 net1004 VGND VGND VPWR VPWR out31 sky130_fd_sc_hd__buf_2
Xoutput65 net993 VGND VGND VPWR VPWR out2 sky130_fd_sc_hd__buf_2
Xoutput54 net982 VGND VGND VPWR VPWR out1 sky130_fd_sc_hd__buf_2
Xoutput98 net1038 VGND VGND VPWR VPWR out7 sky130_fd_sc_hd__buf_2
Xoutput87 net1015 VGND VGND VPWR VPWR out43 sky130_fd_sc_hd__buf_2
XANTENNA_input30_A in35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c611_A3 clknet_1_1__leaf_net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge773_B1 net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c258_CLK_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_1_0__f_net990_A clknet_0_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge802_S0 net499 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_99_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc307 clknet_4_7_0_clk net248 net241 net1058 net242 net252 VGND VGND VPWR VPWR net256
+ net255 sky130_fd_sc_hd__sdfbbn_2
Xc318 net231 clknet_1_0__leaf_net1025 clknet_1_0__leaf_net1023 VGND VGND VPWR VPWR
+ net267 sky130_fd_sc_hd__o21bai_4
XFILLER_0_13_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc329 net272 net876 net878 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__a21bo_2
XFILLER_0_13_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c580_B1_N clknet_1_0__leaf_net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout103_X net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c671_A net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge795_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge817 net157 net28 net158 net295 net1001 net1026 VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__mux4_4
XFILLER_0_83_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge828 net563 net980 clknet_1_0__leaf_net565 clknet_1_0__leaf_net342 clknet_1_0__leaf_net567
+ net1037 VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__mux4_1
Xmerge806 net92 net459 net1037 clknet_1_0__leaf_net339 clknet_1_0__leaf_net340 net338
+ VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__mux4_1
Xs934 clknet_4_15_0_clk net78 VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__dfxtp_1
Xmerge839 net168 net1088 VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__xor2_1
XFILLER_0_36_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs967 clknet_4_3_0_clk net528 VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__dfxtp_2
Xs956 net356 clknet_4_4_0_clk VGND VGND VPWR VPWR net883 net882 sky130_fd_sc_hd__dlxbn_1
Xs945 net226 clknet_4_4_0_clk VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__dlxtn_2
XTAP_TAPCELL_ROW_11_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs989 net730 clknet_4_0_0_clk VGND VGND VPWR VPWR net925 net924 sky130_fd_sc_hd__dlxbn_1
Xs978 net631 clknet_4_2_0_clk VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__dlxtp_1
Xclkbuf_0_net462 net462 VGND VGND VPWR VPWR clknet_0_net462 sky130_fd_sc_hd__clkbuf_16
Xrebuffer9 net1076 VGND VGND VPWR VPWR net1077 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c606_A3 clknet_1_0__leaf_net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge768_B1 net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net339 clknet_0_net339 VGND VGND VPWR VPWR clknet_1_0__leaf_net339
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c204_S1 net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c366_B1 net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout118 net290 VGND VGND VPWR VPWR net1046 sky130_fd_sc_hd__buf_4
Xfanout107 net282 VGND VGND VPWR VPWR net1035 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge828_A3 clknet_1_0__leaf_net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c707_A2 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc115 net62 net61 net50 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__a21o_1
Xc126 net62 net58 net45 net1051 net743 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__a41o_1
Xc104 net11 net972 net12 net46 net37 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__a41oi_1
XFILLER_0_60_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc159 net108 net109 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__xor2_2
Xc137 net977 net939 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__xnor2_4
Xc148 net758 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__buf_2
XFILLER_0_13_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c305_S0 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_A2 net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_net270 net270 VGND VGND VPWR VPWR clknet_0_net270 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge770_A1 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge897_GATE clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc682 net1039 net348 VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__xnor2_4
Xc660 net338 net1047 VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__xor2_2
Xc671 net820 VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__buf_6
XFILLER_0_75_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc693 clknet_4_0_0_clk net587 net1039 net1042 net480 net901 VGND VGND VPWR VPWR net596
+ net595 sky130_fd_sc_hd__sdfbbp_1
Xclkbuf_1_0__f_net136 clknet_0_net136 VGND VGND VPWR VPWR clknet_1_0__leaf_net136
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net147 clknet_0_net147 VGND VGND VPWR VPWR clknet_1_0__leaf_net147
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_clkbuf_1_0__f_net786_A clknet_0_net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c246_A3 net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc690_9 clknet_1_0__leaf_net919 VGND VGND VPWR VPWR net1072 sky130_fd_sc_hd__clkinv_2
XPHY_EDGE_ROW_27_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c422_X net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_36_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net827 clknet_0_net827 VGND VGND VPWR VPWR clknet_1_1__leaf_net827
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_45_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c546_Q net468 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c628_A1 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_54_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge781_B1 net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc490 net293 net428 clknet_1_1__leaf_net990 net181 VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__a31oi_1
XPHY_EDGE_ROW_63_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c84_CLK_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_72_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout130_A net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc53 net951 net935 net970 net975 net1061 VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__a41oi_4
Xc64 net1 net9 net949 net5 net975 net762 VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__mux4_2
Xc75 net17 net19 net11 VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__o21ba_1
Xc86 net16 net27 net28 net31 net4 net23 VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__mux4_4
Xc97 net22 net376 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__xnor2_4
XFILLER_0_97_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c66_A1 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_90_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c183_A1 net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c614_A3 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_60_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c165_A net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout133_X net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_0_0_clk_X clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c284_A0 clknet_1_0__leaf_net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c731_A1 net568 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold32 net759 VGND VGND VPWR VPWR net1100 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 net103 VGND VGND VPWR VPWR net1089 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c95_B1_N net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c80_Y net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c625_A2 net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net454 clknet_0_net454 VGND VGND VPWR VPWR clknet_1_1__leaf_net454
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c369_B1 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s986_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c547_A net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c429_A3 net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net655 net655 VGND VGND VPWR VPWR clknet_0_net655 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c63_A2 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c445_A2 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c742_A0 net536 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput66 net994 VGND VGND VPWR VPWR out20 sky130_fd_sc_hd__buf_2
XANTENNA_c461_A1 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput55 net1041 VGND VGND VPWR VPWR out10 sky130_fd_sc_hd__buf_2
Xoutput77 net1005 VGND VGND VPWR VPWR out32 sky130_fd_sc_hd__buf_2
Xoutput88 net1016 VGND VGND VPWR VPWR out44 sky130_fd_sc_hd__buf_2
Xoutput99 net1027 VGND VGND VPWR VPWR out8 sky130_fd_sc_hd__buf_2
XANTENNA_c84_SCD net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input23_A in29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net1023 net1023 VGND VGND VPWR VPWR clknet_0_net1023 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_98_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c339_A3 net165 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c636_A1 net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c697_S1 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s968_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net262 clknet_0_net262 VGND VGND VPWR VPWR clknet_1_1__leaf_net262
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c414_D net349 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c365_CLK_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc308 net140 net138 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__xor2_2
Xc319 net779 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c285_X net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c664_A net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc536_10 net921 VGND VGND VPWR VPWR net1073 sky130_fd_sc_hd__clkinv_4
Xmerge807 net350 net337 clknet_1_0__leaf_net222 net575 clknet_1_1__leaf_net576 clknet_1_0__leaf_net577
+ VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__mux4_1
Xmerge818 net259 clknet_1_0__leaf_net262 net1064 clknet_1_1__leaf_net462 clknet_1_1__leaf_net458
+ net1031 VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__mux4_2
XFILLER_0_82_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge829 clknet_4_0_0_clk net569 net579 VGND VGND VPWR VPWR net738 net737 sky130_fd_sc_hd__dfrbp_1
XFILLER_0_36_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xs935 clknet_4_15_0_clk net81 VGND VGND VPWR VPWR net986 sky130_fd_sc_hd__dfxtp_1
Xs946 net253 clknet_4_7_0_clk VGND VGND VPWR VPWR net1024 sky130_fd_sc_hd__dlxtp_1
XFILLER_0_36_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs968 clknet_4_11_0_clk net546 VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__dfxtp_1
Xs957 net370 clknet_4_3_0_clk VGND VGND VPWR VPWR net1027 net884 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_90_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xs979 net641 clknet_4_2_0_clk VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__lpflow_inputisolatch_1
XTAP_TAPCELL_ROW_11_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net452 net452 VGND VGND VPWR VPWR clknet_0_net452 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net474 net474 VGND VGND VPWR VPWR clknet_0_net474 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net463 net463 VGND VGND VPWR VPWR clknet_0_net463 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c175_A2 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c622_A3 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input26_X net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c501_S0 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c382_A0 net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_hold31_A net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s944_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net830 clknet_0_net830 VGND VGND VPWR VPWR clknet_1_0__leaf_net830
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c557_B1 net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c707_A3 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c276_A1 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc116 net832 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_2
Xc127 net66 net65 net45 net32 net1051 net817 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__mux4_4
Xc105 net24 net218 net15 net47 net12 net46 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__mux4_1
XFILLER_0_13_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_96_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c60_A3 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc149 net758 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__inv_2
Xc138 net1060 net88 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__xor2_4
XANTENNA_c305_S1 net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c324_Q net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge770_A2 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc672 net573 net564 net570 VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__o21bai_1
Xc661 clknet_1_0__leaf_net335 net338 VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__xor2_1
Xc683 net842 VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__inv_6
Xc694 net1072 net1042 net845 VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__o21bai_2
XFILLER_0_91_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net137 clknet_0_net137 VGND VGND VPWR VPWR clknet_1_0__leaf_net137
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c262_A3 net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c579_D net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c55_A3 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c718_A2 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c734_A1 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c750_A0 net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net828 clknet_0_net828 VGND VGND VPWR VPWR clknet_1_1__leaf_net828
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_100_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c628_A2 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c706_Q net609 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_48 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc480 clknet_1_0__leaf_net415 net1044 net409 clknet_1_1__leaf_net398 net26 net416
+ VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__mux4_4
Xc491 net56 clknet_1_1__leaf_net321 clknet_1_1__leaf_net425 net293 clknet_1_1__leaf_net867
+ VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__a41oi_2
XFILLER_0_87_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c257_A3 net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c554_A1 net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c704_A4 net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c570_B1 clknet_1_0__leaf_net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c720_A3 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc54 net1013 net951 net968 VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__a21bo_4
Xc65 net934 net956 net932 VGND VGND VPWR VPWR net1013 sky130_fd_sc_hd__o21ba_2
Xc76 net969 net762 VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__xnor2_4
Xc87 net12 net934 net30 net20 net32 net861 VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__mux4_4
XFILLER_0_97_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc98 net44 net42 VGND VGND VPWR VPWR net1011 sky130_fd_sc_hd__xor2_4
XFILLER_0_97_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A1 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c448_A2 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c745_A0 clknet_1_0__leaf_net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c630_A3 clknet_1_0__leaf_net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net647 clknet_0_net647 VGND VGND VPWR VPWR clknet_1_1__leaf_net647
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c477_RESET_B clknet_1_1__leaf_net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge792_B1 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c332_B net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold22 net879 VGND VGND VPWR VPWR net1090 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 net1018 VGND VGND VPWR VPWR net1101 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c459_A1 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c475_A0 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c73_Y net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c194_A1 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c625_A3 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c369_A1 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c551_A2 net360 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c733_SCD net519 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c230_X net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net623 net623 VGND VGND VPWR VPWR clknet_0_net623 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s935_Q net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c726_A2 clknet_1_1__leaf_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c742_A1 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput67 clknet_1_1__leaf_net995 VGND VGND VPWR VPWR out21 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c461_A2 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput56 net1075 VGND VGND VPWR VPWR out11 sky130_fd_sc_hd__buf_2
Xoutput89 net1017 VGND VGND VPWR VPWR out45 sky130_fd_sc_hd__clkbuf_4
Xoutput78 net1006 VGND VGND VPWR VPWR out33 sky130_fd_sc_hd__clkbuf_4
XANTENNA_input16_A in22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c636_A2 net507 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net230 clknet_0_net230 VGND VGND VPWR VPWR clknet_1_1__leaf_net230
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge886_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc309 clknet_1_0__leaf_net136 net975 net1024 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__a21bo_2
XFILLER_0_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c712_A4 net1052 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input8_A in15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c664_B clknet_1_0__leaf_net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c180_X net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmerge808 net337 clknet_1_0__leaf_net453 net88 net102 net220 net213 VGND VGND VPWR
+ VPWR net716 sky130_fd_sc_hd__mux4_1
Xmerge819 net92 clknet_1_1__leaf_net335 net336 net975 clknet_1_1__leaf_net270 net261
+ VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__mux4_4
XANTENNA_c612_X net536 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs936 clknet_4_7_0_clk net113 VGND VGND VPWR VPWR net1008 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_82_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xs947 net254 clknet_4_6_0_clk VGND VGND VPWR VPWR net997 sky130_fd_sc_hd__lpflow_inputisolatch_1
XFILLER_0_36_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs958 net386 clknet_4_6_0_clk VGND VGND VPWR VPWR net886 net885 sky130_fd_sc_hd__dlxbp_1
XTAP_TAPCELL_ROW_11_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net453 net453 VGND VGND VPWR VPWR clknet_0_net453 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net464 net464 VGND VGND VPWR VPWR clknet_0_net464 sky130_fd_sc_hd__clkbuf_16
Xs969 clknet_4_11_0_clk net547 VGND VGND VPWR VPWR net987 sky130_fd_sc_hd__dlclkp_1
XFILLER_0_51_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c753_A0 net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c472_A1 net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge768_A2 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c382_A1 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout109 net561 VGND VGND VPWR VPWR net1037 sky130_fd_sc_hd__clkbuf_4
XANTENNA_merge813_S1 net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c707_A4 clknet_1_1__leaf_net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c405_A net854 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc117 net61 net50 net1063 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__mux2_1
Xc106 net46 net50 net47 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__a21oi_2
XFILLER_0_79_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c60_A4 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc128 net74 net5 net45 net75 net1051 net863 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__mux4_1
Xc139 net83 net938 net89 net935 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__a31oi_2
XFILLER_0_13_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c667_Y net568 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c222_B1_N net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c748_A0 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c93_A net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge770_A3 net360 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c633_A3 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc662 net348 net338 VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__xnor2_1
Xc673 net674 VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__inv_4
Xc684 clknet_1_0__leaf_net576 net1039 clknet_1_1__leaf_net566 VGND VGND VPWR VPWR
+ net586 sky130_fd_sc_hd__o21ai_1
Xc695 net564 net596 clknet_1_0__leaf_net597 VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__a21bo_2
XFILLER_0_91_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c543_A3 net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge808_S1 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge824_S0 net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c188_A net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_rebuffer6_A net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c750_A1 net609 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c628_A3 net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge926_Q net854 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc481 net274 net993 net397 net821 net889 VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__a41oi_1
Xc470 clknet_4_9_0_clk net296 clknet_1_0__leaf_net374 net404 net1002 VGND VGND VPWR
+ VPWR net999 sky130_fd_sc_hd__sdfstp_2
Xc492 clknet_4_9_0_clk net400 clknet_1_0__leaf_net429 net993 net422 net426 VGND VGND
+ VPWR VPWR net432 net431 sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_59_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c110_B net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout116_A net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc55 net968 net1 net973 net975 VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__a31oi_2
Xc66 net938 net11 net972 net7 net762 VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__a41o_2
Xc77 net16 net20 net972 VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__a21boi_1
Xc99 net29 net978 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__xnor2_2
Xc88 net817 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_26_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c66_A3 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c729_A2 net594 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c82_A2 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c761_A0 net593 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c480_A1 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input46_A in5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c597_SCE net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge876_Q net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c549_A2 net468 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net827 net827 VGND VGND VPWR VPWR clknet_0_net827 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c565_A1 net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c715_A4 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c687_A net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_A3 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold23 net817 VGND VGND VPWR VPWR net1091 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c579_SCE net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold12 net422 VGND VGND VPWR VPWR net1080 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 net871 VGND VGND VPWR VPWR net1102 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c756_A0 net609 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c194_A2 net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c59_X net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c491_B1 clknet_1_1__leaf_net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input49_X net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap129_A net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net412 clknet_0_net412 VGND VGND VPWR VPWR clknet_1_1__leaf_net412
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net456 clknet_0_net456 VGND VGND VPWR VPWR clknet_1_1__leaf_net456
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge787_A1 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c385_A1 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge816_S1 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_9_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_69_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net990 clknet_0_net990 VGND VGND VPWR VPWR clknet_1_1__leaf_net990
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c733_SCE net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_1_0__f_net1025_X clknet_1_0__leaf_net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c63_A4 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c726_A3 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_78_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput57 net985 VGND VGND VPWR VPWR out12 sky130_fd_sc_hd__buf_2
Xoutput79 net1007 VGND VGND VPWR VPWR out34 sky130_fd_sc_hd__buf_2
Xoutput68 net996 VGND VGND VPWR VPWR out23 sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_net1014 net1014 VGND VGND VPWR VPWR clknet_0_net1014 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net1025 net1025 VGND VGND VPWR VPWR clknet_0_net1025 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net1003 net1003 VGND VGND VPWR VPWR clknet_0_net1003 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_98_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c486_B1 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c488_SCD net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge798_A0 net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge827_S0 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge809 net949 net12 net156 net149 net1108 VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__a41o_1
XFILLER_0_83_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c737_A2 net536 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs937 clknet_4_5_0_clk net126 VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__dlclkp_1
XFILLER_0_75_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xs948 clknet_4_6_0_clk net269 VGND VGND VPWR VPWR net877 net876 sky130_fd_sc_hd__dfxbp_2
XFILLER_0_36_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xs959 net393 clknet_4_6_0_clk VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__dlxtn_2
XFILLER_0_36_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net454 net454 VGND VGND VPWR VPWR clknet_0_net454 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge768_A3 net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_19_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c366_A3 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s973_GATE_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_CLK_N clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c557_A2 net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c133_A net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c573_A1 net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc118 net831 VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__buf_1
Xc107 clknet_4_13_0_clk net39 net46 net53 net44 net1100 VGND VGND VPWR VPWR net55
+ net54 sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_5_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc129 clknet_4_15_0_clk net75 net63 net1051 net864 net865 VGND VGND VPWR VPWR net80
+ net79 sky130_fd_sc_hd__sdfbbn_1
XANTENNA_fanout101_X net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c748_A1 net609 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net262 net262 VGND VGND VPWR VPWR clknet_0_net262 sky130_fd_sc_hd__clkbuf_16
Xc630 net985 net991 net852 clknet_1_0__leaf_net867 net890 net1053 VGND VGND VPWR VPWR
+ net554 sky130_fd_sc_hd__mux4_2
Xc663 net675 VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__inv_1
Xc696 clknet_1_0__leaf_net586 net594 net584 net1042 net1039 VGND VGND VPWR VPWR net599
+ sky130_fd_sc_hd__a41oi_4
Xc685 net484 net1039 clknet_1_1__leaf_net566 VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__a21oi_2
Xc674 net574 clknet_1_0__leaf_net567 net575 VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__o21a_1
XANTENNA_max_cap111_A net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c197_B1_N net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c188_B net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c143_Y net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net867_X clknet_1_1__leaf_net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c584_A0 net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c408_Y net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c734_A3 clknet_1_1__leaf_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c453_A4 net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c197_A2 net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge781_A3 net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc482 clknet_1_0__leaf_net412 net1044 net821 net888 VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__a31o_4
Xc471 net405 net999 net404 net26 clknet_1_1__leaf_net381 VGND VGND VPWR VPWR net407
+ sky130_fd_sc_hd__a41o_1
Xc460 net394 net380 net397 net886 net887 net888 VGND VGND VPWR VPWR net1002 sky130_fd_sc_hd__mux4_2
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc493 net1092 net1032 net310 net416 VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__a31o_1
XANTENNA_c388_A1 net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_32_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge931_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge819_S1 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c554_A3 net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_93_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout109_A net561 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc67 net1078 VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_2
Xc56 net970 net976 net1061 VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__o21bai_4
XPHY_EDGE_ROW_50_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc89 net17 net765 VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__xor2_2
Xc78 net778 VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_26_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A3 clknet_1_1__leaf_net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c66_A4 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s958_Q net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net481 clknet_0_net481 VGND VGND VPWR VPWR clknet_1_0__leaf_net481
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c365_RESET_B net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c464_A3 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input39_A in43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net616 clknet_0_net616 VGND VGND VPWR VPWR clknet_1_1__leaf_net616
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c670_SET_B net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge792_A2 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc290 net930 net767 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__xnor2_2
XFILLER_0_94_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_4_5_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net828 net828 VGND VGND VPWR VPWR clknet_0_net828 sky130_fd_sc_hd__clkbuf_16
XANTENNA_clkbuf_1_1__f_net398_X clknet_1_1__leaf_net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c284_A3 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net565_X clknet_1_1__leaf_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold13 net841 VGND VGND VPWR VPWR net1081 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 net54 VGND VGND VPWR VPWR net1103 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 net404 VGND VGND VPWR VPWR net1092 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c459_A3 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c756_A1 clknet_1_1__leaf_net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c194_A3 net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c369_A3 net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c255_CLK_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c163_A net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_36_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c428_A net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net647 net647 VGND VGND VPWR VPWR clknet_0_net647 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput58 net986 VGND VGND VPWR VPWR out13 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput69 net997 VGND VGND VPWR VPWR out24 sky130_fd_sc_hd__buf_2
XFILLER_0_98_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c189_A3 net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c488_SCE net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net276 clknet_0_net276 VGND VGND VPWR VPWR clknet_1_1__leaf_net276
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge827_S1 net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c545_A net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c340_Y net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c587_B1 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs938 clknet_4_7_0_clk net139 VGND VGND VPWR VPWR net1023 sky130_fd_sc_hd__dlclkp_2
XANTENNA_s940_Q net869 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs949 clknet_4_7_0_clk net278 VGND VGND VPWR VPWR net879 net878 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_16_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c472_A3 net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c616_S0 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input21_A in27 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_13_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c351_S0 net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c382_A3 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_97_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c441_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net866 clknet_0_net866 VGND VGND VPWR VPWR clknet_1_0__leaf_net866
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net899 clknet_0_net899 VGND VGND VPWR VPWR clknet_1_0__leaf_net899
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c557_A3 net336 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_1_0__f_net867_X clknet_1_0__leaf_net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c469_B1_N net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc108 net840 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__inv_4
Xc119 net63 net972 net1011 net64 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_96_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c290_Y net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c662_A net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c748_A2 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net230 net230 VGND VGND VPWR VPWR clknet_0_net230 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_52_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc631 clknet_1_1__leaf_net419 net516 clknet_1_1__leaf_net554 net186 net1045 clknet_1_0__leaf_net987
+ VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__mux4_1
Xc620 clknet_1_0__leaf_net321 net1045 net985 net1033 clknet_1_1__leaf_net535 net890
+ VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__mux4_4
Xc664 net1047 clknet_1_0__leaf_net453 VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__xnor2_2
Xc686 net459 net578 net902 VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__o21a_1
Xc697 net459 net1042 net588 net1037 net595 net1062 VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__mux4_4
Xc675 net460 net574 net573 clknet_1_0__leaf_net566 clknet_1_0__leaf_net576 net738
+ VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__mux4_1
XANTENNA_merge779_A3 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c607_CLK_N clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c393_A2 clknet_1_1__leaf_net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s962_GATE clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c414_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c584_A1 net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c750_A3 net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c166_S0 net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c478_A2 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc450 net387 clknet_1_1__leaf_net381 VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__xnor2_2
Xc461 clknet_1_0__leaf_net385 net397 net1002 net368 net387 net888 VGND VGND VPWR VPWR
+ net398 sky130_fd_sc_hd__mux4_4
Xc472 net384 net974 net405 net1061 net294 net1006 VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__mux4_2
XFILLER_0_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc483 clknet_4_9_0_clk net418 net293 clknet_1_1__leaf_net419 net413 clknet_1_1__leaf_net415
+ VGND VGND VPWR VPWR net421 net420 sky130_fd_sc_hd__sdfbbp_1
Xc494 clknet_4_12_0_clk net301 net424 net427 net317 net781 VGND VGND VPWR VPWR net435
+ net434 sky130_fd_sc_hd__sdfbbn_1
XANTENNA_c388_A2 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_82_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_0__f_net398_X clknet_1_0__leaf_net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net565_X clknet_1_0__leaf_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_1_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c570_A3 net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc57 net976 net970 net948 VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__o21a_4
Xc68 net967 net2 net1043 VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__mux2_2
Xc79 net930 net19 net5 VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__a21boi_2
XFILLER_0_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A4 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c246_X net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge928_GATE clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c65_B1_N net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c480_A3 clknet_1_1__leaf_net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net617 clknet_0_net617 VGND VGND VPWR VPWR clknet_1_1__leaf_net617
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_96_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc280 net216 net221 net874 VGND VGND VPWR VPWR net1025 sky130_fd_sc_hd__o21ba_4
Xc291 net237 net955 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__xor2_4
XFILLER_0_46_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c565_A3 net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge790 net244 net239 net349 net336 VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_31_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c581_A2 clknet_1_0__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold14 net819 VGND VGND VPWR VPWR net1082 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 net1000 VGND VGND VPWR VPWR net1093 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 net835 VGND VGND VPWR VPWR net1104 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c756_A2 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c619_S0 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input51_A in8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge831_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net425 clknet_0_net425 VGND VGND VPWR VPWR clknet_1_1__leaf_net425
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net458 clknet_0_net458 VGND VGND VPWR VPWR clknet_1_1__leaf_net458
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_84_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s956_GATE_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c203_B1 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net992 clknet_0_net992 VGND VGND VPWR VPWR clknet_1_1__leaf_net992
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_0_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c330_B net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c711_S1 net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c323_A net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge889_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c216_Y net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge767_D net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c592_A1 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c439_S0 net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput59 clknet_1_1__leaf_net987 VGND VGND VPWR VPWR out14 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c709_SCD clknet_1_0__leaf_net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c486_A2 net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c426_Q_N net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge798_A2 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net222 clknet_0_net222 VGND VGND VPWR VPWR clknet_1_1__leaf_net222
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s979_SLEEP_B clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xs939 clknet_4_7_0_clk net144 VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_48_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net412 net412 VGND VGND VPWR VPWR clknet_0_net412 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net456 net456 VGND VGND VPWR VPWR clknet_0_net456 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c753_A3 net609 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c254_CLK_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c616_S1 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input14_A in20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c497_A1 net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net990 net990 VGND VGND VPWR VPWR clknet_0_net990 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_74_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net867 clknet_0_net867 VGND VGND VPWR VPWR clknet_1_0__leaf_net867
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc109 net44 net55 net759 VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__a21boi_1
XFILLER_0_41_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input6_A in13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c662_B net338 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c748_A3 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc621 clknet_1_1__leaf_net412 net979 net1032 net522 net445 c621/S1 VGND VGND VPWR
+ VPWR net545 sky130_fd_sc_hd__mux4_4
Xc610 net529 net421 net397 net1040 clknet_1_1__leaf_net881 net897 VGND VGND VPWR VPWR
+ net534 sky130_fd_sc_hd__mux4_1
Xc632 net422 net1022 net999 clknet_1_0__leaf_net554 net818 clknet_1_1__leaf_net828
+ VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__mux4_1
XANTENNA_merge764_S0 clknet_1_1__leaf_net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc698 net924 VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__inv_4
Xc665 net221 net460 VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__xnor2_1
Xc676 net859 VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__clkinv_8
Xc687 net793 VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c627_S0 clknet_1_0__leaf_net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input17_X net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c393_A3 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c256_S1 net869 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_98_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c584_A2 net499 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc438_6 clknet_1_1__leaf_net786 VGND VGND VPWR VPWR net1069 sky130_fd_sc_hd__clkinv_1
XFILLER_0_41_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c166_S1 net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge857_GATE clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c759_A2 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc462 clknet_1_1__leaf_net342 clknet_1_0__leaf_net1014 net1062 VGND VGND VPWR VPWR
+ net399 sky130_fd_sc_hd__a21boi_1
Xc473 net808 VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__buf_6
Xc451 net932 net379 clknet_1_0__leaf_net385 net808 net876 VGND VGND VPWR VPWR net1003
+ sky130_fd_sc_hd__a41o_1
Xc440 net834 VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__inv_2
Xc495 clknet_1_1__leaf_net425 net435 net313 net428 net181 net432 VGND VGND VPWR VPWR
+ net436 sky130_fd_sc_hd__mux4_4
Xc484 clknet_4_12_0_clk net347 net1040 net509 net1086 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__sdfstp_4
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c685_A1 net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc58 net969 net976 net971 VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__o21bai_4
Xc69 net764 VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_6
XANTENNA_c353_A net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c730_S0 clknet_1_0__leaf_net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c595_A1 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c562_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc281 clknet_4_4_0_clk net223 net103 net796 net874 net875 VGND VGND VPWR VPWR net229
+ net228 sky130_fd_sc_hd__sdfbbp_1
Xc292 clknet_4_5_0_clk net84 net1089 net239 net116 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__sdfrtp_4
XFILLER_0_46_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c696_B1 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge780 clknet_1_0__leaf_net371 net252 net383 clknet_1_1__leaf_net270 net1047 VGND
+ VGND VPWR VPWR net688 sky130_fd_sc_hd__a41oi_1
Xmerge791 net213 net936 net135 net128 net1020 VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__a41o_1
XFILLER_0_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net453_X clknet_1_1__leaf_net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c581_A3 net499 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c681_SCD net578 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold26 net796 VGND VGND VPWR VPWR net1094 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 net484 VGND VGND VPWR VPWR net1083 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 net893 VGND VGND VPWR VPWR net1105 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_3_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c530_Y net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c756_A3 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_252 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c619_S1 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input44_A in48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net415 clknet_0_net415 VGND VGND VPWR VPWR clknet_1_1__leaf_net415
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c370_S0 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net616 net616 VGND VGND VPWR VPWR clknet_0_net616 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_583 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout117_X net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c439_S1 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c709_SCE net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c57_X net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c597_Q net522 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input47_X net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net267 clknet_0_net267 VGND VGND VPWR VPWR clknet_1_1__leaf_net267
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net289 clknet_0_net289 VGND VGND VPWR VPWR clknet_1_1__leaf_net289
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_84_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_13_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c722_S1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_1_0__f_net1023_X clknet_1_0__leaf_net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c319_X net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output75_A clknet_1_0__leaf_net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge894_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c215_B1_N net869 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c598_A1 net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c269_X net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s970_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net276 net276 VGND VGND VPWR VPWR clknet_0_net276 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc611 net414 net532 net519 clknet_1_1__leaf_net1025 net889 net897 VGND VGND VPWR VPWR
+ net535 sky130_fd_sc_hd__mux4_4
Xc622 net421 net446 net414 net1022 net994 net1041 VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__mux4_1
Xc600 net838 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__clkbuf_1
Xc633 net186 clknet_1_1__leaf_net554 net448 net777 clknet_1_0__leaf_net867 clknet_1_1__leaf_net899
+ VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__mux4_2
Xc688 net842 VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__buf_1
Xc666 clknet_1_1__leaf_net920 VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__buf_1
Xc677 clknet_1_1__leaf_net562 clknet_1_0__leaf_net577 net572 clknet_1_1__leaf_net576
+ VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__a31o_4
XANTENNA_c627_S1 clknet_1_1__leaf_net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc699 net1042 net844 net903 VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__o21ba_1
XFILLER_0_99_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold15_A net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net643 clknet_0_net643 VGND VGND VPWR VPWR clknet_1_0__leaf_net643
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s952_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c584_A3 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc438_7 clknet_1_0__leaf_net786 VGND VGND VPWR VPWR net1070 sky130_fd_sc_hd__clkinv_1
XTAP_TAPCELL_ROW_29_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c478_A4 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc430 net592 VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__inv_4
XFILLER_0_20_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc441 clknet_4_6_0_clk net252 net238 net1033 net882 VGND VGND VPWR VPWR net380 net379
+ sky130_fd_sc_hd__sdfsbp_1
Xc463 net1104 VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__clkbuf_2
Xc452 clknet_4_6_0_clk net1034 net387 net384 clknet_1_0__leaf_net1003 net754 VGND
+ VGND VPWR VPWR net390 net389 sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_20_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc474 net409 net405 clknet_1_1__leaf_net1014 net821 net1008 VGND VGND VPWR VPWR net410
+ sky130_fd_sc_hd__a41o_2
Xc485 clknet_1_1__leaf_net374 net994 net323 net310 net885 VGND VGND VPWR VPWR net423
+ sky130_fd_sc_hd__a41o_1
Xc496 net1079 net423 net400 net426 net432 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__a41o_2
XFILLER_0_19_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c373_S0 net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge916_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s934_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c685_A2 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net453_X clknet_1_0__leaf_net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c206_A1 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_10_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc59 net967 net1 net964 net5 VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__a31o_4
XFILLER_0_92_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge907_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c141_Y net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c730_S1 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c595_A2 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net462 clknet_0_net462 VGND VGND VPWR VPWR clknet_1_0__leaf_net462
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c458_S0 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge800_Y net708 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c193_S0 net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c452_SET_B net754 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c728_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc260 net204 net82 net201 net199 net972 net1005 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__mux4_1
Xc271 net963 net815 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__xnor2_4
Xc293 net118 net237 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__xnor2_4
Xc282 clknet_1_1__leaf_net222 net88 net223 net228 net99 net95 VGND VGND VPWR VPWR
+ net230 sky130_fd_sc_hd__mux4_1
XFILLER_0_79_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c250_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge770 net1032 net978 net360 net1058 VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__a31oi_1
Xmerge781 net101 clknet_1_1__leaf_net340 net337 net214 VGND VGND VPWR VPWR net689
+ sky130_fd_sc_hd__a31oi_1
XFILLER_0_15_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge792 net372 net363 clknet_1_0__leaf_net375 net1058 VGND VGND VPWR VPWR net700
+ sky130_fd_sc_hd__a31o_4
XFILLER_0_70_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout107_A net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge801_A1 net580 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold38 net477 VGND VGND VPWR VPWR net1106 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 net888 VGND VGND VPWR VPWR net1084 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c741_S0 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net270 clknet_0_net270 VGND VGND VPWR VPWR clknet_1_0__leaf_net270
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c491_A4 net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input37_A in41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c203_A2 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net617 net617 VGND VGND VPWR VPWR clknet_0_net617 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c592_A3 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s942_GATE clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c455_S1 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c486_A4 net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net235 clknet_0_net235 VGND VGND VPWR VPWR clknet_1_1__leaf_net235
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c320_A0 net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge854_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c587_A3 net507 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net425 net425 VGND VGND VPWR VPWR clknet_0_net425 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net458 net458 VGND VGND VPWR VPWR clknet_0_net458 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_2_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c124_A1 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c140_B1 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net992 net992 VGND VGND VPWR VPWR clknet_0_net992 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_22_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c426_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_66_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_85_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_75_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_84_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c436_Y net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c331_X net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_93_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net222 net222 VGND VGND VPWR VPWR clknet_0_net222 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_64_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc612 net531 net507 net523 net501 net813 net897 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__mux4_2
Xc601 clknet_1_1__leaf_net1025 net999 net1045 clknet_1_1__leaf_net881 VGND VGND VPWR
+ VPWR net995 sky130_fd_sc_hd__a31o_2
XFILLER_0_32_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc634 net993 clknet_1_1__leaf_net554 net1033 net849 net852 clknet_1_0__leaf_net987
+ VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__mux4_1
Xc623 net541 net428 net1041 clknet_1_1__leaf_net534 net1032 net186 VGND VGND VPWR
+ VPWR net547 sky130_fd_sc_hd__mux4_4
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc667 net928 VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__clkinv_2
Xc689 net449 net485 net480 net1042 net348 clknet_1_1__leaf_net586 VGND VGND VPWR VPWR
+ net591 sky130_fd_sc_hd__mux4_4
Xc678 net568 net575 net460 net348 net564 net737 VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__mux4_2
XFILLER_0_24_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_58 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c699_A1 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net655 clknet_0_net655 VGND VGND VPWR VPWR clknet_1_0__leaf_net655
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c229_B net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge804_A1 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c660_A net338 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc420 net348 net224 VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc453 clknet_1_0__leaf_net388 net390 clknet_1_1__leaf_net381 net240 net387 VGND VGND
+ VPWR VPWR net391 sky130_fd_sc_hd__a41oi_4
Xc442 net1069 net932 net273 VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__mux2_8
Xc431 clknet_1_0__leaf_net367 clknet_1_0__leaf_net990 clknet_1_1__leaf_net339 clknet_1_1__leaf_net366
+ clknet_1_0__leaf_net361 net820 VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__mux4_4
Xc464 net283 clknet_1_1__leaf_net399 net1058 net400 VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__a31o_1
XFILLER_0_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc497 net980 net432 net420 net994 net434 VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__a41o_1
Xc475 net217 net405 net298 net409 net274 net283 VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__mux4_4
Xc486 net41 net1057 net181 net293 net978 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__a41oi_2
XTAP_TAPCELL_ROW_82_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge930 clknet_4_3_0_clk net715 net789 VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__edfxtp_1
XFILLER_0_7_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c564_S0 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c222_A1 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c179_B net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net452 clknet_0_net452 VGND VGND VPWR VPWR clknet_1_0__leaf_net452
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net474 clknet_0_net474 VGND VGND VPWR VPWR clknet_1_0__leaf_net474
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net463 clknet_0_net463 VGND VGND VPWR VPWR clknet_1_0__leaf_net463
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_34_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c301_Y net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge843_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c413_A0 net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c193_S1 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_s945_GATE_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc250 clknet_4_15_0_clk net195 net1093 net179 clknet_1_0__leaf_net194 VGND VGND VPWR
+ VPWR net1021 net198 sky130_fd_sc_hd__sdfrbp_1
Xc261 net1097 net207 net1011 net1082 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__a31o_1
Xc272 net788 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__buf_6
Xc294 net118 net767 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__xor2_4
Xc283 net788 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__inv_4
XANTENNA_c384_S0 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c696_A2 net594 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge771 net23 net20 net12 net1109 VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__a31oi_1
Xmerge782 net285 net281 net292 net293 net295 net1055 VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__mux4_1
XFILLER_0_7_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge793 net497 clknet_1_0__leaf_net230 clknet_1_0__leaf_net270 clknet_1_0__leaf_net289
+ net521 net983 VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__mux4_4
XFILLER_0_15_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c278_S1 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c296_B net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge801_A2 net561 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold28 net862 VGND VGND VPWR VPWR net1096 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 net203 VGND VGND VPWR VPWR net1085 sky130_fd_sc_hd__dlygate4sd3_1
Xhold39 net1008 VGND VGND VPWR VPWR net1107 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c349_Y net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c87_S0 net32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output98_A net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_90_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net995 clknet_0_net995 VGND VGND VPWR VPWR clknet_1_1__leaf_net995
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c561_S1 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s991_GATE_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge812_A1 net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c459_X net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net1019 net1019 VGND VGND VPWR VPWR clknet_0_net1019 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_39_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net258 clknet_0_net258 VGND VGND VPWR VPWR clknet_1_1__leaf_net258
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net247 clknet_0_net247 VGND VGND VPWR VPWR clknet_1_1__leaf_net247
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_hold38_A net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c230_A1 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c587_A4 clknet_1_0__leaf_net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c154_A net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge807_A1 net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net415 net415 VGND VGND VPWR VPWR clknet_0_net415 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c324_SCE net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout122_X net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c576_X net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c497_A4 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c123_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input52_X net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c567_S0 net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c488_D net165 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c271_A net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_7_0_clk_X clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_A3 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c119_A2 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net267 net267 VGND VGND VPWR VPWR clknet_0_net267 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net289 net289 VGND VGND VPWR VPWR clknet_0_net289 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc613 net532 net397 net522 net536 clknet_1_0__leaf_net535 net897 VGND VGND VPWR VPWR
+ net537 sky130_fd_sc_hd__mux4_2
Xc602 net838 VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__clkbuf_1
Xc635 net1062 net978 net1035 net1057 clknet_1_0__leaf_net827 net1028 VGND VGND VPWR
+ VPWR net1012 sky130_fd_sc_hd__mux4_4
Xc624 net507 net428 net941 clknet_1_1__leaf_net535 clknet_1_0__leaf_net995 net781
+ VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__mux4_4
Xc679 net570 net571 net574 clknet_1_0__leaf_net576 net338 net1037 VGND VGND VPWR VPWR
+ net581 sky130_fd_sc_hd__mux4_1
Xc668 net341 clknet_1_0__leaf_net566 clknet_1_0__leaf_net565 VGND VGND VPWR VPWR net569
+ sky130_fd_sc_hd__o21bai_2
XANTENNA_input12_A in19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output80_A net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net623 clknet_0_net623 VGND VGND VPWR VPWR clknet_1_0__leaf_net623
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_clkbuf_0_net147_A net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input4_A in11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c660_B net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s978_GATE clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c760_S0 net1052 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c489_RESET_B net1080 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc410 net922 VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__clkbuf_2
Xc421 net945 net227 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__xnor2_1
Xc432 net213 net347 clknet_1_1__leaf_net367 net1036 net364 net954 VGND VGND VPWR VPWR
+ net370 sky130_fd_sc_hd__mux4_1
Xc454 net261 net387 net390 clknet_1_1__leaf_net388 net1034 VGND VGND VPWR VPWR net392
+ sky130_fd_sc_hd__a41o_4
Xc443 net971 net1044 clknet_1_0__leaf_net990 net1032 net877 VGND VGND VPWR VPWR net382
+ sky130_fd_sc_hd__a41o_1
XFILLER_0_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc465 net835 VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__dlygate4sd3_1
Xc487 net42 net414 clknet_1_0__leaf_net374 net181 net416 VGND VGND VPWR VPWR net425
+ sky130_fd_sc_hd__a41o_4
Xc476 net167 net405 net1046 clknet_1_1__leaf_net867 VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__a31o_4
Xc498 net181 net1034 net958 net848 VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__a31o_1
XFILLER_0_35_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge931 clknet_4_8_0_clk net790 net802 VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__sdlclkp_1
Xmerge920 net784 clknet_4_11_0_clk net775 VGND VGND VPWR VPWR net1015 net1018 sky130_fd_sc_hd__dlrbn_1
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c693_SCD net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c206_A3 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c58_B1_N net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net464 clknet_0_net464 VGND VGND VPWR VPWR clknet_1_0__leaf_net464
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net453 clknet_0_net453 VGND VGND VPWR VPWR clknet_1_0__leaf_net453
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c739_S1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c755_S0 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input7_X net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc262 net981 net195 net202 net184 clknet_1_1__leaf_net194 net816 VGND VGND VPWR VPWR
+ net211 sky130_fd_sc_hd__mux4_2
Xc251 net197 net196 net72 net175 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__a31oi_1
Xc240 clknet_1_0__leaf_net183 net186 net187 net1060 net771 net868 VGND VGND VPWR VPWR
+ net190 sky130_fd_sc_hd__mux4_2
XANTENNA_clkbuf_4_15_0_clk_X clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc295 net242 net236 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__xnor2_4
Xc284 clknet_1_0__leaf_net1025 net231 net228 net213 net101 net874 VGND VGND VPWR VPWR
+ net232 sky130_fd_sc_hd__mux4_1
Xc273 net921 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_46_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge772 net217 net26 net284 net748 net1084 VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__a41o_1
Xmerge794 net20 net21 net157 net159 VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__a31oi_1
Xmerge783 net244 net938 clknet_1_0__leaf_net247 net770 VGND VGND VPWR VPWR net691
+ sky130_fd_sc_hd__a31oi_1
XFILLER_0_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c710_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_net381_A net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold29 net1021 VGND VGND VPWR VPWR net1097 sky130_fd_sc_hd__dlygate4sd3_1
Xhold18 net1006 VGND VGND VPWR VPWR net1086 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_merge893_GATE clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge795_D net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net429 clknet_0_net429 VGND VGND VPWR VPWR clknet_1_1__leaf_net429
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_90_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c334_B1 net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c203_A4 net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout112_A net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge812_A2 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c244_B1 clknet_1_1__leaf_net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c399_A net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_76_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input42_A in46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c601_A1 clknet_1_1__leaf_net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c320_A2 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s982_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c314_A net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_3_0_clk_X clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout115_X net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge823_A1 net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c683_A net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c62_Y net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input45_X net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net827 clknet_0_net827 VGND VGND VPWR VPWR clknet_1_0__leaf_net827
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_s964_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c264_A net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s955_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net235 net235 VGND VGND VPWR VPWR clknet_0_net235 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c119_A3 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c758_S0 net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc603 net526 net1040 net273 net1030 net889 net896 VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__mux4_2
XFILLER_0_32_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc625 net522 net991 net182 net1038 clknet_1_1__leaf_net860 clknet_1_0__leaf_net987
+ VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__mux4_4
Xc614 net403 clknet_1_0__leaf_net534 net273 clknet_1_0__leaf_net535 net536 VGND VGND
+ VPWR VPWR net538 sky130_fd_sc_hd__a41oi_4
Xc636 net420 net313 net507 clknet_1_1__leaf_net827 clknet_1_1__leaf_net867 net898
+ VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__mux4_1
Xc669 net928 VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__inv_1
XANTENNA_c432_A0 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c326_A1 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_output73_A net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s937_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c427_A0 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc411 net787 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__buf_1
Xc400 net229 net221 VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__xor2_2
Xc422 net811 VGND VGND VPWR VPWR net984 sky130_fd_sc_hd__buf_4
Xc444 net965 clknet_1_1__leaf_net381 VGND VGND VPWR VPWR net1014 sky130_fd_sc_hd__xnor2_1
Xc433 clknet_1_1__leaf_net365 net974 net748 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__mux2_8
Xc455 net378 net384 clknet_1_1__leaf_net1003 net217 net389 net886 VGND VGND VPWR VPWR
+ net393 sky130_fd_sc_hd__mux4_2
XPHY_EDGE_ROW_8_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc466 net813 VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__inv_2
Xc477 clknet_4_9_0_clk net284 clknet_1_1__leaf_net230 net400 net404 net1063 VGND VGND
+ VPWR VPWR net414 net413 sky130_fd_sc_hd__sdfbbn_1
Xc488 clknet_4_12_0_clk net165 clknet_1_0__leaf_net425 net1034 net422 net1032 VGND
+ VGND VPWR VPWR net991 net426 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc499 net317 clknet_1_1__leaf_net429 net980 net434 net431 net801 VGND VGND VPWR VPWR
+ net440 sky130_fd_sc_hd__mux4_4
XFILLER_0_99_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge910 clknet_4_9_0_clk net747 net680 VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__dfrtn_1
Xmerge921 net739 clknet_4_14_0_clk net676 VGND VGND VPWR VPWR net848 net847 sky130_fd_sc_hd__dlrbp_2
XANTENNA_clkbuf_4_11_0_clk_X clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c337_A0 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c693_SCE net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c503_A2 net165 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_504 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net454 clknet_0_net454 VGND VGND VPWR VPWR clknet_1_0__leaf_net454
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge815_A2 net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c401_B clknet_1_1__leaf_net335 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c413_A2 net349 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c281_SET_B net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c274_B1_N net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc230 net172 net5 net1056 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__mux2_4
XTAP_TAPCELL_ROW_79_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc263 net198 net79 net202 net1017 net816 net864 VGND VGND VPWR VPWR net1016 sky130_fd_sc_hd__mux4_2
Xc252 net175 net1021 net193 net196 net863 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__a41oi_2
Xc241 net189 net53 clknet_1_1__leaf_net183 net180 net974 net187 VGND VGND VPWR VPWR
+ net191 sky130_fd_sc_hd__mux4_1
Xc296 net241 net930 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__xnor2_1
Xc285 net229 net231 net770 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__o21ba_2
Xc274 net1068 net102 net221 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__a21boi_1
XFILLER_0_46_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c696_A4 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge773 clknet_1_1__leaf_net147 net53 net57 net281 VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__a31oi_2
XFILLER_0_7_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge784 net64 net69 net82 clknet_1_0__leaf_net194 net193 VGND VGND VPWR VPWR net692
+ sky130_fd_sc_hd__a41oi_2
XFILLER_0_28_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge795 clknet_4_4_0_clk net103 net214 net338 net1031 VGND VGND VPWR VPWR net703
+ sky130_fd_sc_hd__sdfrtn_1
XFILLER_0_70_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold19 net868 VGND VGND VPWR VPWR net1087 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_0_net374_A net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c184_B net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c728_D net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net262 clknet_0_net262 VGND VGND VPWR VPWR clknet_1_0__leaf_net262
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c132_X net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c127_A3 net32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net419 clknet_0_net419 VGND VGND VPWR VPWR clknet_1_1__leaf_net419
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_98_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c85_X net32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c318_A2 clknet_1_0__leaf_net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_90_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c334_A1 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net920 clknet_0_net920 VGND VGND VPWR VPWR clknet_1_1__leaf_net920
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_79_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c228_A2 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s958_Q_N net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c399_B net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c53_B1 net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c462_B1_N net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input35_A in4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c601_A2 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge823_A2 net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c702_A1 net593 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_17_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net995 net995 VGND VGND VPWR VPWR clknet_0_net995 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c612_A1 net507 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net828 clknet_0_net828 VGND VGND VPWR VPWR clknet_1_0__leaf_net828
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_35_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge882_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_1__f_net1025_X clknet_1_1__leaf_net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c264_B net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net247 net247 VGND VGND VPWR VPWR clknet_0_net247 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net258 net258 VGND VGND VPWR VPWR clknet_0_net258 sky130_fd_sc_hd__clkbuf_16
XANTENNA_clkbuf_0_net990_A net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_0__f_net1014_X clknet_1_0__leaf_net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_62_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc604 clknet_1_1__leaf_net463 clknet_1_0__leaf_net419 net1032 net521 net1022 net1030
+ VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__mux4_1
XANTENNA_c416_A2 net336 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc615 net274 net256 net397 net988 net859 VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__a41o_1
Xc626 net499 net446 net182 net1045 net1057 net1053 VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__mux4_1
Xc637 net1065 net559 clknet_1_1__leaf_net412 net824 net898 clknet_1_0__leaf_net987
+ VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_73_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c713_B1 net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c432_A1 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_80_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge864_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge921_GATE clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output66_A net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net647 clknet_0_net647 VGND VGND VPWR VPWR clknet_1_0__leaf_net647
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c708_B1 clknet_1_0__leaf_net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c146_A2 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge846_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc412 net350 clknet_1_0__leaf_net342 net348 net338 clknet_1_1__leaf_net335 net1031
+ VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__mux4_1
Xc401 net220 clknet_1_1__leaf_net335 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__xor2_1
Xc423 net799 VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__inv_4
XANTENNA_c61_B1 net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc434 net224 net756 VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__xnor2_1
Xc445 net932 net268 net252 VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__o21ba_1
Xc456 net779 VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__buf_1
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc467 net812 VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__inv_6
Xc478 net406 net1058 clknet_1_0__leaf_net412 net1044 net889 VGND VGND VPWR VPWR net415
+ sky130_fd_sc_hd__a41o_2
XANTENNA_c443_B1 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c162_A1 net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c579_RESET_B net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc489 clknet_4_11_0_clk net310 net1080 net1041 net426 clknet_1_1__leaf_net990 VGND
+ VGND VPWR VPWR net428 net427 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_35_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge911 clknet_4_13_0_clk net153 net696 VGND VGND VPWR VPWR net836 sky130_fd_sc_hd__dfrtp_2
Xmerge900 net648 net636 VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__xor2_4
Xmerge922 net678 clknet_4_8_0_clk net807 VGND VGND VPWR VPWR net850 net849 sky130_fd_sc_hd__dlrbp_1
XFILLER_0_51_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c679_S0 net338 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c227_B clknet_1_0__leaf_net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c589_S0 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge815_A3 net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout135_A net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c413_A3 net336 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_582 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc220 net1060 net1040 net50 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_79_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc253 net50 net70 net864 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__mux2_1
Xc242 net187 net864 net869 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__a21o_1
Xc231 net803 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__buf_2
XANTENNA_c604_A2 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc286 net110 clknet_1_0__leaf_net1025 net1061 net814 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__a31oi_1
Xc297 net101 net233 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__xnor2_1
Xc264 net935 net83 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__xnor2_1
Xc275 net926 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__clkbuf_4
XANTENNA_input20_X net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A1 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge763 net87 net112 net90 net106 VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__a31o_1
XFILLER_0_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge796 net942 net101 net97 net111 net109 net1036 VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__mux4_1
Xmerge785 net131 net965 net238 net248 net260 net1061 VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_31_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge774 net336 net1038 net495 clknet_1_0__leaf_net270 VGND VGND VPWR VPWR net682
+ sky130_fd_sc_hd__a31o_2
XFILLER_0_43_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput1 in0 VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_36_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_39_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net230 clknet_0_net230 VGND VGND VPWR VPWR clknet_1_0__leaf_net230
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_34_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c721_A0 net578 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c168_B1 net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c153_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c615_A1 net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_90_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c281_SCD net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net987 clknet_0_net987 VGND VGND VPWR VPWR clknet_1_1__leaf_net987
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_36_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s947_Q net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c451_B1 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input28_A in33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c601_A3 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s958_GATE clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c329_A2 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c626_A0 net499 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output96_A net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c254_SCD net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0_net429 net429 VGND VGND VPWR VPWR clknet_0_net429 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge823_A3 net570 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c702_A2 clknet_1_0__leaf_net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c300_S0 net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c484_SCD net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c241_A3 net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s957_GATE_N clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c416_A3 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc627 net182 clknet_1_1__leaf_net990 net1040 c627/A3 clknet_1_0__leaf_net867 clknet_1_1__leaf_net987
+ VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__mux4_1
Xc616 clknet_1_1__leaf_net535 net448 clknet_1_0__leaf_net321 clknet_1_1__leaf_net990
+ net999 net1027 VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__mux4_1
Xc605 net274 clknet_1_1__leaf_net990 net897 VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__a21boi_0
XTAP_TAPCELL_ROW_73_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c59_B1 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_51_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net1025_X clknet_0_net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input50_X net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output59_A clknet_1_1__leaf_net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c568_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c236_A3 net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_hold39_X net1107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c541_B clknet_1_0__leaf_net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c155_X net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c534_A net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c559_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c701_A net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c427_A2 clknet_1_0__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge877_CLK_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c691_X net593 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc402 net833 VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__clkbuf_2
Xc413 net974 net343 net349 net336 net1031 net757 VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__mux4_1
Xc424 clknet_1_0__leaf_net339 clknet_1_1__leaf_net235 net1074 VGND VGND VPWR VPWR
+ net361 sky130_fd_sc_hd__a21o_1
Xc435 clknet_1_0__leaf_net786 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__buf_12
XANTENNA_c443_A1 net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc446 net834 VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__buf_1
Xc468 net792 VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__inv_1
Xc457 clknet_1_0__leaf_net391 net389 clknet_1_0__leaf_net388 net1032 net808 net887
+ VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__mux4_1
Xc479 clknet_4_9_0_clk net410 net400 net409 net413 clknet_1_0__leaf_net399 VGND VGND
+ VPWR VPWR net993 net416 sky130_fd_sc_hd__sdfbbn_2
XANTENNA_merge814_X net722 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input10_A in17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge912 clknet_4_10_0_clk net804 net665 VGND VGND VPWR VPWR net1028 sky130_fd_sc_hd__dfrtp_2
Xmerge901 clknet_4_10_0_clk net557 net637 VGND VGND VPWR VPWR net824 net823 sky130_fd_sc_hd__edfxbp_1
Xmerge923 net682 clknet_4_3_0_clk net742 VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__dlrtn_1
XFILLER_0_55_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c679_S1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c618_A1 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s940_GATE_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c634_A0 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net412 clknet_0_net412 VGND VGND VPWR VPWR clknet_1_0__leaf_net412
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net456 clknet_0_net456 VGND VGND VPWR VPWR clknet_1_0__leaf_net456
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c589_S1 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_62_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c247_A2 net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout128_A net1107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input2_A in1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_s977_Q net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net990 clknet_0_net990 VGND VGND VPWR VPWR clknet_1_0__leaf_net990
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc210 net794 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__inv_4
XTAP_TAPCELL_ROW_79_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c454_B1 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc221 net847 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__inv_8
Xc254 clknet_4_15_0_clk net82 net193 net50 net201 net986 VGND VGND VPWR VPWR net998
+ net202 sky130_fd_sc_hd__sdfbbn_1
Xc243 net5 net160 net1050 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__a21o_2
Xc232 net148 net175 net176 net869 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__a31o_2
XFILLER_0_20_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc265 net95 net212 net932 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__a21o_2
Xc287 net223 clknet_1_0__leaf_net866 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__xnor2_1
Xc276 net217 net215 net223 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__o21ai_4
Xc298 net766 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_5_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A2 net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input13_X net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c348_A1 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge764 net273 net26 net525 net403 clknet_1_1__leaf_net398 net1081 VGND VGND VPWR
+ VPWR net671 sky130_fd_sc_hd__mux4_4
Xmerge797 net158 net30 net960 net8 VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__a31oi_1
Xmerge775 net28 net1041 net14 net26 VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__a31o_1
Xmerge786 net940 net97 net87 net96 VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_31_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput2 in1 VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_39_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge826_A3 net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c615_A2 net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c334_A3 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net900 clknet_0_net900 VGND VGND VPWR VPWR clknet_1_1__leaf_net900
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c733_D net485 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s985_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c53_A2 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c732_A0 net594 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c451_A1 net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_87_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c355_SET_B clknet_1_1__leaf_net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c626_A1 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c345_A2 net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge920_Q net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s967_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net419 net419 VGND VGND VPWR VPWR clknet_0_net419 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_56_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_8_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c202_B net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c552_B1 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c702_A3 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc270_1 clknet_1_0__leaf_net786 VGND VGND VPWR VPWR net1064 sky130_fd_sc_hd__inv_8
XANTENNA_c64_A1 net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net920 net920 VGND VGND VPWR VPWR clknet_0_net920 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c727_A0 clknet_1_1__leaf_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c80_B1 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input40_A in44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c292_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s949_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge803_S0 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net582 clknet_0_net582 VGND VGND VPWR VPWR clknet_1_1__leaf_net582
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout113_X net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc606 net523 net499 net522 clknet_1_0__leaf_net381 clknet_1_1__leaf_net990 net1062
+ VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__mux4_1
Xc628 net451 net186 net1040 net991 net427 net898 VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__mux4_1
Xc617 net979 net1066 net282 net445 net416 net422 VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_73_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c713_A2 net578 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c432_A3 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c192_B1 net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c623_A2 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input43_X net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net616 clknet_0_net616 VGND VGND VPWR VPWR clknet_1_0__leaf_net616
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_98_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c236_A4 net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c427_A3 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c724_A1 net578 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc403 clknet_1_0__leaf_net920 VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_32_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c61_A2 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc414 clknet_4_1_0_clk net349 net348 net1031 clknet_1_0__leaf_net880 VGND VGND VPWR
+ VPWR net353 sky130_fd_sc_hd__sdfrtp_4
Xc436 clknet_1_1__leaf_net373 net252 VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__xnor2_2
Xc425 clknet_1_0__leaf_net235 net1056 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__xor2_4
Xc469 net973 net1008 net1054 VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__o21ba_1
Xc458 net368 net390 net387 net379 net261 net887 VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__mux4_1
Xc447 clknet_1_1__leaf_net381 net754 net1054 VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__a21o_4
XANTENNA_c443_A2 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c740_A0 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c306_S0 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge902 net646 net660 VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__xor2_2
Xmerge913 clknet_4_10_0_clk net654 net433 VGND VGND VPWR VPWR net837 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_95_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge924 net701 clknet_4_9_0_clk net829 VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__dlrtn_1
XFILLER_0_82_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c618_A2 net499 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c337_A3 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output71_A net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap126_X net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c265_X net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge895_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_81_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c670_RESET_B clknet_1_0__leaf_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_59_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c324_CLK_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c454_A1 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc211 net826 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__inv_6
Xc200 net803 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__buf_1
Xc244 net64 net187 net69 clknet_1_1__leaf_net867 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__a31o_4
Xc233 net177 net955 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__xor2_2
Xc222 net963 net48 net972 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__a21boi_1
XPHY_EDGE_ROW_68_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc288 net116 net1061 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__xor2_4
Xc255 clknet_4_15_0_clk net184 net201 net1098 net64 net185 VGND VGND VPWR VPWR net204
+ net203 sky130_fd_sc_hd__sdfbbn_1
Xc266 net99 net95 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__xor2_4
Xc277 net215 net102 clknet_1_1__leaf_net222 net221 net213 net97 VGND VGND VPWR VPWR
+ net225 sky130_fd_sc_hd__mux4_1
Xc299 net245 net241 net1058 clknet_1_0__leaf_net1025 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__a31o_4
XFILLER_0_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_5_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A3 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge766_A1 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c629_A1 net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c348_A2 net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge776 net794 VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__buf_4
Xmerge787 net294 net397 net402 net298 net748 net1104 VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__mux4_1
Xmerge765 net840 VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__buf_1
Xmerge798 net238 clknet_1_1__leaf_net371 net1034 net835 net885 net888 VGND VGND VPWR
+ VPWR net706 sky130_fd_sc_hd__mux4_4
XFILLER_0_70_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_net999_2_A clknet_1_1__leaf_net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 in10 VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_39_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net276 clknet_0_net276 VGND VGND VPWR VPWR clknet_1_0__leaf_net276
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c225_A net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c705_A3 net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c364_RESET_B net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c615_A3 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_4_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c732_A1 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c90_Y net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c195_B1 clknet_1_0__leaf_net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c626_A2 net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge913_Q net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net786 clknet_0_net786 VGND VGND VPWR VPWR clknet_1_1__leaf_net786
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput50 in7 VGND VGND VPWR VPWR net978 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_12_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout103_A net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c477_SET_B net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c178_X net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c352_Y net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c345_X net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c727_A1 clknet_1_0__leaf_net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net987 net987 VGND VGND VPWR VPWR clknet_0_net987 sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge876_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c743_A0 clknet_1_1__leaf_net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input33_A in38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net1023 clknet_0_net1023 VGND VGND VPWR VPWR clknet_1_1__leaf_net1023
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_18_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge774_A1 net336 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge790_B1 net336 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s939_GCLK net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_22_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c138_A net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc607 clknet_4_3_0_clk net26 clknet_1_0__leaf_net530 net521 net1058 net1081 VGND VGND
+ VPWR VPWR net532 net531 sky130_fd_sc_hd__sdfbbn_1
Xc618 clknet_1_0__leaf_net534 net1062 net499 clknet_1_1__leaf_net990 net447 net890
+ VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__mux4_2
XANTENNA_fanout106_X net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc629 net414 net991 net322 clknet_1_1__leaf_net398 net447 clknet_1_0__leaf_net987
+ VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__mux4_2
XANTENNA_c282_A1 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_40_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_23_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c91_B1 net32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge849_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c307_SET_B net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_12_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input36_X net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge769_A1 net580 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net617 clknet_0_net617 VGND VGND VPWR VPWR clknet_1_0__leaf_net617
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c383_A0 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net1023_X clknet_1_1__leaf_net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net391 clknet_0_net391 VGND VGND VPWR VPWR clknet_1_1__leaf_net391
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c558_A0 net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c277_A1 net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c412_S0 clknet_1_1__leaf_net335 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c131_S1 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c724_A2 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c61_A3 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc404 net854 VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__clkbuf_2
Xc415 clknet_1_0__leaf_net340 net341 net348 net353 net1031 VGND VGND VPWR VPWR net354
+ sky130_fd_sc_hd__a41o_2
Xc426 clknet_4_4_0_clk net359 clknet_1_0__leaf_net362 net252 net1031 VGND VGND VPWR
+ VPWR net364 net363 sky130_fd_sc_hd__sdfsbp_2
Xc437 clknet_1_0__leaf_net365 clknet_1_0__leaf_net373 net363 VGND VGND VPWR VPWR net375
+ sky130_fd_sc_hd__a21o_2
XANTENNA_merge855_GATE_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc459 net390 net252 net368 net885 net887 net888 VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__mux4_2
XANTENNA_c443_A3 clknet_1_0__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc448 net935 clknet_1_1__leaf_net385 net261 clknet_1_1__leaf_net270 net1034 net876
+ VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_28_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge903 clknet_4_13_0_clk net720 net725 VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__edfxtp_1
XFILLER_0_95_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge925 net653 clknet_4_10_0_clk net783 VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__dlrtn_1
Xmerge914 clknet_4_12_0_clk net729 net671 VGND VGND VPWR VPWR net839 net838 sky130_fd_sc_hd__dfsbp_2
XANTENNA_c618_A3 clknet_1_1__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c634_A2 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap119_X net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net425 clknet_0_net425 VGND VGND VPWR VPWR clknet_1_0__leaf_net425
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net458 clknet_0_net458 VGND VGND VPWR VPWR clknet_1_0__leaf_net458
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net992 clknet_0_net992 VGND VGND VPWR VPWR clknet_1_0__leaf_net992
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c735_A1 clknet_1_0__leaf_net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc201 net31 net964 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__xnor2_2
Xc212 net778 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_79_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc234 net36 net159 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__xor2_2
Xc245 net187 net979 net80 net863 VGND VGND VPWR VPWR net981 sky130_fd_sc_hd__a31o_1
Xc223 net847 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__inv_4
Xc256 net160 net204 net79 net196 net82 net869 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__mux4_1
Xc267 net770 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__inv_6
Xc278 net212 net214 net220 net936 net1067 net217 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__mux4_1
Xc289 net955 net946 net1056 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__o21a_2
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c348_A3 net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge788 net53 net165 net133 net47 VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__a31oi_1
XANTENNA_merge782_A1 net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge777 net1031 clknet_1_0__leaf_net458 clknet_1_0__leaf_net452 clknet_1_0__leaf_net880
+ VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__a31o_4
Xmerge766 net1036 net358 clknet_1_0__leaf_net365 net756 VGND VGND VPWR VPWR net673
+ sky130_fd_sc_hd__a31oi_4
Xmerge799 net119 net977 net110 net124 net115 net1048 VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__mux4_1
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput4 in11 VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_67_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net222 clknet_0_net222 VGND VGND VPWR VPWR clknet_1_0__leaf_net222
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout133_A net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_0_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c555_A1 net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c274_A2 net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_5_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c721_A3 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c746_A0 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c615_A4 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c631_A3 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge853_GATE clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge777_A1 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_64_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge806_S1 net338 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_87_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c53_A4 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c732_A2 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_87_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c476_B1 clknet_1_1__leaf_net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_363 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c626_A3 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput40 in44 VGND VGND VPWR VPWR net968 sky130_fd_sc_hd__buf_1
XFILLER_0_31_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput51 in8 VGND VGND VPWR VPWR net979 sky130_fd_sc_hd__clkbuf_8
XANTENNA_merge817_S0 net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c552_A2 net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net900 net900 VGND VGND VPWR VPWR clknet_0_net900 sky130_fd_sc_hd__clkbuf_16
XANTENNA_s945_Q net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c64_A3 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c727_A2 clknet_1_1__leaf_net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c462_A2 clknet_1_0__leaf_net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c364_Q net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input26_A in31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c325_S0 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge774_A2 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output94_A net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net562 clknet_0_net562 VGND VGND VPWR VPWR clknet_1_1__leaf_net562
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_0_net230_A net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c138_B net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c563_A1 net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc619 net1058 net999 clknet_1_0__leaf_net535 net1035 net994 net1053 VGND VGND VPWR
+ VPWR net543 sky130_fd_sc_hd__mux4_1
Xc608 clknet_1_1__leaf_net530 net522 net1045 clknet_1_0__leaf_net867 net897 VGND VGND
+ VPWR VPWR net533 sky130_fd_sc_hd__a41oi_4
XFILLER_0_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c59_A3 net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c75_A2 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c738_A1 net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c91_A1 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c355_RESET_B net165 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge785_A1 net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c502_S1 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge814_S1 net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net381 clknet_0_net381 VGND VGND VPWR VPWR clknet_1_1__leaf_net381
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c558_A1 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c412_S1 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c716_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c210_Y net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc405 net854 VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__buf_2
Xc416 clknet_1_0__leaf_net335 net353 net336 net83 net757 clknet_1_1__leaf_net880 VGND
+ VGND VPWR VPWR net355 sky130_fd_sc_hd__mux4_1
Xc427 net945 net1074 clknet_1_0__leaf_net990 net363 net820 net997 VGND VGND VPWR VPWR
+ net365 sky130_fd_sc_hd__mux4_2
Xc449 net808 VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__inv_2
XANTENNA_c443_A4 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge767_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c749_A0 clknet_1_1__leaf_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge904 clknet_4_10_0_clk net556 net550 VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__sdlclkp_1
Xmerge926 net689 clknet_4_5_0_clk net708 VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__dlrtp_2
Xmerge915 clknet_4_9_0_clk net760 net722 VGND VGND VPWR VPWR net841 net840 sky130_fd_sc_hd__dfsbp_2
XFILLER_0_67_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net582 net582 VGND VGND VPWR VPWR clknet_0_net582 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_50_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output57_A net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net415 clknet_0_net415 VGND VGND VPWR VPWR clknet_1_0__leaf_net415
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge930_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c484_D net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c569_A0 net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c719_A3 net606 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc202 net100 net1056 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_79_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc213 net162 net161 net158 net1020 net14 net836 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__mux4_4
Xc235 net6 net148 net175 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__mux2_1
Xc224 net836 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_92_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc257 net185 net196 net204 net184 net1050 net872 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__mux4_1
Xc246 net80 net193 net974 net171 VGND VGND VPWR VPWR net1000 sky130_fd_sc_hd__a31o_2
Xc268 net770 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__inv_6
XFILLER_0_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c751_A1 net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc279 net223 net875 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__xor2_4
XFILLER_0_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c629_A3 clknet_1_1__leaf_net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_523 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge778 net97 net99 net212 net214 VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__a31o_1
Xmerge767 clknet_4_0_0_clk net1037 net563 net574 clknet_1_0__leaf_net562 VGND VGND
+ VPWR VPWR net675 net674 sky130_fd_sc_hd__sdfrbp_1
XFILLER_0_24_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge789 clknet_1_1__leaf_net458 net941 clknet_1_0__leaf_net462 net465 VGND VGND
+ VPWR VPWR net697 sky130_fd_sc_hd__a31o_2
XFILLER_0_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap131_X net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput5 in12 VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_78_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net267 clknet_0_net267 VGND VGND VPWR VPWR clknet_1_0__leaf_net267
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net289 clknet_0_net289 VGND VGND VPWR VPWR clknet_1_0__leaf_net289
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge903_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c113_A net672 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net565_X clknet_0_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c299_B1 clknet_1_0__leaf_net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c762_A0 clknet_1_0__leaf_net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c481_A1 net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c328_S0 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input11_X net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge793_A1 clknet_1_0__leaf_net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge822_S1 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c732_A3 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input3_X net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c757_A0 clknet_1_0__leaf_net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_84_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c386_A1 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput30 in35 VGND VGND VPWR VPWR net958 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput41 in45 VGND VGND VPWR VPWR net969 sky130_fd_sc_hd__buf_2
XFILLER_0_12_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput52 in9 VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_52_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c552_A3 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c743_A2 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c606_S0 clknet_1_1__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net1003 clknet_0_net1003 VGND VGND VPWR VPWR clknet_1_1__leaf_net1003
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_input19_A in25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c325_S1 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net1014 clknet_0_net1014 VGND VGND VPWR VPWR clknet_1_1__leaf_net1014
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net1025 clknet_0_net1025 VGND VGND VPWR VPWR clknet_1_1__leaf_net1025
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_18_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge790_A2 net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output87_A net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c445_B1_N net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net530 clknet_0_net530 VGND VGND VPWR VPWR clknet_1_1__leaf_net530
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c563_A2 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc609 net852 VGND VGND VPWR VPWR net988 sky130_fd_sc_hd__inv_2
XFILLER_0_12_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_84_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c318_B1_N clknet_1_0__leaf_net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c738_A2 net536 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c457_A3 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c754_A1 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c91_A2 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net786 net786 VGND VGND VPWR VPWR clknet_0_net786 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge785_A2 net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net371 clknet_0_net371 VGND VGND VPWR VPWR clknet_1_1__leaf_net371
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c277_A3 net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc417 net341 net353 net345 net213 clknet_1_1__leaf_net880 clknet_1_0__leaf_net881
+ VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__mux4_4
Xc406 net703 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__dlygate4sd3_1
Xc428 net364 clknet_1_0__leaf_net866 VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__xor2_1
XFILLER_0_13_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc439 clknet_1_1__leaf_net362 clknet_1_1__leaf_net375 net1070 clknet_1_1__leaf_net366
+ net364 net820 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__mux4_1
XANTENNA_c398_X net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c740_A3 net593 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c749_A1 net606 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge927 net644 clknet_4_8_0_clk net658 VGND VGND VPWR VPWR net855 sky130_fd_sc_hd__dlrtp_1
Xmerge905 clknet_4_10_0_clk net551 net659 VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__sdlclkp_2
Xmerge916 clknet_4_8_0_clk net677 net825 VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__dfstp_2
XFILLER_0_36_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c394_A1 net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_19_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge795_RESET_B net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c532_B net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c719_A4 net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c735_A3 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_28_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc203 net21 net26 net961 net152 net1034 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__a41oi_1
Xc214 net798 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__buf_6
Xc225 net1059 net759 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__xnor2_4
Xc236 net159 net35 net180 net166 net175 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__a41oi_4
XTAP_TAPCELL_ROW_79_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_92_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc247 net171 net160 net175 net64 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__a31o_1
Xc258 clknet_4_14_0_clk net201 net1085 net819 net873 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__sdfrtn_1
Xc269 net963 net216 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_69_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge779 net929 net12 net1043 net14 VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__a31oi_1
Xmerge768 net170 net1060 net964 net94 VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__a31oi_2
XANTENNA_merge782_A3 net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge927_GATE clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net391 net391 VGND VGND VPWR VPWR clknet_0_net391 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_max_cap124_X net1052 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput6 in13 VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__dlymetal6s2s_1
XANTENNA_c389_A1 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net235 clknet_0_net235 VGND VGND VPWR VPWR clknet_1_0__leaf_net235
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c594_D net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c571_A2 net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge795_SCD net338 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c481_A2 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input49_A in6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge879_Q net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c607_D net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net1025_A clknet_0_net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_87_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s975_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge879_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c339_S0 clknet_1_1__leaf_net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge788_A2 net165 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c386_A2 clknet_1_1__leaf_net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput20 in26 VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__buf_2
Xinput31 in36 VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__buf_1
XFILLER_0_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput42 in46 VGND VGND VPWR VPWR net970 sky130_fd_sc_hd__buf_2
XFILLER_0_71_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c505_CLK_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold12_X net1080 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c173_A net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c577_A1 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c431_S1 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c743_A3 clknet_1_1__leaf_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c595_X net519 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c606_S1 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c622_S0 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge790_A3 net349 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge799_A1 net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net597 clknet_0_net597 VGND VGND VPWR VPWR clknet_1_1__leaf_net597
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net586 clknet_0_net586 VGND VGND VPWR VPWR clknet_1_1__leaf_net586
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c678_A0 net568 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge828_S1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c290_A net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_84_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s950_Q net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_90_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c754_A2 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input31_A in36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c383_A3 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net361 clknet_0_net361 VGND VGND VPWR VPWR clknet_1_1__leaf_net361
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c255_D net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c408_B net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net1023 clknet_0_net1023 VGND VGND VPWR VPWR clknet_1_0__leaf_net1023
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc418 net343 net252 VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__xor2_1
Xc407 net345 net224 net875 VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__o21ai_0
XFILLER_0_13_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout104_X net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc429 clknet_1_1__leaf_net361 net1044 net364 net945 VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__a31o_1
XANTENNA_c460_X net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c749_A2 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge917 clknet_4_13_0_clk net705 net681 VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__dfstp_4
Xmerge928 net697 clknet_4_1_0_clk net791 VGND VGND VPWR VPWR net856 sky130_fd_sc_hd__dlrtp_2
Xmerge906 net552 net553 VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__xnor2_1
Xclkbuf_0_net562 net562 VGND VGND VPWR VPWR clknet_0_net562 sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge890_GATE_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input34_X net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c394_A2 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c257_S0 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c569_A2 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_81_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net995 clknet_0_net995 VGND VGND VPWR VPWR clknet_1_0__leaf_net995
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c585_A1 net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c420_A net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc204 net961 net957 net94 net955 net1013 net152 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__mux4_4
Xc215 net151 net152 net869 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__a21boi_4
XTAP_TAPCELL_ROW_79_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc226 net854 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__inv_4
XFILLER_0_60_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc237 net1043 net179 net155 net159 net171 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__a41o_2
Xc259 net199 net201 net197 net82 net203 net207 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__mux4_4
Xc248 net816 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__inv_2
XFILLER_0_13_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c751_A3 net606 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge769 net580 clknet_1_0__leaf_net454 clknet_1_0__leaf_net481 clknet_1_1__leaf_net566
+ net490 VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__a41oi_2
XANTENNA_c630_S0 net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net381 net381 VGND VGND VPWR VPWR clknet_0_net381 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc760 net1045 net980 net606 clknet_1_0__leaf_net828 net1052 net918 VGND VGND VPWR
+ VPWR net667 sky130_fd_sc_hd__mux4_4
XANTENNA_output62_A clknet_1_0__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c441_SCD net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput7 in14 VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c389_A2 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net247 clknet_0_net247 VGND VGND VPWR VPWR clknet_1_0__leaf_net247
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net258 clknet_0_net258 VGND VGND VPWR VPWR clknet_1_0__leaf_net258
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_1_1__f_net565_A clknet_0_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c571_A3 net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge795_SCE net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_1__f_net987_X clknet_1_1__leaf_net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_38_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c481_A3 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s974_GATE clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_1_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc590 net1071 clknet_1_0__leaf_net510 net1041 net501 net1030 net859 VGND VGND VPWR
+ VPWR net513 sky130_fd_sc_hd__mux4_1
XANTENNA_c414_SCD net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_35_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_15_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c489_SET_B clknet_1_1__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c582_A2 net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_65_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c103_A1 net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_74_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c476_A3 net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c339_S1 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_92_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c386_A3 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput21 in27 VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__buf_1
Xinput10 in17 VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_12_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput32 in37 VGND VGND VPWR VPWR net960 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput43 in47 VGND VGND VPWR VPWR net971 sky130_fd_sc_hd__buf_2
XFILLER_0_12_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c452_D net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c77_B1_N net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c340_B net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c577_A2 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout134_X net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c593_A1 net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c622_S1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net510 clknet_0_net510 VGND VGND VPWR VPWR clknet_1_1__leaf_net510
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net565 clknet_0_net565 VGND VGND VPWR VPWR clknet_1_1__leaf_net565
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net554 clknet_0_net554 VGND VGND VPWR VPWR clknet_1_1__leaf_net554
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net598 clknet_0_net598 VGND VGND VPWR VPWR clknet_1_1__leaf_net598
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net576 clknet_0_net576 VGND VGND VPWR VPWR clknet_1_1__leaf_net576
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_84_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c343_Y net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c754_A3 net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c617_S1 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input24_A in3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge850_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c633_S0 clknet_1_0__leaf_net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c504_CLK_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_output92_A net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c307_Q_N net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net340 clknet_0_net340 VGND VGND VPWR VPWR clknet_1_1__leaf_net340
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net362 clknet_0_net362 VGND VGND VPWR VPWR clknet_1_1__leaf_net362
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net373 clknet_0_net373 VGND VGND VPWR VPWR clknet_1_1__leaf_net373
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s951_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc408 net96 net86 VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__xnor2_2
XFILLER_0_13_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc419 clknet_1_1__leaf_net866 net874 VGND VGND VPWR VPWR net990 sky130_fd_sc_hd__xnor2_2
XANTENNA_c590_A2 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_6_0_clk_X clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c665_A net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c599_B1 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c749_A3 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge923_GATE_N clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge918 clknet_4_0_0_clk net599 net488 VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__dfstp_1
Xmerge907 clknet_4_2_0_clk net630 net822 VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__sdlclkp_4
Xmerge929 clknet_4_3_0_clk net607 net782 VGND VGND VPWR VPWR net858 net857 sky130_fd_sc_hd__edfxbp_1
XFILLER_0_36_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net530 net530 VGND VGND VPWR VPWR clknet_0_net530 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input27_X net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net429 clknet_0_net429 VGND VGND VPWR VPWR clknet_1_0__leaf_net429
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s933_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_0__f_net565_A clknet_0_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_10_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c569_A3 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_53_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c585_A2 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net1003_X clknet_1_0__leaf_net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc205 net948 net1043 net809 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__mux2_4
Xc227 net155 clknet_1_0__leaf_net1023 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__xor2_4
Xc216 net164 net162 net763 net1056 net868 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__a41oi_4
XTAP_TAPCELL_ROW_79_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc238 net48 clknet_1_0__leaf_net183 net1020 net13 net187 VGND VGND VPWR VPWR net188
+ sky130_fd_sc_hd__a41oi_4
Xc249 net816 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c448_S0 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c630_S1 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c495_A2 net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net371 net371 VGND VGND VPWR VPWR clknet_0_net371 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc761 net593 net666 net667 net633 net1028 net918 VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__mux4_1
Xc750 net1057 net609 net853 net890 clknet_1_0__leaf_net899 net1052 VGND VGND VPWR
+ VPWR net657 sky130_fd_sc_hd__mux4_4
XANTENNA_c441_SCE net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput8 in15 VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output55_A net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c686_A1 net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c299_A3 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c731_S0 net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c423_Y net360 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_14_0_clk_X clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc580 net455 net985 clknet_1_0__leaf_net867 VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__a21boi_0
Xc591 net508 net260 clknet_1_1__leaf_net510 net1030 net499 VGND VGND VPWR VPWR net514
+ sky130_fd_sc_hd__a41oi_1
XFILLER_0_47_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c697_A0 net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_35_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_63_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge802_A0 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c726_S0 clknet_1_1__leaf_net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c578_A net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c757_A3 net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c71_B net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c636_S0 clknet_1_1__leaf_net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c452_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput11 in18 VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__clkbuf_8
Xinput22 in28 VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_71_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput44 in48 VGND VGND VPWR VPWR net972 sky130_fd_sc_hd__clkbuf_4
Xinput33 in38 VGND VGND VPWR VPWR net961 sky130_fd_sc_hd__buf_1
XFILLER_0_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c220_B1 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c175_S1 net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net566 clknet_0_net566 VGND VGND VPWR VPWR clknet_1_1__leaf_net566
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net577 clknet_0_net577 VGND VGND VPWR VPWR clknet_1_1__leaf_net577
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c488_SET_B net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c426_SET_B net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge909_Q_N net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c723_S1 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c588_A2 net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_2_0_clk_X clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_s936_Q net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c125_B1 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input17_A in23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c498_A2 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c689_A1 net485 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net374 clknet_0_net374 VGND VGND VPWR VPWR clknet_1_1__leaf_net374
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net385 clknet_0_net385 VGND VGND VPWR VPWR clknet_1_1__leaf_net385
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c365_SET_B clknet_1_1__leaf_net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net1014 clknet_0_net1014 VGND VGND VPWR VPWR clknet_1_0__leaf_net1014
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net1003 clknet_0_net1003 VGND VGND VPWR VPWR clknet_1_0__leaf_net1003
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net1025 clknet_0_net1025 VGND VGND VPWR VPWR clknet_1_0__leaf_net1025
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc409 net703 VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__buf_6
XANTENNA_input9_A in16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c734_S0 net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c560_A net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c279_X net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge908 clknet_4_15_0_clk net733 net713 VGND VGND VPWR VPWR net832 net831 sky130_fd_sc_hd__dfrbp_1
Xmerge919 net513 clknet_4_3_0_clk net752 VGND VGND VPWR VPWR net846 net845 sky130_fd_sc_hd__dlrbn_1
XFILLER_0_67_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net586 net586 VGND VGND VPWR VPWR clknet_0_net586 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net597 net597 VGND VGND VPWR VPWR clknet_0_net597 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_101_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net419 clknet_0_net419 VGND VGND VPWR VPWR clknet_1_0__leaf_net419
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_26_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold25_A net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net920 clknet_0_net920 VGND VGND VPWR VPWR clknet_1_0__leaf_net920
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_53_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c239_A net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc206 net973 net149 net18 net753 net809 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__a41oi_1
XTAP_TAPCELL_ROW_79_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc217 net826 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_92_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc228 net55 net1043 net57 net175 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__a31oi_1
Xc239 net180 net771 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c448_S1 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c106_A2 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c94_A net32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net361 net361 VGND VGND VPWR VPWR clknet_0_net361 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc740 net1062 net539 net604 net593 clknet_1_1__leaf_net830 net911 VGND VGND VPWR VPWR
+ net647 sky130_fd_sc_hd__mux4_1
Xc762 clknet_1_0__leaf_net398 net1028 net849 net853 net916 net918 VGND VGND VPWR VPWR
+ net669 sky130_fd_sc_hd__mux4_4
Xc751 clknet_1_0__leaf_net554 net323 net657 net606 clknet_1_1__leaf_net643 clknet_1_1__leaf_net900
+ VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__mux4_4
XANTENNA_c313_B1 net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_46 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput9 in16 VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__buf_2
XANTENNA_c686_A2 net578 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_30_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c151_Y net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c731_S1 clknet_1_1__leaf_net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c409_X net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c117_A1 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c194_S0 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc581 net503 net266 clknet_1_0__leaf_net990 net499 net501 net876 VGND VGND VPWR VPWR
+ net504 sky130_fd_sc_hd__mux4_1
Xc570 net486 clknet_1_1__leaf_net481 net484 clknet_1_0__leaf_net453 VGND VGND VPWR
+ VPWR net493 sky130_fd_sc_hd__a31oi_1
Xc592 clknet_1_1__leaf_net452 net1030 net266 net1022 clknet_1_0__leaf_net510 net846
+ VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__mux4_1
XFILLER_0_47_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c697_A1 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_35_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_15_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout117_A net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c726_S1 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input47_A in50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c310_A1 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge896_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput12 in19 VGND VGND VPWR VPWR net940 sky130_fd_sc_hd__buf_1
XFILLER_0_71_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput45 in49 VGND VGND VPWR VPWR net973 sky130_fd_sc_hd__buf_2
Xinput23 in29 VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__buf_1
Xinput34 in39 VGND VGND VPWR VPWR net962 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c204_A2 net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c220_A1 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c688_A net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c305_A1 net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net534 clknet_0_net534 VGND VGND VPWR VPWR clknet_1_1__leaf_net534
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net567 clknet_0_net567 VGND VGND VPWR VPWR clknet_1_1__leaf_net567
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c678_A3 net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c694_A2 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c269_A net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge808_A0 net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c125_A1 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c733_RESET_B clknet_1_1__leaf_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c498_A3 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c316_B1 net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output78_A net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c689_A2 net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net342 clknet_0_net342 VGND VGND VPWR VPWR clknet_1_1__leaf_net342
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net375 clknet_0_net375 VGND VGND VPWR VPWR clknet_1_1__leaf_net375
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap131 net138 VGND VGND VPWR VPWR net1059 sky130_fd_sc_hd__buf_4
Xmax_cap120 net1049 VGND VGND VPWR VPWR net1048 sky130_fd_sc_hd__buf_4
XFILLER_0_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge810_A1 clknet_1_0__leaf_net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmerge909 clknet_4_4_0_clk net688 net727 VGND VGND VPWR VPWR net834 net833 sky130_fd_sc_hd__dfrbp_2
XFILLER_0_67_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net510 net510 VGND VGND VPWR VPWR clknet_0_net510 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net565 net565 VGND VGND VPWR VPWR clknet_0_net565 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net554 net554 VGND VGND VPWR VPWR clknet_0_net554 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net598 net598 VGND VGND VPWR VPWR clknet_0_net598 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net576 net576 VGND VGND VPWR VPWR clknet_0_net576 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c136_B1 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold18_A net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net194 clknet_0_net194 VGND VGND VPWR VPWR clknet_1_1__leaf_net194
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net183 clknet_0_net183 VGND VGND VPWR VPWR clknet_1_1__leaf_net183
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_81_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_53_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c141_B net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net987 clknet_0_net987 VGND VGND VPWR VPWR clknet_1_0__leaf_net987
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_33_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc207 net0 net18 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__xor2_2
Xc218 net151 net1034 net149 net165 net162 net164 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__mux4_1
XFILLER_0_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_92_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc229 net35 net9 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__xor2_2
XFILLER_0_13_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout102_X net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c291_X net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c563_Y net485 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c480_S0 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c546_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge915_SET_B net722 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net340 net340 VGND VGND VPWR VPWR clknet_0_net340 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net362 net362 VGND VGND VPWR VPWR clknet_0_net362 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net373 net373 VGND VGND VPWR VPWR clknet_0_net373 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc730 net604 net613 net519 net633 clknet_1_0__leaf_net398 net1038 VGND VGND VPWR VPWR
+ net636 sky130_fd_sc_hd__mux4_4
Xc741 net536 clknet_1_0__leaf_net647 clknet_1_0__leaf_net643 clknet_1_1__leaf_net565
+ net909 net912 VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__mux4_4
Xc752 net256 net313 clknet_1_1__leaf_net643 net633 net853 net916 VGND VGND VPWR VPWR
+ net659 sky130_fd_sc_hd__mux4_1
XANTENNA_input32_X net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c438_6_A clknet_1_1__leaf_net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c565_S0 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_97_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s947_SLEEP_B clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c311_Y net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c304_X net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c475_S0 net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c194_S1 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net919 clknet_0_net919 VGND VGND VPWR VPWR clknet_1_1__leaf_net919
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge892_GATE clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c442_S net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge856_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c344_B1_N net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c385_S0 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc571 net486 clknet_1_1__leaf_net481 net451 net793 net856 net1053 VGND VGND VPWR VPWR
+ net494 sky130_fd_sc_hd__mux4_4
Xc560 net249 clknet_1_1__leaf_net474 VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__xor2_1
Xc582 net500 net477 net895 VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__a21boi_1
XANTENNA_output60_A net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc593 net498 net477 net508 net846 net857 net896 VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__mux4_1
XFILLER_0_47_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c579_CLK_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c218_A1 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput100 net1028 VGND VGND VPWR VPWR out9 sky130_fd_sc_hd__buf_2
XFILLER_0_42_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c128_A1 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c189_S1 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c144_B1 net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c310_A2 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c728_RESET_B net536 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput13 in2 VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_40_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput35 in4 VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__clkbuf_8
Xinput24 in3 VGND VGND VPWR VPWR net952 sky130_fd_sc_hd__clkbuf_4
Xinput46 in5 VGND VGND VPWR VPWR net974 sky130_fd_sc_hd__buf_4
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc390 net192 net73 net179 net324 net1007 net1004 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__mux4_1
XANTENNA_c204_A3 net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c220_A2 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s981_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c753_S0 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c472_S1 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net1019 clknet_0_net1019 VGND VGND VPWR VPWR clknet_1_1__leaf_net1019
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c130_A2 net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c139_B1 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net535 clknet_0_net535 VGND VGND VPWR VPWR clknet_1_1__leaf_net535
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c382_S1 net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_45_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c215_A2 net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s954_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c436_B net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge808_A1 clknet_1_0__leaf_net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c316_A1 net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c689_A3 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net321 clknet_0_net321 VGND VGND VPWR VPWR clknet_1_1__leaf_net321
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net365 clknet_0_net365 VGND VGND VPWR VPWR clknet_1_1__leaf_net365
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net398 clknet_0_net398 VGND VGND VPWR VPWR clknet_1_1__leaf_net398
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge918_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s936_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap121 net106 VGND VGND VPWR VPWR net1049 sky130_fd_sc_hd__buf_4
Xmax_cap132 net85 VGND VGND VPWR VPWR net1060 sky130_fd_sc_hd__buf_4
XFILLER_0_4_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c242_B1 net869 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge810_A2 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c553_B net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge819_A0 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge909_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_526 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c750_S1 net1052 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net566 net566 VGND VGND VPWR VPWR clknet_0_net566 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net577 net577 VGND VGND VPWR VPWR clknet_0_net577 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c136_A1 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input22_A in28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net900 clknet_0_net900 VGND VGND VPWR VPWR clknet_1_0__leaf_net900
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_526 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc208 net149 net0 net150 net963 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__a31o_2
XFILLER_0_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_92_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc219 net157 net167 net161 net794 net1087 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__a41o_1
XTAP_TAPCELL_ROW_5_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c556_Y net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_101_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net374 net374 VGND VGND VPWR VPWR clknet_0_net374 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net385 net385 VGND VGND VPWR VPWR clknet_0_net385 sky130_fd_sc_hd__clkbuf_16
Xc720 net954 net614 net1047 clknet_1_1__leaf_net623 net805 VGND VGND VPWR VPWR net625
+ sky130_fd_sc_hd__a41o_4
Xc731 clknet_1_1__leaf_net617 net568 net539 net1030 net255 clknet_1_1__leaf_net230
+ VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__mux4_2
Xc753 net1057 clknet_1_1__leaf_net643 clknet_1_0__leaf_net554 net609 net422 net313
+ VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__mux4_4
Xc742 net536 net1062 clknet_1_0__leaf_net643 clknet_1_1__leaf_net647 net818 net823
+ VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__mux4_2
XANTENNA_c426_SCE net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c313_A2 net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_38_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c137_Y net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c146_B1_N net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc572 net851 VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__inv_2
Xc550 net850 VGND VGND VPWR VPWR net1022 sky130_fd_sc_hd__buf_4
Xc561 net357 net466 net477 net480 clknet_1_1__leaf_net481 net1062 VGND VGND VPWR VPWR
+ net482 sky130_fd_sc_hd__mux4_2
Xc594 clknet_4_3_0_clk net26 net999 net1058 clknet_1_1__leaf_net398 net1077 VGND VGND
+ VPWR VPWR net518 net517 sky130_fd_sc_hd__sdfbbn_1
Xc583 net266 net480 net1038 clknet_1_0__leaf_net881 net895 VGND VGND VPWR VPWR net506
+ sky130_fd_sc_hd__a41oi_4
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c697_A3 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap108_X net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_35_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_63_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net582 clknet_0_net582 VGND VGND VPWR VPWR clknet_1_0__leaf_net582
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s948_Q_N net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge798_S0 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput36 in40 VGND VGND VPWR VPWR net964 sky130_fd_sc_hd__clkbuf_8
Xinput25 in30 VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__buf_1
Xinput14 in20 VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_64_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput47 in50 VGND VGND VPWR VPWR net975 sky130_fd_sc_hd__buf_4
XFILLER_0_24_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c335_B1 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc391 net330 net1010 net1016 net998 net1007 net1004 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__mux4_4
XFILLER_0_74_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge890 net774 clknet_4_13_0_clk net154 VGND VGND VPWR VPWR net1009 net809 sky130_fd_sc_hd__dlrbn_1
XFILLER_0_15_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge813_A2 net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c197_X net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c753_S1 net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c139_A1 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input52_A in9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c488_Q net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_17_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c710_SCD clknet_1_0__leaf_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge881_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_22 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_7_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c157_A net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge808_A2 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c125_A3 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge872_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c703_B1 net1052 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c72_Y net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c316_A2 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge863_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net333 clknet_0_net333 VGND VGND VPWR VPWR clknet_1_1__leaf_net333
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net366 clknet_0_net366 VGND VGND VPWR VPWR clknet_1_1__leaf_net366
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net388 clknet_0_net388 VGND VGND VPWR VPWR clknet_1_1__leaf_net388
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_71_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net399 clknet_0_net399 VGND VGND VPWR VPWR clknet_1_1__leaf_net399
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_1_0__f_net381_X clknet_1_0__leaf_net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap111 net239 VGND VGND VPWR VPWR net1039 sky130_fd_sc_hd__buf_4
XFILLER_0_96_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge819_A1 clknet_1_1__leaf_net335 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net534 net534 VGND VGND VPWR VPWR clknet_0_net534 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net567 net567 VGND VGND VPWR VPWR clknet_0_net567 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge845_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input15_A in21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c672_B1_N net570 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_output83_A net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c237_A1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc209 net843 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__inv_12
XFILLER_0_60_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_92_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c253_A0 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input7_A in14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net342 net342 VGND VGND VPWR VPWR clknet_0_net342 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net375 net375 VGND VGND VPWR VPWR clknet_0_net375 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c147_A1 net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc721 net578 clknet_1_0__leaf_net623 net601 net1029 net614 net741 VGND VGND VPWR VPWR
+ net626 sky130_fd_sc_hd__mux4_4
Xc710 clknet_4_2_0_clk net380 net1029 clknet_1_0__leaf_net565 net1052 VGND VGND VPWR
+ VPWR net614 sky130_fd_sc_hd__sedfxtp_4
Xc743 clknet_1_1__leaf_net453 clknet_1_1__leaf_net617 net1062 clknet_1_1__leaf_net565
+ clknet_1_0__leaf_net830 clknet_1_0__leaf_net860 VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__mux4_4
Xc754 clknet_1_0__leaf_net655 net1035 net422 net313 net609 net855 VGND VGND VPWR VPWR
+ net661 sky130_fd_sc_hd__mux4_4
Xc732 net594 net1029 net1045 net1042 net536 net910 VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__mux4_1
XANTENNA_clkbuf_4_15_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c470_Q net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input18_X net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c338_B1 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_30_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c581_S1 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net786 clknet_0_net786 VGND VGND VPWR VPWR clknet_1_0__leaf_net786
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge816_A2 clknet_1_0__leaf_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c404_A net854 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net183 net183 VGND VGND VPWR VPWR clknet_0_net183 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net194 net194 VGND VGND VPWR VPWR clknet_0_net194 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc540 net856 VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__inv_4
XANTENNA_c605_A1 net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc573 net380 net477 net877 VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__mux2_1
Xc551 clknet_1_0__leaf_net362 net360 net357 net773 VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__a31o_2
Xc562 clknet_4_1_0_clk net372 clknet_1_1__leaf_net474 clknet_1_1__leaf_net481 net1105
+ VGND VGND VPWR VPWR net484 net483 sky130_fd_sc_hd__sedfxbp_2
Xc595 net397 net941 net502 VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__a21o_1
Xc584 net364 net260 net499 net1022 net851 net884 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__mux4_2
XANTENNA_c414_RESET_B net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_35_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c218_A3 net165 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c101_CLK_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c470_SET_B net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput15 in21 VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_12_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput26 in31 VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_40_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput37 in41 VGND VGND VPWR VPWR net965 sky130_fd_sc_hd__buf_2
Xinput48 in51 VGND VGND VPWR VPWR net976 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc370 clknet_1_1__leaf_net316 net306 net315 net295 net186 clknet_1_0__leaf_net147
+ VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__mux4_1
Xc392 net315 net72 net207 net1055 net1007 clknet_1_0__leaf_net992 VGND VGND VPWR VPWR
+ net333 sky130_fd_sc_hd__mux4_2
XFILLER_0_74_46 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net919 net919 VGND VGND VPWR VPWR clknet_0_net919 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c364_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge880 clknet_4_0_0_clk net478 net728 VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__dfrtp_4
Xmerge891 net673 clknet_4_4_0_clk net473 VGND VGND VPWR VPWR net811 net810 sky130_fd_sc_hd__dlrbn_2
XANTENNA_c207_B net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_3_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c102_A net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge813_A3 net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c492_SCD net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_1__f_net990_X clknet_1_1__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net391 clknet_0_net391 VGND VGND VPWR VPWR clknet_1_0__leaf_net391
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c139_A2 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c107_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input45_A in49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c321_A3 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c670_CLK_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c710_SCE net1052 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c157_B net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge808_A3 net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c256_A0 net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout118_X net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c125_A4 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c703_A1 net578 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c316_A3 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c613_A1 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_58_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net367 clknet_0_net367 VGND VGND VPWR VPWR clknet_1_1__leaf_net367
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_71_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s976_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge810_A4 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge819_A2 net336 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net786_X clknet_1_1__leaf_net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net535 net535 VGND VGND VPWR VPWR clknet_0_net535 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c254_SET_B net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c433_A1 net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_580 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_4_11_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c624_A0 net507 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c343_A1 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net321 net321 VGND VGND VPWR VPWR clknet_0_net321 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net365 net365 VGND VGND VPWR VPWR clknet_0_net365 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c147_A2 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net398 net398 VGND VGND VPWR VPWR clknet_0_net398 sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc711 net601 net609 net584 net1037 net614 net954 VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__mux4_1
Xc700 net596 clknet_1_0__leaf_net454 net583 clknet_1_1__leaf_net577 net483 net904
+ VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__mux4_2
Xc722 net1037 net614 net1029 net980 net818 net905 VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__mux4_4
Xc733 clknet_4_2_0_clk net485 clknet_1_1__leaf_net565 net519 net1042 net621 VGND VGND
+ VPWR VPWR net640 net639 sky130_fd_sc_hd__sdfbbp_1
Xc755 net568 net446 net661 net609 net422 net855 VGND VGND VPWR VPWR net662 sky130_fd_sc_hd__mux4_2
Xc744 clknet_1_0__leaf_net647 net518 clknet_1_0__leaf_net398 clknet_1_1__leaf_net643
+ clknet_1_1__leaf_net830 net911 VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__mux4_2
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c610_A2 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s990_GATE clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c619_A0 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c711_A1 net609 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c57_B1 net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c70_B1_N net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc530 net859 VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__inv_4
XANTENNA_c605_A2 clknet_1_1__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc563 net256 net227 net455 net810 VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__a31oi_4
Xc552 clknet_1_0__leaf_net375 net249 net1036 net1033 VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__a31oi_2
Xc541 net1073 clknet_1_0__leaf_net453 VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__xor2_2
Xc585 net396 net484 net363 net497 net501 net894 VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__mux4_1
Xc574 net851 VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__clkbuf_1
Xc596 net466 net502 clknet_1_1__leaf_net289 net896 VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__a31o_2
XANTENNA_input30_X net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c621_A1 net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_35_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge891_GATE_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net990_X clknet_1_0__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s984_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net562 clknet_0_net562 VGND VGND VPWR VPWR clknet_1_0__leaf_net562
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_12_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c722_A0 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_21_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c426_Q net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput27 in32 VGND VGND VPWR VPWR net955 sky130_fd_sc_hd__buf_4
Xinput16 in22 VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_12_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput38 in42 VGND VGND VPWR VPWR net966 sky130_fd_sc_hd__clkbuf_1
Xinput49 in6 VGND VGND VPWR VPWR net977 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_52_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc382 net180 net1000 net314 net986 net1005 net1055 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__mux4_2
Xc371 net303 net312 net317 net305 net309 net761 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__mux4_4
XFILLER_0_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c632_A0 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc360 net173 net305 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__xor2_2
Xc393 clknet_1_0__leaf_net333 net324 clknet_1_1__leaf_net1025 net777 net1004 clknet_1_0__leaf_net992
+ VGND VGND VPWR VPWR net996 sky130_fd_sc_hd__mux4_1
XFILLER_0_74_58 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s966_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_86_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge881 clknet_4_7_0_clk net723 net717 VGND VGND VPWR VPWR net799 net798 sky130_fd_sc_hd__dfsbp_2
XFILLER_0_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge870 net731 net726 VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__xor2_4
XFILLER_0_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge892 net533 clknet_4_3_0_clk net695 VGND VGND VPWR VPWR net813 net812 sky130_fd_sc_hd__dlrbp_1
XFILLER_0_15_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c245_A2 net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c492_SCE net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s957_Q net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net381 clknet_0_net381 VGND VGND VPWR VPWR clknet_1_0__leaf_net381
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input38_A in42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s948_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge764_A0 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c627_A0 net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c346_A1 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc190 net684 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__buf_1
XFILLER_0_85_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_1_1__f_net1025_A clknet_0_net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s939_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge824_A3 net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_95_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c153_SCD net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c447_B1 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c58_Y net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c613_A2 net522 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net335 clknet_0_net335 VGND VGND VPWR VPWR clknet_1_1__leaf_net335
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_58_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net1019 clknet_0_net1019 VGND VGND VPWR VPWR clknet_1_0__leaf_net1019
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap124 net906 VGND VGND VPWR VPWR net1052 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_52_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net880 clknet_0_net880 VGND VGND VPWR VPWR clknet_1_1__leaf_net880
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge819_A3 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout130_X net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c417_A3 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c584_X net507 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c608_A2 net522 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c343_A2 net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output69_A net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_92_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_77_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge890_D net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net366 net366 VGND VGND VPWR VPWR clknet_0_net366 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net333 net333 VGND VGND VPWR VPWR clknet_0_net333 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net388 net388 VGND VGND VPWR VPWR clknet_0_net388 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net399 net399 VGND VGND VPWR VPWR clknet_0_net399 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c725_B1 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge862_GATE clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_86_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc701 net797 VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__clkbuf_2
Xc712 net480 clknet_1_0__leaf_net598 net614 net1052 net907 VGND VGND VPWR VPWR net616
+ sky130_fd_sc_hd__a41o_4
Xc734 net621 net1029 net590 clknet_1_1__leaf_net565 net979 net740 VGND VGND VPWR VPWR
+ net641 sky130_fd_sc_hd__mux4_2
Xc745 clknet_1_0__leaf_net381 clknet_1_0__leaf_net643 net911 net913 net916 net917
+ VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__mux4_2
Xc723 net1037 clknet_1_1__leaf_net616 net612 net620 net795 net909 VGND VGND VPWR VPWR
+ net628 sky130_fd_sc_hd__mux4_2
Xc756 net609 clknet_1_1__leaf_net230 net1038 net1040 clknet_1_0__leaf_net900 net914
+ VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__mux4_4
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input20_A in26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_95_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c610_A3 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c619_A1 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c338_A2 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c635_A0 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge851_GATE_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_38_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge801_S0 net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c132_B net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c282_X net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc531 net344 net221 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__xnor2_4
Xc564 net485 net348 net483 net769 net797 net810 VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__mux4_2
Xc542 net450 clknet_1_0__leaf_net452 VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__xnor2_4
Xc553 clknet_1_0__leaf_net366 net1058 VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__xnor2_4
Xc575 net852 VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__inv_2
Xc597 clknet_4_3_0_clk net1106 clknet_1_0__leaf_net419 net413 net26 clknet_1_1__leaf_net881
+ VGND VGND VPWR VPWR net522 net521 sky130_fd_sc_hd__sdfbbp_1
XANTENNA_c621_A2 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge898_Q net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c559_SCD net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net530 clknet_0_net530 VGND VGND VPWR VPWR clknet_1_0__leaf_net530
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c135_Y net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c302_Y net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_96_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput28 in33 VGND VGND VPWR VPWR net956 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_91_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput17 in23 VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__buf_1
XFILLER_0_52_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput39 in43 VGND VGND VPWR VPWR net967 sky130_fd_sc_hd__buf_1
XANTENNA_c728_SET_B net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc361 net826 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__inv_2
Xc350 net297 net1001 VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__xor2_1
Xc372 clknet_4_12_0_clk net39 clknet_1_0__leaf_net316 net317 net761 net1082 VGND VGND
+ VPWR VPWR net323 net322 sky130_fd_sc_hd__sdfbbn_1
XANTENNA_c632_A1 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc383 net1050 net192 net315 net1038 net872 net1005 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__mux4_1
Xc394 clknet_1_1__leaf_net333 net979 net1050 net314 net198 clknet_1_0__leaf_net992
+ VGND VGND VPWR VPWR net1019 sky130_fd_sc_hd__mux4_4
XANTENNA_c351_A2 net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s959_GATE_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge882 clknet_4_14_0_clk net430 net191 VGND VGND VPWR VPWR net801 net800 sky130_fd_sc_hd__dfsbp_1
Xmerge860 net441 net334 VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__xnor2_1
Xmerge871 clknet_4_4_0_clk net699 net700 VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__sdlclkp_4
Xmerge893 net93 clknet_4_5_0_clk net98 VGND VGND VPWR VPWR net815 net814 sky130_fd_sc_hd__dlrbp_2
XFILLER_0_70_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge884_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c297_B net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net371 clknet_0_net371 VGND VGND VPWR VPWR clknet_1_0__leaf_net371
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_34_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c627_A1 clknet_1_1__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge764_A1 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c346_A2 net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge780_B1 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output99_A net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc180 net799 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_4
XFILLER_0_20_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc191 net134 net138 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__xor2_1
XFILLER_0_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c362_X net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c65_A1 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c166_A2 net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_50_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_0_net1025_A net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input50_A in7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c613_A3 net536 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge775_B1 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge880_Q net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap125 net891 VGND VGND VPWR VPWR net1053 sky130_fd_sc_hd__buf_2
XFILLER_0_52_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_hold39_A net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net881 clknet_0_net881 VGND VGND VPWR VPWR clknet_1_1__leaf_net881
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c559_SET_B net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c441_D net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c322_A net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c706_D net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c215_Y net165 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c714_A2 net594 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c691_A net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c608_A3 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c624_A2 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c365_SCE net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c129_CLK_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc586_8 clknet_1_1__leaf_net919 VGND VGND VPWR VPWR net1071 sky130_fd_sc_hd__clkinv_4
XFILLER_0_95_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c332_Y net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net367 net367 VGND VGND VPWR VPWR clknet_0_net367 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc713 clknet_1_1__leaf_net567 net578 net585 net601 net954 VGND VGND VPWR VPWR net617
+ sky130_fd_sc_hd__a41o_4
XFILLER_0_16_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc702 net602 net593 clknet_1_0__leaf_net230 net958 net844 net906 VGND VGND VPWR VPWR
+ net605 sky130_fd_sc_hd__mux4_1
Xc724 net585 net578 net1029 clknet_1_0__leaf_net616 net795 net909 VGND VGND VPWR VPWR
+ net629 sky130_fd_sc_hd__mux4_2
Xc746 net1042 clknet_1_1__leaf_net617 clknet_1_0__leaf_net643 c746/A3 net805 net855
+ VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__mux4_1
Xc735 clknet_1_0__leaf_net381 net634 net905 net910 net911 VGND VGND VPWR VPWR net642
+ sky130_fd_sc_hd__a41oi_1
XFILLER_0_31_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c292_SCD net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c741_A0 net536 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc757 clknet_1_0__leaf_net398 net448 net853 net890 clknet_1_1__leaf_net899 net918
+ VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__mux4_1
XFILLER_0_98_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input13_A in2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge772_A1 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c635_A1 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge843_Q net754 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_38_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge801_S1 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input5_A in12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c711_A3 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c661_B net338 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c442_X net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c736_A0 clknet_1_1__leaf_net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc532 clknet_1_0__leaf_net452 net86 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__xor2_4
Xc554 net103 net449 net974 net467 VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__a31o_1
Xc543 clknet_1_0__leaf_net222 clknet_1_0__leaf_net335 net451 clknet_1_0__leaf_net881
+ VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__a31oi_1
Xc576 net496 net491 net883 VGND VGND VPWR VPWR net985 sky130_fd_sc_hd__o21ba_2
Xc598 net974 net521 net1045 net896 VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__a31o_1
Xc565 net486 net477 clknet_1_1__leaf_net481 net249 net1053 net893 VGND VGND VPWR VPWR
+ net487 sky130_fd_sc_hd__mux4_4
Xc587 net461 net501 net507 clknet_1_0__leaf_net867 net876 VGND VGND VPWR VPWR net510
+ sky130_fd_sc_hd__a41o_4
XANTENNA_c621_A3 net522 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_35_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c500_S0 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net342_X clknet_1_0__leaf_net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_hold21_A net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c559_SCE net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge852_GATE clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net586 clknet_0_net586 VGND VGND VPWR VPWR clknet_1_0__leaf_net586
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net597 clknet_0_net597 VGND VGND VPWR VPWR clknet_1_0__leaf_net597
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c402_A net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c722_A2 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input8_X net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c68_A1 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c90_A net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput18 in24 VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__buf_2
Xinput29 in34 VGND VGND VPWR VPWR net957 sky130_fd_sc_hd__buf_1
XFILLER_0_91_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c616_A3 clknet_1_1__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc340 net794 net1055 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__xnor2_2
Xc351 net299 net291 net1001 net1063 net282 clknet_1_1__leaf_net262 VGND VGND VPWR
+ VPWR net300 sky130_fd_sc_hd__mux4_1
Xc373 net303 net1059 net312 net317 net301 net819 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__mux4_2
XANTENNA_c632_A2 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc362 net836 VGND VGND VPWR VPWR net994 sky130_fd_sc_hd__clkbuf_4
Xc384 net193 net179 net1020 net1000 net1050 net306 VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__mux4_1
Xc395 net207 net1000 clknet_1_0__leaf_net1019 net1007 net1004 clknet_1_0__leaf_net992
+ VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__mux4_4
XFILLER_0_20_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c351_A3 net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge778_B1 net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c597_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge861 net211 net331 VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__xor2_1
Xmerge850 net735 clknet_4_7_0_clk net10 VGND VGND VPWR VPWR net763 net762 sky130_fd_sc_hd__dlrbn_2
XFILLER_0_7_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge872 clknet_4_4_0_clk net718 net698 VGND VGND VPWR VPWR net788 net787 sky130_fd_sc_hd__dfrbp_1
Xmerge894 net692 clknet_4_15_0_clk net210 VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__dlrtn_1
XFILLER_0_15_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge883 net638 net628 VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__xnor2_1
XFILLER_0_43_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_1__f_net335_X clknet_1_1__leaf_net335 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c261_A3 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c185_A net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c352_A net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net361 clknet_0_net361 VGND VGND VPWR VPWR clknet_1_0__leaf_net361
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge898_GATE clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c627_A2 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc170 net120 net959 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__xnor2_2
Xc181 net107 net4 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__xor2_1
Xc192 net141 net138 net130 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__a21o_1
XFILLER_0_85_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_87_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout113_A net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c100_A net854 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s962_Q net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c447_A2 net754 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c733_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_18_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input43_A in47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c479_Q net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c357_A2 net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge791_B1 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c373_A1 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap126 net997 VGND VGND VPWR VPWR net1054 sky130_fd_sc_hd__buf_4
XFILLER_0_20_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net860 clknet_0_net860 VGND VGND VPWR VPWR clknet_1_1__leaf_net860
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_95_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c564_A0 net485 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout116_X net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c103_X net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c714_A3 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c577_Y net499 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c730_A2 net519 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c706_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c608_A4 clknet_1_0__leaf_net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c474_B1 net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input46_X net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap126_A net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c413_S0 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c278_A1 net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net335 net335 VGND VGND VPWR VPWR clknet_0_net335 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc703 net578 net845 net1052 VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__a21oi_4
Xc714 clknet_1_0__leaf_net617 net594 net1029 net907 net908 VGND VGND VPWR VPWR net618
+ sky130_fd_sc_hd__a41o_2
Xc725 clknet_1_1__leaf_net623 net604 clknet_1_1__leaf_net453 clknet_1_0__leaf_net860
+ net909 VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__a41oi_4
Xc736 clknet_1_1__leaf_net453 net639 net604 net958 net517 net911 VGND VGND VPWR VPWR
+ net643 sky130_fd_sc_hd__mux4_2
Xc747 net1029 net634 net842 net909 net916 net917 VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__mux4_1
XFILLER_0_31_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc758 net1080 net1035 clknet_1_1__leaf_net643 net1062 net842 net918 VGND VGND VPWR
+ VPWR net665 sky130_fd_sc_hd__mux4_2
XANTENNA_c460_A2 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c619_A3 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge911_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge772_A2 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c635_A2 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net880 net880 VGND VGND VPWR VPWR clknet_0_net880 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_78_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output74_A net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap129_X net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_66_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_0_clk_X clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c280_A2 net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s987_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c289_B1 net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c752_A0 net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc500 net457 net438 clknet_1_0__leaf_net425 net413 net886 net890 VGND VGND VPWR VPWR
+ net441 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_9_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc544 net927 VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__clkbuf_1
Xc555 net357 net249 net773 VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__mux2_1
Xc533 net224 clknet_1_0__leaf_net452 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__xnor2_4
Xc566 clknet_1_0__leaf_net474 net486 clknet_1_0__leaf_net481 net483 net363 net892
+ VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__mux4_1
Xc577 net268 net1022 net461 VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__a21boi_4
Xc588 net505 net480 net502 net483 VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__a31oi_2
XANTENNA_c573_S net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc599 clknet_1_0__leaf_net399 net502 net421 net1032 VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__a31o_4
XFILLER_0_99_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c559_Q net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c500_S1 net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s969_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net510 clknet_0_net510 VGND VGND VPWR VPWR clknet_1_0__leaf_net510
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net576 clknet_0_net576 VGND VGND VPWR VPWR clknet_1_0__leaf_net576
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net565 clknet_0_net565 VGND VGND VPWR VPWR clknet_1_0__leaf_net565
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net554 clknet_0_net554 VGND VGND VPWR VPWR clknet_1_0__leaf_net554
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net598 clknet_0_net598 VGND VGND VPWR VPWR clknet_1_0__leaf_net598
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c722_A3 net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c747_A0 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c90_B net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput19 in25 VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_12_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s988_GATE_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c307_Q net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc330 net161 net18 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_75_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc341 net277 net1046 net1090 VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__o21a_1
Xc363 net803 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__inv_2
Xc352 net946 net1054 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__xnor2_2
XFILLER_0_20_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc385 net73 net994 net200 net179 net1050 net1007 VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc396 clknet_1_0__leaf_net222 net875 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_48_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge851 net34 clknet_4_13_0_clk net687 VGND VGND VPWR VPWR net765 net764 sky130_fd_sc_hd__dlrbn_1
Xmerge840 net206 net209 VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__xor2_1
XFILLER_0_7_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge873 net538 net512 VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__xor2_4
Xmerge862 net543 clknet_4_11_0_clk net329 VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__dlrtp_1
Xmerge895 net76 clknet_4_15_0_clk net679 VGND VGND VPWR VPWR net817 sky130_fd_sc_hd__dlrtn_2
Xmerge884 clknet_4_13_0_clk net683 net712 VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__dfstp_1
XFILLER_0_28_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs990 net734 clknet_4_1_0_clk VGND VGND VPWR VPWR net927 net926 sky130_fd_sc_hd__dlxbp_1
XTAP_TAPCELL_ROW_97_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net230_X clknet_1_1__leaf_net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge823_S0 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c185_B net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c352_B net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net340 clknet_0_net340 VGND VGND VPWR VPWR clknet_1_0__leaf_net340
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net362 clknet_0_net362 VGND VGND VPWR VPWR clknet_1_0__leaf_net362
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net373 clknet_0_net373 VGND VGND VPWR VPWR clknet_1_0__leaf_net373
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_80_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c717_A3 net578 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout130 net240 VGND VGND VPWR VPWR net1058 sky130_fd_sc_hd__clkbuf_8
XANTENNA_c79_A1 net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge780_A2 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc171 net121 net1048 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__xnor2_1
Xc160 net109 net107 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__xor2_1
XANTENNA_merge916_Q net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc193 clknet_1_1__leaf_net136 net142 net7 net107 net128 net931 VGND VGND VPWR VPWR
+ net143 sky130_fd_sc_hd__mux4_2
Xc182 net105 net125 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__xor2_1
XFILLER_0_85_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap111_X net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c241_S0 net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c117_S net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_72_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c760_A0 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input36_A in40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net316 clknet_0_net316 VGND VGND VPWR VPWR clknet_1_1__leaf_net316
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge775_A2 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge791_A1 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap127 net1024 VGND VGND VPWR VPWR net1055 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_52_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge820_S1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c315_B net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c564_A1 net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout109_X net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c739_A1 clknet_1_1__leaf_net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c755_A0 net568 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c56_Y net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c193_A2 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_34_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap119_A net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge815_S1 net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_0_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_5_0_clk_X clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_46_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c725_A3 clknet_1_1__leaf_net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc704 clknet_1_1__leaf_net598 net468 clknet_1_0__leaf_net582 net480 net905 VGND VGND
+ VPWR VPWR net607 sky130_fd_sc_hd__a41o_1
XFILLER_0_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc737 net642 net536 clknet_1_0__leaf_net643 net517 net911 VGND VGND VPWR VPWR net644
+ sky130_fd_sc_hd__a41oi_2
Xc715 clknet_1_1__leaf_net582 net610 clknet_1_0__leaf_net617 net1029 net614 VGND VGND
+ VPWR VPWR net619 sky130_fd_sc_hd__a41o_1
Xc726 net519 clknet_1_1__leaf_net617 clknet_1_1__leaf_net565 net1035 clknet_1_1__leaf_net453
+ net909 VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__mux4_4
Xc759 net634 clknet_1_1__leaf_net655 net1045 clknet_1_1__leaf_net860 clknet_1_0__leaf_net900
+ net918 VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__mux4_1
Xc748 net1040 net609 net422 net837 clknet_1_0__leaf_net899 net915 VGND VGND VPWR VPWR
+ net655 sky130_fd_sc_hd__mux4_4
XPHY_EDGE_ROW_55_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c460_A3 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c87_A1 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c469_A1 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c604_S0 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_80_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_64_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c485_B1 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c504_Q net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c635_A3 net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net881 net881 VGND VGND VPWR VPWR clknet_0_net881 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_78_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_73_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge829_Q net738 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c370_A3 net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge926_GATE clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_91_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge826_S0 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c494_D net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c561_A2 net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c289_A1 net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_37_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c455_A3 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c752_A1 net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc501 net438 net435 net322 net427 net837 net1101 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_9_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc534 net980 net450 VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__xnor2_2
Xc545 net820 VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__inv_2
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc556 net850 VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__inv_2
Xc567 net476 net484 clknet_1_0__leaf_net366 net467 net249 net844 VGND VGND VPWR VPWR
+ net489 sky130_fd_sc_hd__mux4_2
Xc589 clknet_1_1__leaf_net510 net502 net1030 net477 net1032 net877 VGND VGND VPWR
+ VPWR net512 sky130_fd_sc_hd__mux4_4
Xc578 net260 net266 VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__xor2_1
XANTENNA_c471_A2 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge833_CLK_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge783_A2 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net230_X clknet_1_0__leaf_net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c716_SCD net593 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net566 clknet_0_net566 VGND VGND VPWR VPWR clknet_1_0__leaf_net566
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net577 clknet_0_net577 VGND VGND VPWR VPWR clknet_1_0__leaf_net577
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c280_X net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge878_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc320 net265 net257 net268 net264 net242 clknet_1_0__leaf_net262 VGND VGND VPWR VPWR
+ net269 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_75_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc353 net281 net181 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__xor2_2
Xc331 net164 net216 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__xor2_4
Xc342 net746 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc397 net96 net814 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__xor2_4
Xc364 clknet_4_14_0_clk net306 net295 net310 net1046 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__sdfrtp_4
Xc386 net200 net972 clknet_1_1__leaf_net1025 net1020 net1007 net1004 VGND VGND VPWR
+ VPWR net329 sky130_fd_sc_hd__mux4_1
XFILLER_0_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_13_0_clk_X clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_86_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge830 net436 net437 VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__xnor2_2
Xmerge863 clknet_4_15_0_clk net776 net702 VGND VGND VPWR VPWR net1017 net778 sky130_fd_sc_hd__edfxbp_1
Xmerge852 net234 clknet_4_5_0_clk net691 VGND VGND VPWR VPWR net767 net766 sky130_fd_sc_hd__dlrbp_2
XFILLER_0_7_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge841 net669 net656 VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__xnor2_4
XFILLER_0_28_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge896 net625 clknet_4_2_0_clk net806 VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__dlrtn_2
Xmerge874 net548 net664 VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__xor2_1
Xmerge885 net527 net558 VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__xnor2_4
XFILLER_0_43_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs980 clknet_4_8_0_clk net645 VGND VGND VPWR VPWR net913 net912 sky130_fd_sc_hd__dfxbp_1
Xs991 net736 clknet_4_0_0_clk VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_70_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_97_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge823_S1 net738 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c178_B net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c567_A1 net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net385 clknet_0_net385 VGND VGND VPWR VPWR clknet_1_0__leaf_net385
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net374 clknet_0_net374 VGND VGND VPWR VPWR clknet_1_0__leaf_net374
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c286_A2 clknet_1_0__leaf_net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c79_A2 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c758_A0 net1080 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_45_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c95_A1 net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc172 net117 net112 net104 net121 net115 net1049 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__mux4_1
Xc161 net953 net109 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__xnor2_2
Xc150 net937 net100 net942 net979 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__a31o_2
Xc183 net125 net6 net122 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__mux2_1
Xc194 net140 net1060 net130 net128 net1034 net938 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__mux4_4
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge818_S1 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c432_S0 net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s948_Q net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c410_X net349 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c744_A2 clknet_1_0__leaf_net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c760_A1 net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input29_A in34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net339 clknet_0_net339 VGND VGND VPWR VPWR clknet_1_1__leaf_net339
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_58_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge791_A2 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output97_A clknet_1_0__leaf_net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_1_0_clk_X clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_net867_A net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c427_S0 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c755_A1 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c490_A1 net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c484_Q net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net136 clknet_0_net136 VGND VGND VPWR VPWR clknet_1_1__leaf_net136
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_7_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net147 clknet_0_net147 VGND VGND VPWR VPWR clknet_1_1__leaf_net147
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c710_DE net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c368_A3 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c384_A2 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c281_RESET_B net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c278_A3 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c425_B net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_101_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc738 net640 net1057 net536 clknet_1_0__leaf_net643 clknet_1_0__leaf_net830 net909
+ VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__mux4_1
Xc716 clknet_4_2_0_clk clknet_1_1__leaf_net452 net1083 net593 net1037 VGND VGND VPWR
+ VPWR net621 net620 sky130_fd_sc_hd__sdfrbp_1
Xc705 net491 clknet_1_1__leaf_net598 clknet_1_1__leaf_net452 net255 clknet_1_0__leaf_net597
+ net1029 VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__mux4_2
Xc727 clknet_1_1__leaf_net565 clknet_1_0__leaf_net398 clknet_1_1__leaf_net230 clknet_1_0__leaf_net617
+ net1045 net909 VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__mux4_4
XANTENNA_c591_B1 net499 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc749 clknet_1_1__leaf_net565 net606 net1038 net1040 net837 clknet_1_1__leaf_net900
+ VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__mux4_1
XANTENNA_c741_A3 clknet_1_1__leaf_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c469_A2 net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c604_S1 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c483_RESET_B net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_80_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net860 net860 VGND VGND VPWR VPWR clknet_0_net860 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input51_X net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c395_A1 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge826_S1 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c561_A3 net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer10 net764 VGND VGND VPWR VPWR net1078 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_83_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_1_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c289_A2 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_37_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c535_A net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c736_A3 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c692_X net594 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc502 net56 clknet_1_1__leaf_net425 net427 net166 net800 net837 VGND VGND VPWR VPWR
+ net443 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_9_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc546 clknet_4_1_0_clk clknet_1_0__leaf_net456 net221 clknet_1_0__leaf_net462 clknet_1_0__leaf_net1025
+ clknet_1_0__leaf_net880 VGND VGND VPWR VPWR net468 net467 sky130_fd_sc_hd__sdfbbp_1
Xc535 net88 clknet_1_1__leaf_net880 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__xor2_4
Xc568 clknet_4_0_0_clk net486 clknet_1_0__leaf_net481 net1076 net857 VGND VGND VPWR
+ VPWR net491 net490 sky130_fd_sc_hd__sedfxbp_1
Xc557 net476 net249 net336 net979 VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__a31oi_1
Xc579 clknet_4_1_0_clk net364 net268 clknet_1_0__leaf_net270 net1022 net483 VGND VGND
+ VPWR VPWR net502 net501 sky130_fd_sc_hd__sdfbbn_2
XANTENNA_input11_A in18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_SCD net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput90 net1018 VGND VGND VPWR VPWR out46 sky130_fd_sc_hd__buf_2
XFILLER_0_37_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c716_SCE net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net534 clknet_0_net534 VGND VGND VPWR VPWR clknet_1_0__leaf_net534
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net567 clknet_0_net567 VGND VGND VPWR VPWR clknet_1_0__leaf_net567
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c260_S0 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input3_A in10 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c273_X net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c538_X net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c747_A2 net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge765_X net672 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc321 net257 clknet_1_0__leaf_net258 net268 net263 clknet_1_1__leaf_net267 VGND VGND
+ VPWR VPWR net270 sky130_fd_sc_hd__a41oi_2
XANTENNA_c482_A2 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc310 net227 net975 net7 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_75_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc354 net843 VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__clkbuf_1
Xc343 net219 net1046 net1054 VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__o21bai_4
Xc332 net279 net274 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__xnor2_4
Xc387 net70 net324 net180 net1050 net873 net1007 VGND VGND VPWR VPWR net1010 sky130_fd_sc_hd__mux4_1
Xc365 clknet_4_14_0_clk net43 net301 net310 net1041 clknet_1_1__leaf_net1023 VGND
+ VGND VPWR VPWR net315 net314 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_20_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc398 net83 net224 VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_48_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge820 net583 clknet_1_0__leaf_net577 net490 clknet_1_1__leaf_net566 clknet_1_0__leaf_net481
+ net905 VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__mux4_4
XFILLER_0_28_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge864 clknet_4_7_0_clk net732 net707 VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__edfxtp_1
Xmerge831 clknet_4_2_0_clk net611 net618 VGND VGND VPWR VPWR net741 net740 sky130_fd_sc_hd__dfrbp_1
Xmerge842 net591 net605 VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__xnor2_1
Xmerge853 net475 clknet_4_1_0_clk net479 VGND VGND VPWR VPWR net769 net768 sky130_fd_sc_hd__dlrbp_1
XFILLER_0_99_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge897 net320 clknet_4_14_0_clk net750 VGND VGND VPWR VPWR net819 sky130_fd_sc_hd__dlrtp_1
XFILLER_0_70_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge886 clknet_4_2_0_clk net622 net652 VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__dfstp_1
XFILLER_0_28_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge875 net492 net629 VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__xnor2_1
Xs970 clknet_4_8_0_clk net555 VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__dlclkp_2
XFILLER_0_43_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs981 clknet_4_8_0_clk net649 VGND VGND VPWR VPWR net915 net914 sky130_fd_sc_hd__dfxbp_1
Xrebuffer1 net41 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_23_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xnet999_2 clknet_1_1__leaf_net786 VGND VGND VPWR VPWR net1065 sky130_fd_sc_hd__inv_8
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net342 clknet_0_net342 VGND VGND VPWR VPWR clknet_1_0__leaf_net342
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net375 clknet_0_net375 VGND VGND VPWR VPWR clknet_1_0__leaf_net375
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c286_A3 net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c668_B1_N clknet_1_0__leaf_net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout110 net1026 VGND VGND VPWR VPWR net1038 sky130_fd_sc_hd__clkbuf_8
XANTENNA_input6_X net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c104_B1 net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c758_A1 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_45_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c95_A2 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc151 net758 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__inv_6
Xc162 net947 net977 net112 net89 net110 net109 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__mux4_1
Xc140 net89 net937 net90 net940 net931 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__a41oi_1
Xc184 net950 net971 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__xor2_1
Xc195 net142 clknet_1_0__leaf_net137 net1013 clknet_1_0__leaf_net1023 VGND VGND VPWR
+ VPWR net145 sky130_fd_sc_hd__a31o_2
Xc173 net960 net118 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__xnor2_1
XANTENNA_merge789_A2 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c387_A2 net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge926_RESET_B net708 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c288_B net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c324_Q_N net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c432_S1 net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net183 clknet_0_net183 VGND VGND VPWR VPWR clknet_1_0__leaf_net183
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net194 clknet_0_net194 VGND VGND VPWR VPWR clknet_1_0__leaf_net194
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c760_A2 net606 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c623_S0 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmax_cap129 net4 VGND VGND VPWR VPWR net1057 sky130_fd_sc_hd__buf_4
XFILLER_0_33_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net830 clknet_0_net830 VGND VGND VPWR VPWR clknet_1_1__leaf_net830
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c679_A0 net570 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c580_A2 net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c398_A net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c427_S1 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c709_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input41_A in45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c337_S1 net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net137 clknet_0_net137 VGND VGND VPWR VPWR clknet_1_1__leaf_net137
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_7_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net919 clknet_0_net919 VGND VGND VPWR VPWR clknet_1_0__leaf_net919
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_57_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s932_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c384_A3 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net316 net316 VGND VGND VPWR VPWR clknet_0_net316 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c418_B net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_60_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout114_X net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc717 clknet_1_0__leaf_net616 net614 net578 net585 net908 VGND VGND VPWR VPWR net622
+ sky130_fd_sc_hd__a41oi_2
Xc728 clknet_4_2_0_clk net941 net536 net1038 clknet_1_0__leaf_net381 net856 VGND VGND
+ VPWR VPWR net634 net633 sky130_fd_sc_hd__sdfbbn_1
Xc706 clknet_4_2_0_clk net1030 clknet_1_1__leaf_net577 clknet_1_1__leaf_net452 net858
+ VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__sedfxtp_4
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c682_A net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc739 net518 clknet_1_1__leaf_net453 clknet_1_0__leaf_net643 net539 net855 net905
+ VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__mux4_2
XFILLER_0_97_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_80_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_S1 net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c485_A2 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c54_X net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_78_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c348_S0 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input44_X net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c705_S1 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer11 net424 VGND VGND VPWR VPWR net1079 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_65_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s977_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c528_A net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c316_X net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc503 net435 net404 net165 net431 net848 net1102 VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_9_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c670_SCE net570 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc558 net954 net1022 net455 clknet_1_0__leaf_net474 net1033 net797 VGND VGND VPWR
+ VPWR net479 sky130_fd_sc_hd__mux4_4
Xc569 net480 net486 net1022 net363 net768 net844 VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__mux4_1
Xc547 net856 VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__buf_1
XANTENNA_c471_A4 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c631_S0 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_output72_A net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput80 net1056 VGND VGND VPWR VPWR out35 sky130_fd_sc_hd__buf_2
Xoutput91 clknet_1_1__leaf_net1019 VGND VGND VPWR VPWR out47 sky130_fd_sc_hd__clkbuf_1
XANTENNA_max_cap127_X net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_62_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net535 clknet_0_net535 VGND VGND VPWR VPWR clknet_1_0__leaf_net535
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c121_RESET_B net32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c266_X net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c747_A3 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc311 net772 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__clkinv_8
Xc300 net236 net946 net954 net242 net233 net241 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__mux4_1
Xc322 net833 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__buf_16
XTAP_TAPCELL_ROW_75_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc344 net130 net1046 net1035 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__o21bai_2
Xc333 net256 net273 net1054 net879 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__a31oi_4
Xc388 net179 net180 net1050 net207 net1005 net1004 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__mux4_1
Xc366 net309 net306 net994 net302 net1046 VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__a41o_4
Xc355 clknet_4_12_0_clk net174 net165 net1011 net1107 clknet_1_1__leaf_net1023 VGND
+ VGND VPWR VPWR net305 net304 sky130_fd_sc_hd__sdfbbp_1
XANTENNA_c292_Q net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c626_S0 net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc399 net936 net83 VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_48_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge821 net38 net27 net12 net14 net21 net29 VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__mux4_1
XANTENNA_s960_GATE_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge810 clknet_1_0__leaf_net230 net213 net215 net219 net874 VGND VGND VPWR VPWR
+ net718 sky130_fd_sc_hd__a41o_1
Xmerge843 clknet_4_7_0_clk net143 net145 VGND VGND VPWR VPWR net754 net753 sky130_fd_sc_hd__dfsbp_2
Xmerge854 net232 clknet_4_5_0_clk net686 VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__dlrtn_2
XFILLER_0_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge832 net504 net506 VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__xor2_1
Xmerge887 net624 net549 VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__xor2_1
Xmerge865 clknet_4_11_0_clk net544 merge865/SCE VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__sdlclkp_1
Xmerge876 clknet_4_3_0_clk net493 net709 VGND VGND VPWR VPWR net793 net792 sky130_fd_sc_hd__dfrbp_1
Xs960 net395 clknet_4_6_0_clk VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__dlxtn_2
XFILLER_0_99_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs982 clknet_4_8_0_clk net650 VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_11_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs971 clknet_4_10_0_clk net560 VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_36_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge898 net251 clknet_4_5_0_clk net785 VGND VGND VPWR VPWR net820 sky130_fd_sc_hd__dlrtp_4
Xrebuffer2 net218 VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_net999_3_A clknet_1_1__leaf_net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c392_A3 net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xnet999_3 clknet_1_1__leaf_net786 VGND VGND VPWR VPWR net1066 sky130_fd_sc_hd__inv_8
XANTENNA_hold12_A net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net321 clknet_0_net321 VGND VGND VPWR VPWR clknet_1_0__leaf_net321
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net365 clknet_0_net365 VGND VGND VPWR VPWR clknet_1_0__leaf_net365
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c233_B net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net398 clknet_0_net398 VGND VGND VPWR VPWR clknet_1_0__leaf_net398
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_88_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c226_A net854 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c583_A2 net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c400_B net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c64_S0 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout122 net71 VGND VGND VPWR VPWR net1050 sky130_fd_sc_hd__clkbuf_4
Xfanout133 net1063 VGND VGND VPWR VPWR net1061 sky130_fd_sc_hd__clkbuf_8
XANTENNA_c681_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c550_X net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_45_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c120_B1 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge919_GATE_N clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c493_A2 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc163 net796 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__buf_6
Xc130 net63 net79 net1063 net743 net817 net865 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__mux4_4
Xc141 net943 net977 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__xnor2_2
Xc152 net99 net95 net952 net85 net815 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__a41o_2
XFILLER_0_20_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc196 clknet_1_1__leaf_net137 net753 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__xor2_4
Xc174 net779 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__buf_1
Xc185 net128 net975 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c387_A3 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c607_SCE net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c205_A0 net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c350_B net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c236_Y net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c115_B1 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c623_S1 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge791_A4 net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap108 net115 VGND VGND VPWR VPWR net1036 sky130_fd_sc_hd__buf_4
Xmax_cap119 net219 VGND VGND VPWR VPWR net1047 sky130_fd_sc_hd__buf_4
XFILLER_0_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout104_A net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c755_A3 net609 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c618_S1 net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c490_A3 clknet_1_1__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c372_Q net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input34_A in39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc90 net977 net978 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__xnor2_2
XFILLER_0_97_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c68_S net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net339 net339 VGND VGND VPWR VPWR clknet_0_net339 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_32_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_15_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc718 clknet_1_1__leaf_net597 net978 clknet_1_0__leaf_net598 net614 net613 VGND VGND
+ VPWR VPWR net623 sky130_fd_sc_hd__a41o_4
Xc707 net468 net1042 net2 clknet_1_1__leaf_net453 net568 VGND VGND VPWR VPWR net610
+ sky130_fd_sc_hd__a41o_4
Xc729 net2 net594 clknet_1_1__leaf_net230 net1040 c729/B1 VGND VGND VPWR VPWR net635
+ sky130_fd_sc_hd__a41oi_4
XANTENNA_c591_A2 net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout107_X net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c682_B net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_68_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c99_B net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c485_A3 net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input37_X net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge797_A3 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c728_SCD net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_60_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net136 net136 VGND VGND VPWR VPWR clknet_0_net136 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net147 net147 VGND VGND VPWR VPWR clknet_0_net147 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc537 net353 clknet_1_1__leaf_net456 VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__xnor2_4
Xc504 clknet_4_11_0_clk clknet_1_1__leaf_net391 net801 net1099 VGND VGND VPWR VPWR
+ net446 net445 sky130_fd_sc_hd__dfbbn_1
Xc548 net465 net353 net467 clknet_1_0__leaf_net462 clknet_1_0__leaf_net464 net883
+ VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__mux4_2
Xc559 clknet_4_1_0_clk net472 net249 net239 net1036 VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__sdfstp_4
XANTENNA_c678_X net580 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput70 net998 VGND VGND VPWR VPWR out25 sky130_fd_sc_hd__buf_2
Xoutput92 net1020 VGND VGND VPWR VPWR out48 sky130_fd_sc_hd__clkbuf_4
Xoutput81 net1009 VGND VGND VPWR VPWR out36 sky130_fd_sc_hd__clkbuf_4
XANTENNA_output65_A net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c208_B1 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c732_S0 net536 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c540_A net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c324_SET_B net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc312 net772 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__clkbuf_4
Xc301 net766 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__inv_2
XFILLER_0_20_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc345 net291 net1046 net1086 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__o21ba_2
XTAP_TAPCELL_ROW_75_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc323 net820 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__clkbuf_1
Xc334 net7 net283 net1035 net166 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__a31o_1
Xc356 net843 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__clkbuf_2
Xc367 net176 net312 net871 VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__mux2_2
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc389 net324 net994 net1050 net873 net1007 net1004 VGND VGND VPWR VPWR net989 sky130_fd_sc_hd__mux4_1
XANTENNA_c626_S1 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c300_A1 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge800 net94 net148 net40 net44 VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__a31oi_2
Xmerge811 net304 net182 net1046 net288 net300 net302 VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__mux4_4
Xmerge833 clknet_4_15_0_clk net67 net68 VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__dfrtn_1
Xmerge855 net178 clknet_4_13_0_clk net188 VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__dlrtn_1
XFILLER_0_23_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmerge822 net86 net336 net1031 net489 net595 net1039 VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__mux4_2
XFILLER_0_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge844 net382 net392 VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__xnor2_1
Xmerge877 clknet_4_7_0_clk net721 net749 VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__dfrtn_1
Xmerge866 clknet_4_12_0_clk net319 net719 VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__sdlclkp_2
Xmerge888 net537 net663 VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__xnor2_4
Xs961 net411 clknet_4_12_0_clk VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__dlxtn_1
Xs950 clknet_4_12_0_clk net287 VGND VGND VPWR VPWR net1006 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_82_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_11_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs983 clknet_4_8_0_clk net651 VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__dfxtp_1
Xs972 net581 clknet_4_0_0_clk VGND VGND VPWR VPWR net902 net901 sky130_fd_sc_hd__dlxbn_1
Xmerge899 net407 clknet_4_9_0_clk net417 VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__dlrtp_1
XFILLER_0_51_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer3 net41 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xnet999_4 clknet_1_0__leaf_net786 VGND VGND VPWR VPWR net1067 sky130_fd_sc_hd__inv_8
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net333 clknet_0_net333 VGND VGND VPWR VPWR clknet_1_0__leaf_net333
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net366 clknet_0_net366 VGND VGND VPWR VPWR clknet_1_0__leaf_net366
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net399 clknet_0_net399 VGND VGND VPWR VPWR clknet_1_0__leaf_net399
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net388 clknet_0_net388 VGND VGND VPWR VPWR clknet_1_0__leaf_net388
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_80_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout134_A net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c583_A3 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c727_S0 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout112 net166 VGND VGND VPWR VPWR net1040 sky130_fd_sc_hd__buf_4
XFILLER_0_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout101 net511 VGND VGND VPWR VPWR net1029 sky130_fd_sc_hd__buf_2
Xfanout123 net71 VGND VGND VPWR VPWR net1051 sky130_fd_sc_hd__clkbuf_2
Xfanout134 net962 VGND VGND VPWR VPWR net1062 sky130_fd_sc_hd__buf_4
XANTENNA_c104_A2 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c758_A3 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c74_A net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc120 net45 net1011 net66 net50 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__a31o_1
XFILLER_0_33_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc153 clknet_4_5_0_clk net86 net101 net102 net90 net1094 VGND VGND VPWR VPWR net105
+ net104 sky130_fd_sc_hd__sdfbbp_1
Xc131 net60 net80 net1051 net50 net865 net986 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__mux4_2
Xc142 net90 net88 net978 net939 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__a31oi_1
Xc164 net109 net814 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__xor2_2
Xc175 net125 net121 net1041 net109 net112 net796 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__mux4_1
Xc186 clknet_1_0__leaf_net786 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dlygate4sd3_1
Xc197 net146 net130 net1059 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__a21bo_4
XFILLER_0_87_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c684_A2 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c205_A1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge858_GATE clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c660_X net561 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_6_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c277_S0 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge800_A1 net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c724_S1 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c589_A2 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input27_A in32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c499_A2 net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc80 net25 net22 net19 VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__o21ai_4
Xc91 net939 net1043 net17 net32 VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__a31o_1
XFILLER_0_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output95_A clknet_1_1__leaf_net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c153_D net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc708 clknet_1_1__leaf_net577 clknet_1_1__leaf_net597 net584 clknet_1_0__leaf_net398
+ VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__a31o_4
Xc719 net584 clknet_1_0__leaf_net623 net606 net1057 net858 VGND VGND VPWR VPWR net624
+ sky130_fd_sc_hd__a41oi_4
XFILLER_0_31_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net830 net830 VGND VGND VPWR VPWR clknet_0_net830 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge782_S0 net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c303_A1 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c728_SCE clknet_1_0__leaf_net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c56_B1_N net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s943_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_1 net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net481 clknet_0_net481 VGND VGND VPWR VPWR clknet_1_1__leaf_net481
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_65_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net137 net137 VGND VGND VPWR VPWR clknet_0_net137 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge806_A0 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc505 clknet_4_11_0_clk net444 net442 net445 net426 net293 VGND VGND VPWR VPWR net448
+ net447 sky130_fd_sc_hd__sdfbbn_1
Xc538 net773 VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__dlygate4sd1_1
Xc549 net469 net468 clknet_1_0__leaf_net462 net353 net891 VGND VGND VPWR VPWR net471
+ sky130_fd_sc_hd__a41oi_4
XFILLER_0_99_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c79_B1_N net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_14_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput60 net988 VGND VGND VPWR VPWR out15 sky130_fd_sc_hd__buf_2
Xoutput93 net1021 VGND VGND VPWR VPWR out49 sky130_fd_sc_hd__buf_2
Xoutput82 net1010 VGND VGND VPWR VPWR out37 sky130_fd_sc_hd__buf_2
Xoutput71 net999 VGND VGND VPWR VPWR out26 sky130_fd_sc_hd__buf_2
XANTENNA_output58_A net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c343_B1_N net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc302 net933 net243 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_75_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc335 net150 net279 net1035 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__o21ai_1
Xc313 clknet_1_1__leaf_net258 net255 net138 net1056 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__a31oi_1
XFILLER_0_20_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc324 clknet_4_6_0_clk clknet_1_0__leaf_net267 clknet_1_0__leaf_net136 clknet_1_0__leaf_net262
+ net250 net877 VGND VGND VPWR VPWR net274 net273 sky130_fd_sc_hd__sdfbbn_2
Xc357 net302 net182 net306 net870 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__a31o_1
Xc368 net308 net311 net317 net186 net288 net174 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__mux4_2
Xc346 net1035 net1046 net836 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__a21o_1
XFILLER_0_87_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c300_A2 net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge812 net8 net964 net19 net155 net162 net158 VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__mux4_4
XFILLER_0_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge801 clknet_1_1__leaf_net454 net580 net561 net298 net1001 net26 VGND VGND VPWR
+ VPWR net709 sky130_fd_sc_hd__mux4_1
XFILLER_0_95_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge834 net123 net670 VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__xnor2_1
Xmerge845 clknet_4_4_0_clk net351 net354 VGND VGND VPWR VPWR net757 net756 sky130_fd_sc_hd__dfsbp_2
Xmerge823 net132 net971 net265 net570 net1037 net738 VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__mux4_2
Xs940 net163 clknet_4_13_0_clk VGND VGND VPWR VPWR net869 net868 sky130_fd_sc_hd__dlxbn_1
Xmerge856 net275 clknet_4_7_0_clk net693 VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__dlrtn_2
Xmerge878 clknet_4_2_0_clk net626 net619 VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__dfrtp_1
Xmerge867 net487 net514 VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__xnor2_1
Xs951 clknet_4_14_0_clk net327 VGND VGND VPWR VPWR net1007 sky130_fd_sc_hd__dfxtp_4
Xs984 clknet_4_8_0_clk net662 VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__dfxtp_2
Xs973 net600 clknet_4_0_0_clk VGND VGND VPWR VPWR net904 net903 sky130_fd_sc_hd__dlxbn_1
Xs962 net440 clknet_4_14_0_clk VGND VGND VPWR VPWR net890 sky130_fd_sc_hd__dlxtp_1
Xmerge889 clknet_4_6_0_clk net755 net706 VGND VGND VPWR VPWR net808 sky130_fd_sc_hd__dfstp_1
XTAP_TAPCELL_ROW_11_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer4 net457 VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_51_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_max_cap132_X net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xnet999_5 clknet_1_0__leaf_net786 VGND VGND VPWR VPWR net1068 sky130_fd_sc_hd__inv_8
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net367 clknet_0_net367 VGND VGND VPWR VPWR clknet_1_0__leaf_net367
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_s980_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge803_A1 net165 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c727_S1 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout113 net983 VGND VGND VPWR VPWR net1041 sky130_fd_sc_hd__buf_4
XFILLER_0_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout102 net511 VGND VGND VPWR VPWR net1030 sky130_fd_sc_hd__buf_2
Xfanout135 net962 VGND VGND VPWR VPWR net1063 sky130_fd_sc_hd__clkbuf_4
XANTENNA_input1_A in0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c120_A2 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc110 net20 net5 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__xor2_1
XFILLER_0_33_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc154 net964 net104 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__xnor2_4
Xc121 clknet_4_15_0_clk net65 net32 net64 net63 net45 VGND VGND VPWR VPWR net70 net69
+ sky130_fd_sc_hd__sdfbbn_1
Xc143 net87 net943 net815 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__a21oi_4
Xc132 net952 net932 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__xor2_4
XFILLER_0_20_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc187 net114 clknet_1_1__leaf_net136 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__xnor2_4
Xc165 net796 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__buf_16
Xc176 net684 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__inv_8
Xc198 net803 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__inv_1
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c562_Q net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_2_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c336_B net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s953_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input4_X net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge785_S0 net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net866 clknet_0_net866 VGND VGND VPWR VPWR clknet_1_1__leaf_net866
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net899 clknet_0_net899 VGND VGND VPWR VPWR clknet_1_1__leaf_net899
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge917_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s935_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c558_S0 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c232_B1 net869 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c589_A3 net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge908_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c234_X net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c86_S0 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c407_B1 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c452_SCE clknet_1_0__leaf_net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c142_B1 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc70 net944 net929 net1043 VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__a21bo_2
XFILLER_0_97_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc81 net22 net25 net24 net17 net0 VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__a41oi_2
Xc92 net839 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__inv_4
XFILLER_0_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_60_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c201_B net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc709 clknet_4_2_0_clk net588 net609 clknet_1_0__leaf_net230 net480 clknet_1_1__leaf_net452
+ VGND VGND VPWR VPWR net613 net612 sky130_fd_sc_hd__sdfbbn_1
XANTENNA_c591_A4 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge811_A1 net182 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge782_S1 net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_10_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_100_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_5_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_1_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c571_S0 net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_65_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_334 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge806_A1 net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout112_X net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s974_Q_N net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge822_A0 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc528 net227 net344 VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__xnor2_1
Xc539 net925 VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__buf_6
XFILLER_0_86_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput61 net989 VGND VGND VPWR VPWR out16 sky130_fd_sc_hd__buf_2
Xoutput83 net1011 VGND VGND VPWR VPWR out39 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c307_CLK_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput72 net1000 VGND VGND VPWR VPWR out27 sky130_fd_sc_hd__buf_2
Xoutput94 net1022 VGND VGND VPWR VPWR out5 sky130_fd_sc_hd__buf_2
XFILLER_0_37_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c693_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c566_S0 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c199_B net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c419_Y net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc303 net246 net217 net245 net250 net241 clknet_1_1__leaf_net866 VGND VGND VPWR VPWR
+ net251 sky130_fd_sc_hd__mux4_4
Xc336 net216 net256 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__xnor2_1
Xc314 net820 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__clkbuf_1
Xc325 net263 clknet_1_1__leaf_net270 net265 net1056 net1054 net877 VGND VGND VPWR
+ VPWR net275 sky130_fd_sc_hd__mux4_1
XFILLER_0_60_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc347 net746 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__inv_2
Xc369 net1059 net317 net313 net1011 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__a31o_1
Xc358 net781 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__buf_12
XANTENNA_c415_B1 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c150_B1 net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_86_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge802 net1036 net585 net590 clknet_1_0__leaf_net270 net499 net851 VGND VGND VPWR
+ VPWR net710 sky130_fd_sc_hd__mux4_2
XFILLER_0_67_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge813 net112 net122 net6 net152 net158 net130 VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__mux4_1
Xmerge846 clknet_4_5_0_clk net694 net704 VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__dfstp_2
Xmerge824 net389 clknet_1_1__leaf_net270 net264 net250 net265 net887 VGND VGND VPWR
+ VPWR net732 sky130_fd_sc_hd__mux4_2
Xmerge835 clknet_4_3_0_clk net632 merge835/RESET_B VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_55_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge879 clknet_4_5_0_clk net91 net744 VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__dfrtp_4
Xs941 net190 clknet_4_12_0_clk VGND VGND VPWR VPWR net871 net870 sky130_fd_sc_hd__dlxbn_1
Xmerge868 net751 net668 VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__xnor2_1
Xmerge857 net471 clknet_4_1_0_clk net685 VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__dlrtp_1
Xs952 clknet_4_14_0_clk net328 VGND VGND VPWR VPWR net1004 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_70_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs974 net603 clknet_4_0_0_clk VGND VGND VPWR VPWR net906 net905 sky130_fd_sc_hd__dlxbp_1
Xs985 clknet_4_3_0_clk net710 VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__dlclkp_1
Xs963 net470 clknet_4_1_0_clk VGND VGND VPWR VPWR net891 sky130_fd_sc_hd__lpflow_inputisolatch_1
XTAP_TAPCELL_ROW_11_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer5 net811 VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap125_X net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net335 clknet_0_net335 VGND VGND VPWR VPWR clknet_1_0__leaf_net335
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_80_55 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c307_SCD net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c310_B1_N net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c235_A0 net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge803_A2 net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout103 net1033 VGND VGND VPWR VPWR net1031 sky130_fd_sc_hd__clkbuf_4
Xfanout114 net590 VGND VGND VPWR VPWR net1042 sky130_fd_sc_hd__buf_4
XANTENNA_c271_Y net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net880 clknet_0_net880 VGND VGND VPWR VPWR clknet_1_0__leaf_net880
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c703_Y net606 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc111 net20 net1096 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__xnor2_2
Xc100 net854 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_2
Xc122 net831 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__buf_1
Xc133 net939 net943 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__xor2_2
Xc144 net933 net85 net796 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__o21ai_4
Xc166 net933 net1049 net964 net109 net1061 net932 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__mux4_4
Xc177 net127 net1048 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__xnor2_4
Xc155 net89 net1049 VGND VGND VPWR VPWR net983 sky130_fd_sc_hd__xor2_4
Xc188 net931 net939 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__xnor2_4
Xc199 net957 net6 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__xnor2_2
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_99_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge880_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c738_S1 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge871_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c709_RESET_B net609 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c754_S0 net609 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c412_A1 clknet_1_0__leaf_net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge785_S1 net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net867 clknet_0_net867 VGND VGND VPWR VPWR clknet_1_1__leaf_net867
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s989_GATE_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c558_S1 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c181_B net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c279_B net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge825_A0 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c749_S0 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_7_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc60 net958 net1013 net975 net7 net970 VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__a41o_1
Xc71 net944 net1043 VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__xor2_4
Xc82 net25 net1043 net24 VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__o21a_1
Xc93 net934 net36 VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge835_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c243_B1 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge811_A2 net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c396_B net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_68_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s972_GATE_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input32_A in37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c303_A3 net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_11_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_100_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge862_Q net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_20_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c213_A3 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_1_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c571_S1 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_37_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c137_A net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge806_A2 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge822_A1 net336 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc529 net773 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__buf_2
XANTENNA_fanout105_X net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c399_Y net338 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c230_S net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge793_S1 net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput73 net1001 VGND VGND VPWR VPWR out28 sky130_fd_sc_hd__clkbuf_4
Xoutput84 net1012 VGND VGND VPWR VPWR out4 sky130_fd_sc_hd__clkbuf_1
Xoutput62 clknet_1_0__leaf_net990 VGND VGND VPWR VPWR out17 sky130_fd_sc_hd__clkbuf_1
Xoutput95 clknet_1_1__leaf_net1023 VGND VGND VPWR VPWR out50 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input35_X net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_62_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_hold40_A net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c240_A1 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c421_A net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc326 net257 net268 net271 clknet_1_0__leaf_net262 net242 net772 VGND VGND VPWR VPWR
+ net276 sky130_fd_sc_hd__mux4_4
Xc315 net242 net965 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__xor2_1
Xc304 net787 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__buf_4
Xc348 net286 net938 net255 net1046 net1035 net878 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__mux4_2
Xc337 net18 clknet_1_1__leaf_net262 net283 net1041 net284 net255 VGND VGND VPWR VPWR
+ net287 sky130_fd_sc_hd__mux4_1
Xc359 net781 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_99_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge803 clknet_1_1__leaf_net262 net165 net295 net250 net261 net264 VGND VGND VPWR
+ VPWR net711 sky130_fd_sc_hd__mux4_4
XFILLER_0_67_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge825 net19 net1011 net58 net60 net59 net765 VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__mux4_1
Xmerge814 net49 net1103 net53 net32 net59 net948 VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__mux4_2
Xmerge836 clknet_4_12_0_clk net690 net711 VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_23_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge847 clknet_4_13_0_clk net51 net52 VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__dfstp_2
Xs942 net205 clknet_4_14_0_clk VGND VGND VPWR VPWR net873 net872 sky130_fd_sc_hd__dlxbp_1
Xmerge858 net540 clknet_4_11_0_clk net542 VGND VGND VPWR VPWR net982 sky130_fd_sc_hd__dlrtp_1
Xmerge869 net439 net443 VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__xor2_2
XANTENNA_c309_A2 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs953 clknet_4_14_0_clk net332 VGND VGND VPWR VPWR net992 sky130_fd_sc_hd__dlclkp_1
Xs975 net608 clknet_4_2_0_clk VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__dlxtn_1
Xs986 clknet_4_0_0_clk net714 VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__dlclkp_2
Xs964 clknet_4_1_0_clk net482 VGND VGND VPWR VPWR net893 net892 sky130_fd_sc_hd__dfxbp_1
XTAP_TAPCELL_ROW_11_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net481 net481 VGND VGND VPWR VPWR clknet_0_net481 sky130_fd_sc_hd__clkbuf_16
Xrebuffer6 net1044 VGND VGND VPWR VPWR net1074 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output63_A net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge803_A3 net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout104 net1033 VGND VGND VPWR VPWR net1032 sky130_fd_sc_hd__buf_4
Xfanout115 net13 VGND VGND VPWR VPWR net1043 sky130_fd_sc_hd__buf_4
XFILLER_0_96_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c546_SCE clknet_1_0__leaf_net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net881 clknet_0_net881 VGND VGND VPWR VPWR clknet_1_0__leaf_net881
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_0_net990_X clknet_0_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc101 clknet_4_13_0_clk net27 net46 net218 net44 net38 VGND VGND VPWR VPWR net48 net47
+ sky130_fd_sc_hd__sdfbbn_2
Xc112 net672 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__buf_1
Xc123 clknet_4_15_0_clk net66 net65 net1051 net743 VGND VGND VPWR VPWR net73 net72
+ sky130_fd_sc_hd__sdfrbp_1
Xc134 net943 net942 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__xnor2_2
Xc145 net84 net940 net815 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__mux2_4
XFILLER_0_20_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc178 net105 net128 VGND VGND VPWR VPWR net1020 sky130_fd_sc_hd__xor2_4
Xc156 net106 net814 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__xor2_4
Xc167 net758 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__clkbuf_4
Xc189 net956 net134 clknet_1_1__leaf_net136 net128 net114 net1034 VGND VGND VPWR VPWR
+ net139 sky130_fd_sc_hd__mux4_4
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_3_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c412_A2 net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c131_A3 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_67_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_94_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_76_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c603_A1 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_85_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_444 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c505_SET_B net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c590_S0 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge825_A1 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout135_X net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net786_X clknet_0_net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c704_B1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c142_A2 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc94 net32 net15 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__xnor2_4
Xc72 net798 VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkinv_8
Xc83 net826 VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_2
Xc61 net3 net2 net7 net1061 VGND VGND VPWR VPWR net1026 sky130_fd_sc_hd__a31o_1
XFILLER_0_38_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge796_S1 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c614_B1 net536 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c333_A1 net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net643 clknet_0_net643 VGND VGND VPWR VPWR clknet_1_1__leaf_net643
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c243_A1 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c291_B net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c177_Y net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c609_Y net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net866 net866 VGND VGND VPWR VPWR clknet_0_net866 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_7_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net899 net899 VGND VGND VPWR VPWR clknet_0_net899 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold40 net94 VGND VGND VPWR VPWR net1108 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input25_A in30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_1_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net462 clknet_0_net462 VGND VGND VPWR VPWR clknet_1_1__leaf_net462
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c137_B net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge822_A2 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c429_B1 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput85 net1013 VGND VGND VPWR VPWR out41 sky130_fd_sc_hd__clkbuf_4
Xoutput63 net991 VGND VGND VPWR VPWR out18 sky130_fd_sc_hd__buf_2
Xoutput74 net1002 VGND VGND VPWR VPWR out29 sky130_fd_sc_hd__buf_2
Xoutput96 net1055 VGND VGND VPWR VPWR out51 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_98_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c339_A0 net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
.ends
