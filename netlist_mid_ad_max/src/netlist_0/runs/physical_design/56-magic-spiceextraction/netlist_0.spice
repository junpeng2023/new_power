* NGSPICE file created from netlist_0.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_1 abstract view
.subckt sky130_fd_sc_hd__dlrtp_1 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_4 abstract view
.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_2 abstract view
.subckt sky130_fd_sc_hd__dlrtn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_2 abstract view
.subckt sky130_fd_sc_hd__dfsbp_2 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_2 abstract view
.subckt sky130_fd_sc_hd__dlxtn_2 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_1 abstract view
.subckt sky130_fd_sc_hd__dlxbn_1 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtp_1 abstract view
.subckt sky130_fd_sc_hd__dlxtp_1 D GATE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_2 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_2 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfbbn_2 abstract view
.subckt sky130_fd_sc_hd__dfbbn_2 CLK_N D RESET_B SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_4 abstract view
.subckt sky130_fd_sc_hd__a2111oi_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_2 abstract view
.subckt sky130_fd_sc_hd__or4bb_2 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_2 abstract view
.subckt sky130_fd_sc_hd__a2111o_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_2 abstract view
.subckt sky130_fd_sc_hd__a2111oi_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_2 abstract view
.subckt sky130_fd_sc_hd__dlxbn_2 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_2 abstract view
.subckt sky130_fd_sc_hd__dfstp_2 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbp_1 abstract view
.subckt sky130_fd_sc_hd__dlxbp_1 D GATE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__lpflow_inputisolatch_1 abstract view
.subckt sky130_fd_sc_hd__lpflow_inputisolatch_1 D SLEEP_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_1 abstract view
.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_4 abstract view
.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_4 abstract view
.subckt sky130_fd_sc_hd__mux4_4 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_2 abstract view
.subckt sky130_fd_sc_hd__dlrtp_2 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_2 abstract view
.subckt sky130_fd_sc_hd__dlrbn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_2 abstract view
.subckt sky130_fd_sc_hd__dfxbp_2 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_1 abstract view
.subckt sky130_fd_sc_hd__dlclkp_1 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_1 abstract view
.subckt sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_4 abstract view
.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_4 abstract view
.subckt sky130_fd_sc_hd__a2111o_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_2 abstract view
.subckt sky130_fd_sc_hd__o2111a_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_4 abstract view
.subckt sky130_fd_sc_hd__o2111a_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_4 abstract view
.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_1 abstract view
.subckt sky130_fd_sc_hd__dlrbn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxbp_1 abstract view
.subckt sky130_fd_sc_hd__edfxbp_1 CLK D DE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_1 abstract view
.subckt sky130_fd_sc_hd__dfxbp_1 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_2 abstract view
.subckt sky130_fd_sc_hd__dlclkp_2 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfrbp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_4 abstract view
.subckt sky130_fd_sc_hd__dlclkp_4 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_1 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_4 abstract view
.subckt sky130_fd_sc_hd__dlxtn_4 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbp_1 CLK D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q
+ Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_1 abstract view
.subckt sky130_fd_sc_hd__dlxtn_1 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrbp_2 abstract view
.subckt sky130_fd_sc_hd__sdfrbp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_2 abstract view
.subckt sky130_fd_sc_hd__o2111ai_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_0 abstract view
.subckt sky130_fd_sc_hd__a2111oi_0 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_4 abstract view
.subckt sky130_fd_sc_hd__and3b_4 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_4 abstract view
.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtn_1 abstract view
.subckt sky130_fd_sc_hd__dfrtn_1 CLK_N D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtn_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtn_1 CLK_N D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_2 abstract view
.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_1 abstract view
.subckt sky130_fd_sc_hd__dfsbp_1 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_2 abstract view
.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_1 abstract view
.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_4 abstract view
.subckt sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_2 abstract view
.subckt sky130_fd_sc_hd__dfrbp_2 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_2 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_4 abstract view
.subckt sky130_fd_sc_hd__dlrtp_4 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_16 abstract view
.subckt sky130_fd_sc_hd__buf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxtp_1 abstract view
.subckt sky130_fd_sc_hd__edfxtp_1 CLK D DE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_1 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_1 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_4 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_4 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbp_1 abstract view
.subckt sky130_fd_sc_hd__dlrbp_1 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_2 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_2 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_4 abstract view
.subckt sky130_fd_sc_hd__dfstp_4 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_4 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_4 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_1 abstract view
.subckt sky130_fd_sc_hd__dlrtn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_4 abstract view
.subckt sky130_fd_sc_hd__dlrtn_4 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

.subckt netlist_0 VGND VPWR clk in0 in1 in10 in11 in12 in13 in14 in15 in16 in17 in18
+ in19 in2 in20 in21 in22 in23 in24 in25 in26 in27 in28 in29 in3 in30 in31 in32 in33
+ in34 in35 in36 in37 in38 in39 in4 in40 in41 in42 in43 in44 in45 in46 in47 in48 in49
+ in5 in50 in51 in52 in53 in54 in55 in56 in57 in58 in59 in6 in60 in61 in7 in8 in9
+ out0 out1 out10 out11 out12 out13 out14 out15 out16 out17 out18 out19 out2 out20
+ out21 out22 out23 out24 out25 out26 out27 out28 out29 out3 out30 out31 out32 out33
+ out34 out35 out36 out37 out38 out39 out4 out40 out41 out42 out43 out44 out45 out46
+ out47 out48 out49 out5 out50 out51 out52 out53 out54 out55 out56 out57 out58 out59
+ out6 out60 out61 out7 out8 out9 rst
XFILLER_0_94_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c240_A2 net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c249_A0 net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c421_B net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout215_X net1074 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc327 net131 net255 net129 clknet_1_0__leaf_net251 clknet_1_1__leaf_net257 net976
+ VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__mux4_1
Xc316 net897 clknet_1_0__leaf_net245 net117 clknet_1_1__leaf_net246 net131 net95 VGND
+ VGND VPWR VPWR net248 sky130_fd_sc_hd__mux4_2
XANTENNA_c757_S1 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc305 net234 net96 net228 net673 net1063 clknet_1_1__leaf_net778 VGND VGND VPWR VPWR
+ net238 sky130_fd_sc_hd__mux4_2
XFILLER_0_13_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc349 clknet_1_0__leaf_net946 net733 net739 net786 net1057 net795 VGND VGND VPWR VPWR
+ net282 sky130_fd_sc_hd__mux4_1
Xc338 net3 net975 net1005 net746 net786 net1135 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__mux4_1
XANTENNA_c492_S1 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge837 net670 net260 VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__and2_2
XFILLER_0_67_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmerge826 net600 clknet_4_5_0_clk net624 VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__dlrtp_1
Xmerge815 net584 net622 VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__or2b_4
Xmerge804 net460 net457 VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__and2b_1
XFILLER_0_55_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs910 clknet_4_12_0_clk net277 VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__dfxtp_1
Xmerge859 net695 clknet_4_13_0_clk net294 VGND VGND VPWR VPWR net961 sky130_fd_sc_hd__dlrtn_2
Xmerge848 clknet_4_5_0_clk net488 net694 VGND VGND VPWR VPWR net721 net720 sky130_fd_sc_hd__dfsbp_2
Xs943 clknet_4_6_0_clk net473 VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__dfxtp_4
XFILLER_0_36_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs921 net353 clknet_4_3_0_clk VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__dlxtn_2
Xs932 net409 clknet_4_7_0_clk VGND VGND VPWR VPWR net817 net816 sky130_fd_sc_hd__dlxbn_1
XANTENNA_c74_D1 net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs954 net563 clknet_4_1_0_clk VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__dlxtp_1
Xs965 net587 clknet_4_5_0_clk VGND VGND VPWR VPWR net858 net857 sky130_fd_sc_hd__dlxbn_1
XTAP_TAPCELL_ROW_11_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net493 net493 VGND VGND VPWR VPWR clknet_0_net493 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net471 net471 VGND VGND VPWR VPWR clknet_0_net471 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer7 net1097 VGND VGND VPWR VPWR net1098 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c606_A1 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xnet999_8 clknet_1_0__leaf_net706 VGND VGND VPWR VPWR net1091 sky130_fd_sc_hd__inv_1
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c577_S1 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c235_A2 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout138 net998 VGND VGND VPWR VPWR net997 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c532_B1 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c251_A1 net1072 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s956_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c152_X net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c531_A net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c417_X net328 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c707_A0 net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc102 clknet_4_14_0_clk net37 net39 net38 net1018 net1041 VGND VGND VPWR VPWR net969
+ net40 sky130_fd_sc_hd__sdfbbn_2
XANTENNA_c487_S1 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc113 clknet_4_15_0_clk clknet_1_1__leaf_net48 net967 net943 VGND VGND VPWR VPWR net942
+ net51 sky130_fd_sc_hd__dfbbn_2
Xc124 net55 net32 clknet_1_0__leaf_net52 clknet_1_1__leaf_net56 clknet_1_0__leaf_net54
+ clknet_1_1__leaf_net959 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__mux4_2
Xc135 net905 net862 net1081 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__or3_2
Xc168 net883 net91 net101 net1076 net96 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__a2111oi_4
Xc157 net895 net896 net1074 net882 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__or4bb_2
Xc146 net79 net867 net1025 net1036 net1035 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__a2111oi_4
Xc179 net98 net1 net1072 net1070 net1060 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__a2111o_2
XFILLER_0_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c69_D1 net1071 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s947_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c186_D1 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c617_A0 net481 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c352_A0 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc680 net719 VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__inv_2
Xc691 clknet_4_0_0_clk net526 net554 net876 net823 net825 VGND VGND VPWR VPWR net556
+ net555 sky130_fd_sc_hd__sdfbbn_2
XANTENNA_c502_A3 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c281_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net145 clknet_0_net145 VGND VGND VPWR VPWR clknet_1_0__leaf_net145
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c246_A1 net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_100_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c412_A3 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input55_A in58 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c603_A2 net1074 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge765_C1 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c232_A3 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c554_D1 net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc62 net906 net913 net1069 net915 net914 net878 VGND VGND VPWR VPWR net0 sky130_fd_sc_hd__mux4_2
Xc73 net917 net10 net1069 net1064 net1083 VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__a2111oi_4
Xc84 net21 net16 net14 net1018 net8 VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__a2111o_2
Xc95 net873 net29 net907 VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__or3b_2
XTAP_TAPCELL_ROW_26_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xwire122 net636 VGND VGND VPWR VPWR net981 sky130_fd_sc_hd__clkbuf_1
Xwire144 net104 VGND VGND VPWR VPWR net1003 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_21_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c333_A2 net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_60_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c243_A2 clknet_1_0__leaf_net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c355_SCD net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net834 net834 VGND VGND VPWR VPWR clknet_0_net834 sky130_fd_sc_hd__clkbuf_16
XANTENNA_s937_Q net824 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c290_D_N net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold41 net785 VGND VGND VPWR VPWR net1132 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 net849 VGND VGND VPWR VPWR net1143 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s901_Q_N net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input18_A in24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c600_A3 net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c459_D1 net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c328_A2 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge861_GATE clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c344_A1 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c360_A0 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer17 net76 VGND VGND VPWR VPWR net1152 sky130_fd_sc_hd__dlygate4sd1_1
Xclkbuf_1_1__f_net474 clknet_0_net474 VGND VGND VPWR VPWR clknet_1_1__leaf_net474
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_65_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer28 net1152 VGND VGND VPWR VPWR net1155 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c596_S0 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout195_X net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s887_Q net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c63_A0 net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput75 clknet_1_0__leaf_net934 VGND VGND VPWR VPWR out2 sky130_fd_sc_hd__clkbuf_1
Xoutput64 net1058 VGND VGND VPWR VPWR out1 sky130_fd_sc_hd__buf_2
Xoutput97 net956 VGND VGND VPWR VPWR out43 sky130_fd_sc_hd__buf_2
XANTENNA_c180_A0 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput86 clknet_1_1__leaf_net945 VGND VGND VPWR VPWR out30 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c330_A3 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net508 clknet_0_net508 VGND VGND VPWR VPWR clknet_1_0__leaf_net508
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c339_A1 net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_42_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c505_A3 net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c240_A3 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net282 clknet_0_net282 VGND VGND VPWR VPWR clknet_1_1__leaf_net282
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout155_A net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c421_C net657 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_8_0_clk_X clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout208_X net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc317 net672 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__inv_4
Xc306 net234 net896 net96 net223 net232 net673 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__mux4_1
XFILLER_0_13_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c415_A3 net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc339 net130 net221 net740 net1057 net789 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__a2111o_1
Xc328 clknet_1_1__leaf_net246 net882 net128 net254 net1060 VGND VGND VPWR VPWR net261
+ sky130_fd_sc_hd__a2111oi_2
XFILLER_0_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c712_A1 net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge827 net654 clknet_4_10_0_clk net111 VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__dlrtp_1
Xs900 net248 clknet_4_10_0_clk VGND VGND VPWR VPWR net782 net781 sky130_fd_sc_hd__dlxbn_2
Xmerge816 net663 net646 VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__nor2_2
Xmerge805 clknet_4_3_0_clk net374 net638 VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__dfstp_2
Xmerge838 clknet_4_10_0_clk net132 merge838/RESET_B VGND VGND VPWR VPWR net709 net708
+ sky130_fd_sc_hd__dfrbp_1
Xmerge849 clknet_4_0_0_clk net432 net518 VGND VGND VPWR VPWR net723 net722 sky130_fd_sc_hd__dfsbp_2
Xs933 net412 clknet_4_13_0_clk VGND VGND VPWR VPWR net819 net818 sky130_fd_sc_hd__dlxbn_1
Xs922 net355 clknet_4_3_0_clk VGND VGND VPWR VPWR net808 sky130_fd_sc_hd__dlxtp_1
XFILLER_0_55_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs911 clknet_4_9_0_clk net280 VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__dfxtp_2
Xs966 net590 clknet_4_4_0_clk VGND VGND VPWR VPWR net860 net859 sky130_fd_sc_hd__dlxbp_1
Xs955 net566 clknet_4_1_0_clk VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xs944 clknet_4_4_0_clk net478 VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__dfxtp_4
XTAP_TAPCELL_ROW_11_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net483 net483 VGND VGND VPWR VPWR clknet_0_net483 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net461 net461 VGND VGND VPWR VPWR clknet_0_net461 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer8 net1098 VGND VGND VPWR VPWR net1099 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xnet999_9 clknet_1_0__leaf_net706 VGND VGND VPWR VPWR net1092 sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_19_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c286_C_N net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c593_S1 net724 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c532_A1 net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout139 net344 VGND VGND VPWR VPWR net998 sky130_fd_sc_hd__buf_4
XFILLER_0_89_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout158_X net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge870_D net711 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c707_A1 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c426_A2 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc114 net15 clknet_1_0__leaf_net48 net1076 VGND VGND VPWR VPWR net958 sky130_fd_sc_hd__nand3_2
Xc103 net39 net31 net969 net1016 net1041 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__a2111o_1
Xc125 net10 net942 clknet_1_0__leaf_net48 clknet_1_1__leaf_net959 clknet_1_0__leaf_net50
+ VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__o2111ai_1
Xc136 net863 net69 net71 net1082 net1051 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__o2111ai_4
XANTENNA_merge874_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s892_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc169 net101 net870 net879 net98 net1002 net893 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__mux4_2
Xc158 net893 net875 net1015 net1126 net93 net880 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__mux4_2
Xc147 net867 net874 net1051 net1067 net1033 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__o2111ai_4
XFILLER_0_13_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c69_C1 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge865_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge770_B1 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s883_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c352_A1 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc681 net544 net982 net524 net1045 net1042 clknet_1_0__leaf_net742 VGND VGND VPWR
+ VPWR net545 sky130_fd_sc_hd__mux4_4
Xc670 net532 net1011 net533 net1087 net1047 net1045 VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__mux4_1
Xc692 net548 net555 net1046 net1048 net997 net653 VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__mux4_1
XFILLER_0_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net179 clknet_0_net179 VGND VGND VPWR VPWR clknet_1_0__leaf_net179
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c588_S1 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c246_A2 clknet_1_0__leaf_net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c109_S0 net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge847_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input48_A in51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net815 clknet_0_net815 VGND VGND VPWR VPWR clknet_1_1__leaf_net815
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge765_B1 net419 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge838_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_71_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c599_S0 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c108_X net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge829_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c704_A2 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c720_A1 net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc63 net0 net904 net900 net899 net912 net906 VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__mux4_2
Xc74 net11 net1076 net10 net1069 net1064 VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__o2111ai_4
Xc85 net22 net21 net10 net1018 net1064 net20 VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__mux4_2
Xc96 net665 VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_26_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire123 net531 VGND VGND VPWR VPWR net982 sky130_fd_sc_hd__buf_1
XANTENNA_c183_A0 net1074 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c333_A3 net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net623 clknet_0_net623 VGND VGND VPWR VPWR clknet_1_1__leaf_net623
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_69_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire193_X net1052 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c243_A3 net1072 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_9_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout140_X net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net835 net835 VGND VGND VPWR VPWR clknet_0_net835 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c715_A1 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c284_C1 net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c434_A2 net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net48 clknet_0_net48 VGND VGND VPWR VPWR clknet_1_1__leaf_net48 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_101_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold42 net851 VGND VGND VPWR VPWR net1133 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c459_C1 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c609_A2 net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c80_X net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c625_A1 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c344_A2 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c360_A1 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer18 net81 VGND VGND VPWR VPWR net1109 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_88_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer29 net78 VGND VGND VPWR VPWR net1120 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net475 clknet_0_net475 VGND VGND VPWR VPWR clknet_1_1__leaf_net475
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_37_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c596_S1 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_4_0_clk_X clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout188_X net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c726_A0 net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput65 clknet_1_1__leaf_net924 VGND VGND VPWR VPWR out10 sky130_fd_sc_hd__clkbuf_1
Xoutput76 net935 VGND VGND VPWR VPWR out20 sky130_fd_sc_hd__clkbuf_1
Xoutput87 clknet_1_1__leaf_net946 VGND VGND VPWR VPWR out31 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c180_A1 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput98 clknet_1_1__leaf_net957 VGND VGND VPWR VPWR out44 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input30_A in35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c611_A3 net481 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output117_A net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c339_A2 net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s877_Q_N net757 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net250 clknet_0_net250 VGND VGND VPWR VPWR clknet_1_1__leaf_net250
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c565_SET_B net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c249_A2 net1072 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_99_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout148_A net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c546_A0 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net799_A net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc318 net95 net950 net673 net757 clknet_1_0__leaf_net779 net782 VGND VGND VPWR VPWR
+ net250 sky130_fd_sc_hd__mux4_2
Xc307 net229 net224 net202 net232 net230 net673 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__mux4_2
XFILLER_0_60_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c562_C1 net1155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc329 net261 net128 net254 net657 net1060 net783 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c712_A2 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c159_A2 net1160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge817 net588 net611 VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__nand2_4
Xmerge828 net370 clknet_4_13_0_clk net677 VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__dlrtp_2
Xs901 net259 clknet_4_9_0_clk VGND VGND VPWR VPWR net976 net783 sky130_fd_sc_hd__dlxbn_2
Xmerge806 net216 clknet_4_8_0_clk net236 VGND VGND VPWR VPWR net674 net673 sky130_fd_sc_hd__dlrbn_2
XFILLER_0_36_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs934 net415 clknet_4_7_0_clk VGND VGND VPWR VPWR net821 net820 sky130_fd_sc_hd__dlxbp_1
Xs923 net380 clknet_4_6_0_clk VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__lpflow_inputisolatch_1
XFILLER_0_48_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge839 net379 net385 VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__or2_2
Xs912 clknet_4_13_0_clk net286 VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__dfxtp_2
Xs956 clknet_4_1_0_clk net567 VGND VGND VPWR VPWR net846 net845 sky130_fd_sc_hd__dfxbp_2
XFILLER_0_36_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs945 clknet_4_7_0_clk net495 VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__dlclkp_1
XANTENNA_c456_A0 net1070 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net462 net462 VGND VGND VPWR VPWR clknet_0_net462 sky130_fd_sc_hd__clkbuf_16
Xrebuffer9 net1097 VGND VGND VPWR VPWR net1100 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c622_A2 net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c220_S0 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_74_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout129 net209 VGND VGND VPWR VPWR net988 sky130_fd_sc_hd__buf_4
XFILLER_0_10_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c532_A2 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout220_X net1079 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c442_SET_B net1079 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc104 net33 net969 net38 net943 net873 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__a2111oi_1
Xc115 net1067 clknet_1_1__leaf_net48 clknet_1_1__leaf_net49 VGND VGND VPWR VPWR net52
+ sky130_fd_sc_hd__or3b_4
Xc126 clknet_1_0__leaf_net60 clknet_1_1__leaf_net959 net1125 net17 VGND VGND VPWR
+ VPWR net61 sky130_fd_sc_hd__or4bb_4
XFILLER_0_60_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc137 net864 net1082 net883 net1038 net1051 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__a2111o_4
Xc159 net91 net94 net1015 net93 net76 net1117 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__mux4_2
Xc148 net920 net82 net80 net866 net905 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__o2111a_2
XFILLER_0_13_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c305_S0 net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_99_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c88_C_N net133 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clone26_X net1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_A2 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c336_A3 net1125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c694_S1 net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c352_A2 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc682 net983 net1045 net1079 net696 clknet_1_0__leaf_net778 VGND VGND VPWR VPWR net546
+ sky130_fd_sc_hd__o2111a_4
Xc660 net696 VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__inv_6
Xc671 net533 net1011 net730 VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__or3_2
Xc693 net1046 net551 net78 net1042 VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__or4bb_2
XFILLER_0_91_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c112_C net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c246_A3 net1077 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge807_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c109_S1 net702 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_27_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge792_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_94_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c281_Q net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_45_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge765_A1 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c628_A1 net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c347_A2 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c177_C_N net1070 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc490 clknet_1_1__leaf_net401 net296 clknet_1_1__leaf_net300 clknet_1_1__leaf_net403
+ net1063 net735 VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__mux4_2
XPHY_EDGE_ROW_63_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c118_D_N net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_82_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_72_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c599_S1 net814 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net60 clknet_0_net60 VGND VGND VPWR VPWR clknet_1_0__leaf_net60 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_15_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c554_B1 net1078 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c704_A3 net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_81_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c720_A2 clknet_1_1__leaf_net706 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc64 net3 net910 net909 net906 net902 net900 VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__mux4_2
Xc75 net9 net917 net11 net10 net878 VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__a2111oi_2
Xc97 net665 VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_2
Xc86 net18 net22 net23 net21 net1075 net19 VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_26_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_90_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c302_S1 net657 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_rebuffer33_A net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c464_A0 clknet_1_0__leaf_net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input60_A in7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c183_A1 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge853_GATE_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c358_A1 net1116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_60_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_97_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold49_A net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout178_A net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c549_A0 net1078 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_0_0_clk_X clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c434_A3 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net49 clknet_0_net49 VGND VGND VPWR VPWR clknet_1_1__leaf_net49 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c731_A1 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold43 net843 VGND VGND VPWR VPWR net1134 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c77_B1 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c609_A3 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c194_A0 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c625_A2 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c360_A2 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c207_S1 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net465 clknet_0_net465 VGND VGND VPWR VPWR clknet_1_1__leaf_net465
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s888_GATE_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_65_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net498 clknet_0_net498 VGND VGND VPWR VPWR clknet_1_1__leaf_net498
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_37_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer19 net1109 VGND VGND VPWR VPWR net1110 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_88_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c369_A0 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c223_S0 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c726_A1 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c63_A2 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_50_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c742_A0 net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput66 net925 VGND VGND VPWR VPWR out11 sky130_fd_sc_hd__buf_2
Xoutput99 net958 VGND VGND VPWR VPWR out45 sky130_fd_sc_hd__clkbuf_1
Xoutput77 net936 VGND VGND VPWR VPWR out21 sky130_fd_sc_hd__buf_2
Xoutput88 clknet_1_1__leaf_net947 VGND VGND VPWR VPWR out32 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c180_A2 net1070 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input23_A in29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c189_B1 net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge773_A1 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c636_A1 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_42_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output91_A net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap146_X net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net251 clknet_0_net251 VGND VGND VPWR VPWR clknet_1_1__leaf_net251
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net273 clknet_0_net273 VGND VGND VPWR VPWR clknet_1_1__leaf_net273
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c249_A3 net732 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c546_A1 net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c265_A2 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc308 net1138 VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__inv_6
Xc319 net1001 net0 net129 net1068 net758 clknet_1_0__leaf_net780 VGND VGND VPWR VPWR
+ net251 sky130_fd_sc_hd__mux4_2
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c712_A3 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c671_B net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s959_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge818 net416 net290 VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__nand2b_4
XANTENNA_c429_RESET_B net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge807 net354 clknet_4_2_0_clk net635 VGND VGND VPWR VPWR net676 net675 sky130_fd_sc_hd__dlrbn_1
XFILLER_0_67_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge829 clknet_4_0_0_clk net538 net688 VGND VGND VPWR VPWR net700 net699 sky130_fd_sc_hd__edfxbp_1
Xs924 clknet_4_6_0_clk net381 VGND VGND VPWR VPWR net810 net809 sky130_fd_sc_hd__dfxbp_1
Xs913 clknet_4_13_0_clk net298 VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__dlclkp_1
Xs902 net262 clknet_4_9_0_clk VGND VGND VPWR VPWR net785 net784 sky130_fd_sc_hd__dlxbp_1
XFILLER_0_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs957 clknet_4_1_0_clk net569 VGND VGND VPWR VPWR net848 net847 sky130_fd_sc_hd__dfxbp_1
Xs935 net434 clknet_4_0_0_clk VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__dlxtn_2
Xs946 clknet_4_6_0_clk net496 VGND VGND VPWR VPWR net834 sky130_fd_sc_hd__dlclkp_2
XTAP_TAPCELL_ROW_11_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net474 net474 VGND VGND VPWR VPWR clknet_0_net474 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c191_A1 net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c622_A3 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input26_X net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c366_A1 net1070 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c220_S1 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net852 clknet_0_net852 VGND VGND VPWR VPWR clknet_1_0__leaf_net852
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_64_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout213_X net1072 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc116 net45 net1064 clknet_1_1__leaf_net52 VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__nor3_2
Xc105 net32 net4 net39 net40 net33 net1076 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__mux4_1
Xc127 clknet_1_0__leaf_net57 net22 net15 clknet_1_0__leaf_net48 clknet_1_0__leaf_net60
+ net1072 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_96_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc138 net1066 net69 net1038 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__nor3_4
Xc149 net69 net76 net79 net1035 net1117 net74 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__mux4_2
XANTENNA_c723_A2 net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c305_S1 clknet_1_1__leaf_net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c186_A1 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_A3 net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net282 net282 VGND VGND VPWR VPWR clknet_0_net282 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge770_A2 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c352_A3 net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc672 net530 net982 net533 net1045 net1042 net1053 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__mux4_1
Xc661 net696 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__inv_4
Xc694 clknet_1_1__leaf_net552 net997 net985 net214 net554 net547 VGND VGND VPWR VPWR
+ net559 sky130_fd_sc_hd__mux4_2
Xc683 net1046 net1047 net700 net1053 VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__or4bb_4
XFILLER_0_91_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s940_Q_N net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c734_A1 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c172_A3 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c750_A0 clknet_1_1__leaf_net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_100_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c197_A0 net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c628_A2 net1068 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c347_A3 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc491 net908 clknet_1_0__leaf_net946 clknet_1_1__leaf_net401 clknet_1_0__leaf_net945
+ clknet_1_0__leaf_net762 clknet_1_0__leaf_net927 VGND VGND VPWR VPWR net977 sky130_fd_sc_hd__mux4_4
Xc480 net390 net391 clknet_1_1__leaf_net245 net281 net1054 net811 VGND VGND VPWR VPWR
+ net396 sky130_fd_sc_hd__mux4_4
XANTENNA_c226_S0 net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net50 clknet_0_net50 VGND VGND VPWR VPWR clknet_1_0__leaf_net50 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c257_A3 net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c720_A3 net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc76 net1064 net908 net1022 net899 net2 VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__a2111o_4
Xc65 net865 net882 net878 net879 net889 net1076 VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__mux4_2
Xc87 net24 net1017 net1018 net882 net23 net22 VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__mux4_1
Xc98 clknet_4_14_0_clk net27 net31 net30 net34 VGND VGND VPWR VPWR net36 net35 sky130_fd_sc_hd__sdfrbp_1
XTAP_TAPCELL_ROW_26_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net490 clknet_0_net490 VGND VGND VPWR VPWR clknet_1_0__leaf_net490
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c167_A3 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c745_A0 net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c70_B net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c464_A1 net1074 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c183_A2 net1068 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input53_A in56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c630_A3 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c549_A1 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net815 net815 VGND VGND VPWR VPWR clknet_0_net815 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c403_S1 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c284_A1 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_A2 clknet_1_1__leaf_net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold44 net790 VGND VGND VPWR VPWR net1135 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c450_A3 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c475_A0 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c625_A3 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net433 clknet_0_net433 VGND VGND VPWR VPWR clknet_1_1__leaf_net433
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_65_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net499 clknet_0_net499 VGND VGND VPWR VPWR clknet_1_1__leaf_net499
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c504_S0 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c369_A1 clknet_1_1__leaf_net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c682_D1 clknet_1_0__leaf_net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout190_A net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c168_Y net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net623 net623 VGND VGND VPWR VPWR clknet_0_net623 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c726_A2 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s935_Q net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c742_A1 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c461_A2 net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput67 net926 VGND VGND VPWR VPWR out12 sky130_fd_sc_hd__buf_2
Xoutput78 clknet_1_1__leaf_net937 VGND VGND VPWR VPWR out22 sky130_fd_sc_hd__clkbuf_1
Xoutput89 net948 VGND VGND VPWR VPWR out34 sky130_fd_sc_hd__buf_2
XANTENNA_input16_A in22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c324_S0 net1071 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output84_A net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c371_A2 net734 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c289_C_N net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc309 net117 net221 net1059 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__nor3_1
XFILLER_0_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net542_X clknet_1_1__leaf_net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input8_A in15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s885_Q net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge819 net642 net63 VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__nand2_2
Xmerge808 net413 net417 VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__or2_4
Xs903 net264 clknet_4_11_0_clk VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__dlxtn_2
Xs925 clknet_4_9_0_clk net389 VGND VGND VPWR VPWR net812 net811 sky130_fd_sc_hd__dfxbp_1
Xs914 clknet_4_12_0_clk net301 VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__dlclkp_2
XANTENNA_c74_A2 net1076 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs958 clknet_4_4_0_clk net573 VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__dfxtp_2
Xs936 net435 clknet_4_0_0_clk VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__dlxtn_2
Xs947 clknet_4_6_0_clk net497 VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__dlclkp_4
XTAP_TAPCELL_ROW_11_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net475 net475 VGND VGND VPWR VPWR clknet_0_net475 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c456_A2 net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s895_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c191_A2 net1151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c319_S0 net758 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge801_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input19_X net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c366_A2 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c501_S1 net821 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c443_C_N net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c663_A0 net1108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c102_SET_B net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c229_S0 net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_85_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net853 clknet_0_net853 VGND VGND VPWR VPWR clknet_1_0__leaf_net853
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_70_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s877_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc106 clknet_4_14_0_clk net31 net969 net1148 net38 net37 VGND VGND VPWR VPWR net45
+ net44 sky130_fd_sc_hd__sdfbbn_1
Xc117 net32 net1076 net942 clknet_1_1__leaf_net959 clknet_1_1__leaf_net48 net31 VGND
+ VGND VPWR VPWR net53 sky130_fd_sc_hd__mux4_1
XFILLER_0_79_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc128 net58 net51 clknet_1_1__leaf_net62 clknet_1_1__leaf_net57 net967 VGND VGND VPWR
+ VPWR net63 sky130_fd_sc_hd__o2111a_1
Xc139 net1036 net866 net861 net1066 net1081 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__a2111o_2
XANTENNA_c69_A2 net1083 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_44_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c467_A1 net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c295_A_N net657 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c602_S0 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c186_A2 net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net250 net250 VGND VGND VPWR VPWR clknet_0_net250 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_24_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc673 net532 net1043 net535 net533 net1045 VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__o2111a_1
Xc662 net431 net1045 net995 VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__nor3b_1
Xc695 net548 net1043 net997 net653 clknet_1_1__leaf_net742 VGND VGND VPWR VPWR net560
+ sky130_fd_sc_hd__a2111oi_2
Xc684 net524 net896 net547 net1043 VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__or4bb_1
XFILLER_0_91_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c231_S1 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c393_A0 net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c543_A3 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout156_X net1160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c718_A3 net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_21_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c750_A1 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c316_S1 net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c332_S0 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc470 clknet_1_0__leaf_net946 net1026 net955 net1055 net1054 net810 VGND VGND VPWR
+ VPWR net386 sky130_fd_sc_hd__mux4_4
Xc481 clknet_1_1__leaf_net396 net1072 net391 clknet_1_0__leaf_net946 net784 net795
+ VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__mux4_2
Xc492 net400 clknet_1_1__leaf_net403 net930 net1002 clknet_1_1__leaf_net945 net951
+ VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__mux4_2
XFILLER_0_35_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c242_S0 net1125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net62 clknet_0_net62 VGND VGND VPWR VPWR clknet_1_0__leaf_net62 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_15_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c570_A1 net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c417_S0 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc66 net899 net915 net1083 VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__nand3_4
Xc99 net910 net1069 net1071 net34 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__or4bb_1
Xc77 net9 net1027 net878 net873 net8 VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__o2111ai_4
XFILLER_0_97_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc88 net13 net919 net133 VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__or3b_4
XTAP_TAPCELL_ROW_26_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A2 net328 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c209_CLK_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c70_C net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c464_A2 net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c183_A3 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input46_A in5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net604 clknet_0_net604 VGND VGND VPWR VPWR clknet_1_1__leaf_net604
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c358_A3 net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c165_C net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c549_A2 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c284_A2 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c581_A0 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_A3 net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold45 net786 VGND VGND VPWR VPWR net1136 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clone39_A net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c475_A1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c194_A2 net1077 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c66_Y net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c491_A0 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input49_X net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net401 clknet_0_net401 VGND VGND VPWR VPWR clknet_1_1__leaf_net401
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_83_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net423 clknet_0_net423 VGND VGND VPWR VPWR clknet_1_1__leaf_net423
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_77_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_1__f_net153_X clknet_1_1__leaf_net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_4_9_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c203_D1 net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout183_A net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_69_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c430_S0 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c726_A3 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s928_Q net814 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_78_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c742_A2 net328 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c592_X net481 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput68 clknet_1_1__leaf_net927 VGND VGND VPWR VPWR out13 sky130_fd_sc_hd__clkbuf_1
Xoutput79 clknet_1_1__leaf_net938 VGND VGND VPWR VPWR out23 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c605_S0 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c324_S1 net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c486_A0 net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output77_A net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c371_A3 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net253 clknet_0_net253 VGND VGND VPWR VPWR clknet_1_1__leaf_net253
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net275 clknet_0_net275 VGND VGND VPWR VPWR clknet_1_1__leaf_net275
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c234_S1 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c250_S0 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s878_Q net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge809 net482 net520 VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__or2b_1
XFILLER_0_95_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs915 clknet_4_2_0_clk net325 VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__dlclkp_4
Xs904 net265 clknet_4_12_0_clk VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__dlxtn_4
XFILLER_0_75_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs959 clknet_4_4_0_clk net574 VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__dfxtp_1
Xs937 net438 clknet_4_1_0_clk VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__dlxtn_2
Xs948 net501 clknet_4_7_0_clk VGND VGND VPWR VPWR net933 net836 sky130_fd_sc_hd__dlxbn_1
Xs926 clknet_4_12_0_clk net392 VGND VGND VPWR VPWR net978 sky130_fd_sc_hd__dfxtp_4
XFILLER_0_90_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net465 net465 VGND VGND VPWR VPWR clknet_0_net465 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c456_A3 net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net498 net498 VGND VGND VPWR VPWR clknet_0_net498 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c753_A1 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c191_A3 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c157_D_N net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c335_S0 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c140_C_N net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c366_A3 clknet_1_1__leaf_net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c663_A1 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c245_S0 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c688_D1 net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_85_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c102_Q_N net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c200_C1 net1158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net854 clknet_0_net854 VGND VGND VPWR VPWR clknet_1_0__leaf_net854
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c133_A net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c276_A3 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc118 net1064 clknet_1_1__leaf_net959 net51 net756 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__or4bb_1
Xc107 net900 net969 net1041 net702 net755 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__a2111oi_4
XANTENNA_c292_A2 net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc129 clknet_4_15_0_clk net61 clknet_1_1__leaf_net62 net31 clknet_1_1__leaf_net959
+ clknet_1_1__leaf_net744 VGND VGND VPWR VPWR net65 net64 sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_79_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c748_A1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c602_S1 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net251 net251 VGND VGND VPWR VPWR clknet_0_net251 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net273 net273 VGND VGND VPWR VPWR clknet_0_net273 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc630 net516 clknet_1_0__leaf_net515 clknet_1_0__leaf_net517 net212 clknet_1_0__leaf_net762
+ clknet_1_1__leaf_net834 VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__mux4_2
Xc663 net1108 net1047 net1026 net993 net1045 net418 VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__mux4_4
Xc696 net535 net1043 net1046 net997 net551 net753 VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__mux4_1
Xc674 net217 net533 net1042 net728 VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__or4bb_1
Xc685 net986 clknet_1_0__leaf_net542 net443 net993 net1077 net842 VGND VGND VPWR VPWR
+ net549 sky130_fd_sc_hd__mux4_2
XANTENNA_merge786_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c393_A1 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c690_C1 net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c703_S0 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge802_Y net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c759_A0 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_14_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c332_S1 net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c427_Q net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc460 net375 net1078 net363 net1009 net1104 net672 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__mux4_2
Xc471 net378 net955 net801 net807 net1054 net809 VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__mux4_1
Xc482 clknet_1_1__leaf_net397 net1073 clknet_1_0__leaf_net946 net1138 net978 net813
+ VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__mux4_2
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc493 clknet_1_1__leaf_net403 net943 net735 net929 net768 clknet_1_1__leaf_net815
+ VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__mux4_4
XFILLER_0_35_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c242_S1 net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net52 clknet_0_net52 VGND VGND VPWR VPWR clknet_1_0__leaf_net52 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_41_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc67 net902 net907 net885 net908 VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__or4bb_2
XPHY_EDGE_ROW_50_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc89 net914 net1064 net890 VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__or3_1
XFILLER_0_97_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc78 net2 net9 net915 net7 net12 net1027 VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__mux4_2
XANTENNA_c579_A0 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_26_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c152_S1 net1101 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xwire127 net421 VGND VGND VPWR VPWR net986 sky130_fd_sc_hd__buf_1
XFILLER_0_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s940_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c464_A3 clknet_1_1__leaf_net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c761_A1 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s906_GATE clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c608_S0 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input39_A in43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c327_S1 net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c343_S0 net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s931_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_1_0__f_net153_X clknet_1_0__leaf_net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc290 net220 net1119 net880 net1025 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__or4bb_1
XANTENNA_c237_S1 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_5_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c581_A1 net1130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold46 net308 VGND VGND VPWR VPWR net1137 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c756_A1 clknet_1_1__leaf_net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c475_A2 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c491_A1 clknet_1_0__leaf_net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c338_S0 net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmax_cap202 net749 VGND VGND VPWR VPWR net1061 sky130_fd_sc_hd__buf_4
XFILLER_0_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c682_B1 net1079 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c528_C_N net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c275_C net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c203_C1 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout176_A net1157 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c268_B net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c576_A1 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c711_S0 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c592_A0 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput69 net928 VGND VGND VPWR VPWR out14 sky130_fd_sc_hd__buf_2
XFILLER_0_98_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c621_S0 net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c486_A1 net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input61_X net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_6_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_wire144_A net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c250_S1 clknet_1_0__leaf_net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c706_S0 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs905 net267 clknet_4_11_0_clk VGND VGND VPWR VPWR net788 sky130_fd_sc_hd__dlxtn_1
XANTENNA_c737_A3 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs916 net326 clknet_4_2_0_clk VGND VGND VPWR VPWR net801 net800 sky130_fd_sc_hd__dlxbn_2
Xs949 net503 clknet_4_7_0_clk VGND VGND VPWR VPWR net838 net837 sky130_fd_sc_hd__dlxbn_2
Xs938 net458 clknet_4_1_0_clk VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__dlxtp_1
XANTENNA_s940_Q net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs927 clknet_4_6_0_clk net395 VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_75_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net433 net433 VGND VGND VPWR VPWR clknet_0_net433 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net499 net499 VGND VGND VPWR VPWR clknet_0_net499 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c753_A2 clknet_1_0__leaf_net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c616_S0 net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input21_A in27 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c335_S1 net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_13_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c497_A0 net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output108_A net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge851_Q net725 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c663_A2 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_97_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c245_S1 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net833 clknet_0_net833 VGND VGND VPWR VPWR clknet_1_0__leaf_net833
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_54_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c200_B1 net1160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c133_B net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout139_A net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c405_C net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c573_A2 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c300_B net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc108 net45 net969 net46 net29 net34 net702 VGND VGND VPWR VPWR net967 sky130_fd_sc_hd__mux4_2
XANTENNA_c292_A3 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_96_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc119 clknet_1_0__leaf_net959 net1072 net1064 clknet_1_1__leaf_net48 net949 VGND VGND
+ VPWR VPWR net965 sky130_fd_sc_hd__o2111a_4
XFILLER_0_95_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c283_X net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s890_Q net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c748_A2 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c85_A3 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc631 net455 net1067 net1062 net923 clknet_1_1__leaf_net833 clknet_1_0__leaf_net834
+ VGND VGND VPWR VPWR net973 sky130_fd_sc_hd__mux4_1
Xc620 net1040 clknet_1_1__leaf_net977 net769 clknet_1_0__leaf_net815 net826 net831
+ VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__mux4_1
Xc664 net719 VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__clkbuf_1
Xc697 clknet_1_0__leaf_net552 net1047 clknet_1_0__leaf_net560 clknet_1_1__leaf_net742
+ net1053 VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__o2111ai_4
Xc675 net430 net530 net1079 net533 net431 net532 VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__mux4_1
Xc686 net997 net984 net1047 clknet_1_0__leaf_net542 net823 VGND VGND VPWR VPWR net550
+ sky130_fd_sc_hd__o2111ai_4
XFILLER_0_99_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c393_A2 clknet_1_0__leaf_net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c690_B1 net1079 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_1__f_net762_X clknet_1_1__leaf_net762 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c584_A1 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout211_X net1070 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s903_Q net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s916_Q_N net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c402_D1 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c478_A2 net1070 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c296_D_N net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clone17_X net1108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c691_Q net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_71_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc461 net979 net377 net1105 net368 net375 VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__o2111ai_4
Xc450 clknet_1_0__leaf_net257 net359 net365 net204 net346 net1058 VGND VGND VPWR VPWR
+ net367 sky130_fd_sc_hd__mux4_2
Xc472 clknet_1_1__leaf_net330 clknet_1_1__leaf_net952 net738 net1057 net808 net1054
+ VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__mux4_2
XFILLER_0_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc494 clknet_1_0__leaf_net302 clknet_1_0__leaf_net403 clknet_1_0__leaf_net401 net814
+ clknet_1_0__leaf_net815 clknet_1_0__leaf_net924 VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__mux4_1
Xc483 net391 clknet_1_0__leaf_net396 clknet_1_0__leaf_net397 net962 net978 net813
+ VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__mux4_1
XFILLER_0_35_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c563_RESET_B net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c270_C_N net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c206_C1 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_1_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc79 net904 net1022 net10 VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__or3b_2
Xc68 net908 net2 net1064 VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__nand3_2
XFILLER_0_97_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout161_X net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_26_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c298_A2 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net471 clknet_0_net471 VGND VGND VPWR VPWR clknet_1_0__leaf_net471
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net493 clknet_0_net493 VGND VGND VPWR VPWR clknet_1_0__leaf_net493
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c745_A3 net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net606 clknet_0_net606 VGND VGND VPWR VPWR clknet_1_1__leaf_net606
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net617 clknet_0_net617 VGND VGND VPWR VPWR clknet_1_1__leaf_net617
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c624_S0 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c489_A1 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc280 clknet_4_2_0_clk net211 net205 net1006 net668 VGND VGND VPWR VPWR net213 net212
+ sky130_fd_sc_hd__sdfrbp_2
Xc291 net96 net84 net222 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__or3b_1
XFILLER_0_62_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c423_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge790 clknet_4_8_0_clk net227 merge790/RESET_B VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout219_A net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold47 net738 VGND VGND VPWR VPWR net1138 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input51_A in54 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge831_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net403 clknet_0_net403 VGND VGND VPWR VPWR clknet_1_1__leaf_net403
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net469 clknet_0_net469 VGND VGND VPWR VPWR clknet_1_1__leaf_net469
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_84_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c682_A1 net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_77_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c203_B1 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout169_A net115 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net604 net604 VGND VGND VPWR VPWR clknet_0_net604 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c576_A2 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout124_X net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c158_S1 net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c174_S0 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c455_C_N net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s898_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input54_X net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c446_C_N net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c706_S1 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c273_A net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c159_X net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs906 net268 clknet_4_11_0_clk VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__dlxtp_1
Xs939 net459 clknet_4_1_0_clk VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xclkbuf_0_net423 net423 VGND VGND VPWR VPWR clknet_0_net423 sky130_fd_sc_hd__clkbuf_16
Xs917 net327 clknet_4_2_0_clk VGND VGND VPWR VPWR net803 net802 sky130_fd_sc_hd__dlxbn_2
Xs928 clknet_4_12_0_clk net399 VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_48_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net401 net401 VGND VGND VPWR VPWR clknet_0_net401 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c753_A3 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c169_S0 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge825_GATE_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c98_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c616_S1 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input14_A in20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c663_A3 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net834 clknet_0_net834 VGND VGND VPWR VPWR clknet_1_0__leaf_net834
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c200_A1 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge811_GATE clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c573_A3 net1068 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c300_C net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc109 net1013 net46 net967 net44 net40 net702 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__mux4_1
XFILLER_0_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c717_S0 net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input6_A in13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c436_S1 net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout191_X net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c276_X net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_A0 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c748_A3 net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c452_S0 net1151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net253 net253 VGND VGND VPWR VPWR clknet_0_net253 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c483_A3 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net275 net275 VGND VGND VPWR VPWR clknet_0_net275 sky130_fd_sc_hd__clkbuf_16
Xc610 clknet_1_0__leaf_net498 clknet_1_1__leaf_net483 net19 net683 clknet_1_0__leaf_net833
+ clknet_1_0__leaf_net835 VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__mux4_2
Xc621 clknet_1_0__leaf_net508 net1010 net928 net929 net1056 net839 VGND VGND VPWR
+ VPWR net510 sky130_fd_sc_hd__mux4_1
Xc632 net896 clknet_1_1__leaf_net973 clknet_1_1__leaf_net510 net814 net817 net933
+ VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__mux4_2
Xc698 net556 net561 net1108 net983 net889 net741 VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__mux4_1
Xc676 net419 net533 net1045 net728 clknet_1_0__leaf_net742 net1053 VGND VGND VPWR
+ VPWR net540 sky130_fd_sc_hd__mux4_2
Xc665 net1011 net424 net1042 VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__nor3_1
Xc687 net530 net1046 net1042 net443 net228 net748 VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__mux4_2
XANTENNA_input17_X net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c699_C1 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c211_B1 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c355_D net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout204_X net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c65_S0 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c105_A1 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input9_X net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c560_X net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c759_A2 net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c402_C1 net1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c478_A3 net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc462 net315 net377 clknet_1_0__leaf_net946 net12 net284 net807 VGND VGND VPWR VPWR
+ net952 sky130_fd_sc_hd__mux4_1
Xc473 clknet_1_1__leaf_net331 clknet_1_1__leaf_net369 net1017 net738 net792 clknet_1_1__leaf_net799
+ VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__mux4_1
Xc451 net124 net364 net1006 net1037 net784 net808 VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__mux4_2
Xc440 net231 clknet_1_1__leaf_net331 clknet_1_1__leaf_net332 net1004 net913 net676
+ VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__mux4_4
Xc484 net932 clknet_1_0__leaf_net300 net771 net796 clknet_1_1__leaf_net798 net1055
+ VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__mux4_2
Xc495 net940 clknet_1_0__leaf_net977 net950 net735 clknet_1_1__leaf_net798 net816
+ VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__mux4_4
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_82_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net54 clknet_0_net54 VGND VGND VPWR VPWR clknet_1_0__leaf_net54 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_27_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout199_A net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc69 net912 net1083 net1069 net900 net1071 VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__o2111a_4
XTAP_TAPCELL_ROW_26_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c298_A3 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net461 clknet_0_net461 VGND VGND VPWR VPWR clknet_1_0__leaf_net461
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net483 clknet_0_net483 VGND VGND VPWR VPWR clknet_1_0__leaf_net483
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c595_A1 net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_34_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c413_Y net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_rebuffer4_A net1151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c624_S1 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc281 clknet_4_2_0_clk net207 net200 net211 net866 net1004 VGND VGND VPWR VPWR net215
+ net214 sky130_fd_sc_hd__sdfbbp_1
Xc270 net199 net200 net1019 net83 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__or4bb_4
Xc292 net225 net223 net222 net988 net1121 net96 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__mux4_1
XANTENNA_s916_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmerge791 net527 net536 VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__nand2b_1
Xmerge780 net509 net519 VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__nand2_2
XFILLER_0_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c725_S0 net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c62_S1 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold48 net757 VGND VGND VPWR VPWR net1139 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c356_X net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c756_A3 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input44_A in48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge874_Q net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c178_D_N net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c545_S0 net1074 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c203_A1 net1068 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c161_C_N net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net971 clknet_0_net971 VGND VGND VPWR VPWR clknet_1_1__leaf_net971
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_0_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c576_A3 clknet_1_0__leaf_net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_499 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c439_S1 net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c174_S1 net758 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clone37_A net1082 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c486_A3 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge767_S0 net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c422_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c304_A0 net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net245 clknet_0_net245 VGND VGND VPWR VPWR clknet_1_1__leaf_net245
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_57_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c273_B net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout181_A net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c722_S1 net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c587_A2 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs907 net270 clknet_4_11_0_clk VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xs918 net336 clknet_4_2_0_clk VGND VGND VPWR VPWR net805 net804 sky130_fd_sc_hd__dlxbp_1
Xs929 clknet_4_12_0_clk net404 VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__dlclkp_1
XFILLER_0_63_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s926_Q net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge798_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c632_S1 net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_output75_A clknet_1_0__leaf_net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c688_A1 net1078 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s923_SLEEP_B clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net835 clknet_0_net835 VGND VGND VPWR VPWR clknet_1_0__leaf_net835
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_54_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout184_X net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_A1 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c733_S0 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c269_X net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s876_Q net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_52_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c119_B1 net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc600 net486 net1073 net1130 net454 net721 net831 VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__mux4_2
Xc611 net1095 net1037 clknet_1_1__leaf_net498 net481 net731 net1058 VGND VGND VPWR
+ VPWR net500 sky130_fd_sc_hd__mux4_1
Xc622 clknet_1_0__leaf_net300 clknet_1_0__leaf_net506 net929 net978 net816 clknet_1_1__leaf_net833
+ VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__mux4_4
XANTENNA_c565_Q_N net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc633 net513 clknet_1_0__leaf_net517 clknet_1_1__leaf_net922 clknet_1_0__leaf_net300
+ clknet_1_0__leaf_net508 net722 VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__mux4_1
Xc666 net1042 net1045 net529 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__and3_1
Xc677 net719 VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__clkbuf_2
Xc688 net1078 net1043 clknet_1_0__leaf_net542 net748 net825 VGND VGND VPWR VPWR net552
+ sky130_fd_sc_hd__o2111ai_2
Xc699 net443 net985 net555 net228 net1134 VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__o2111ai_1
XANTENNA_c151_D1 net1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s961_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c396_B_N net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c65_S1 net1076 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c91_B net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s943_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c494_A3 net814 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc430 net343 net315 net896 net341 net1058 net802 VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__mux4_2
XFILLER_0_20_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc452 net368 net889 net363 clknet_1_0__leaf_net246 net113 net684 VGND VGND VPWR VPWR
+ net369 sky130_fd_sc_hd__mux4_2
Xc441 net342 net1067 net908 net1079 clknet_1_0__leaf_net799 VGND VGND VPWR VPWR net356
+ sky130_fd_sc_hd__a2111o_1
Xc463 net12 net932 net209 net378 net792 net800 VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__mux4_4
XFILLER_0_20_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc474 net950 net19 net738 net976 net1054 net812 VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__mux4_1
Xc496 clknet_1_0__leaf_net303 net988 net943 clknet_1_0__leaf_net403 clknet_1_0__leaf_net945
+ net763 VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__mux4_4
Xc485 net1070 clknet_1_1__leaf_net300 clknet_1_0__leaf_net947 net940 net1041 net1054
+ VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__mux4_2
XFILLER_0_19_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c558_C_N net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_10_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c222_A0 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c579_A3 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c283_S0 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net462 clknet_0_net462 VGND VGND VPWR VPWR clknet_1_0__leaf_net462
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c595_A2 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout147_X net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c301_X net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c413_C1 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_A3 clknet_1_0__leaf_net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clone22_X net1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc260 clknet_1_0__leaf_net191 clknet_1_1__leaf_net182 net51 net773 net774 net776 VGND
+ VGND VPWR VPWR net192 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc271 net200 net202 net198 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__and3_1
Xc293 net224 net222 net223 net876 net1063 net777 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__mux4_1
XANTENNA_c442_SCE net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc282 net198 net206 net212 net208 net668 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__o2111ai_1
XANTENNA_c696_A1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge781 net152 net139 VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__and2b_1
XFILLER_0_28_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge770 net77 net208 net988 net1021 net214 VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__o2111a_1
Xmerge792 clknet_4_15_0_clk merge792/D net305 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c217_A0 clknet_1_0__leaf_net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c278_S0 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c568_B net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold49 net801 VGND VGND VPWR VPWR net1140 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s956_Q net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c188_S0 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input37_A in41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_77_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c545_S1 net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net972 clknet_0_net972 VGND VGND VPWR VPWR clknet_1_1__leaf_net972
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_0_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c500_A0 net115 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net606 net606 VGND VGND VPWR VPWR clknet_0_net606 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net952_X clknet_1_0__leaf_net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net617 net617 VGND VGND VPWR VPWR clknet_0_net617 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_7_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c592_A3 net724 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout224_A net133 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c471_S0 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge767_S1 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c154_D1 net1077 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c365_S1 clknet_1_1__leaf_net762 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net246 clknet_0_net246 VGND VGND VPWR VPWR clknet_1_1__leaf_net246
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net257 clknet_0_net257 VGND VGND VPWR VPWR clknet_1_1__leaf_net257
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_57_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge849_SET_B net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold45_A net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c214_A1 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge854_GATE_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net780 clknet_0_net780 VGND VGND VPWR VPWR clknet_1_1__leaf_net780
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs908 clknet_4_11_0_clk net274 VGND VGND VPWR VPWR net970 net791 sky130_fd_sc_hd__dfxbp_1
XANTENNA_clkbuf_1_1__f_net778_X clknet_1_1__leaf_net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net403 net403 VGND VGND VPWR VPWR clknet_0_net403 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs919 net349 clknet_4_3_0_clk VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__dlxtn_2
Xclkbuf_0_net469 net469 VGND VGND VPWR VPWR clknet_0_net469 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c108_A2 net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_2_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s919_Q net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c466_S0 net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c185_S1 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net60 net60 VGND VGND VPWR VPWR clknet_0_net60 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_98_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c497_A3 net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c280_Q_N net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_57_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output68_A clknet_1_1__leaf_net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_66_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c688_A2 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_75_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_84_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s889_GATE_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c291_C_N net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c119_A1 clknet_1_0__leaf_net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc601 net448 net998 clknet_1_1__leaf_net934 net928 net212 net831 VGND VGND VPWR VPWR
+ net490 sky130_fd_sc_hd__mux4_1
Xc612 clknet_1_1__leaf_net499 net249 clknet_1_0__leaf_net498 clknet_1_1__leaf_net490
+ net378 clknet_1_0__leaf_net835 VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__mux4_2
Xc634 clknet_1_1__leaf_net517 clknet_1_1__leaf_net922 clknet_1_1__leaf_net510 net716
+ net722 clknet_1_1__leaf_net834 VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__mux4_2
XFILLER_0_32_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc623 clknet_1_1__leaf_net506 clknet_1_1__leaf_net508 clknet_1_1__leaf_net934 net769
+ net976 clknet_1_0__leaf_net924 VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__mux4_1
Xc689 net543 net443 net997 net983 clknet_1_1__leaf_net742 VGND VGND VPWR VPWR net553
+ sky130_fd_sc_hd__a2111oi_0
Xc678 net1042 net696 net728 clknet_1_0__leaf_net742 net1053 VGND VGND VPWR VPWR net542
+ sky130_fd_sc_hd__a2111oi_4
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc667 net995 net1011 net823 VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__nor3b_1
XANTENNA_c151_C1 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c113_SET_B net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c105_A3 net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c744_S0 net725 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c402_A1 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c463_S1 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c91_C net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c146_C1 net1149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc420 clknet_1_0__leaf_net238 net317 net232 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__nor3_4
XFILLER_0_20_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc442 clknet_4_3_0_clk net356 net237 clknet_1_0__leaf_net331 net214 net1079 VGND VGND
+ VPWR VPWR net932 net357 sky130_fd_sc_hd__sdfbbn_2
Xc464 clknet_1_0__leaf_net952 net1074 net1009 clknet_1_1__leaf_net778 net795 net808
+ VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__mux4_4
Xc431 net1019 net232 net343 net333 net998 net804 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__mux4_2
Xc453 net365 net359 clknet_1_0__leaf_net369 net341 net212 net676 VGND VGND VPWR VPWR
+ net370 sky130_fd_sc_hd__mux4_2
XFILLER_0_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc497 net329 clknet_1_0__leaf_net977 clknet_1_1__leaf_net403 net929 net796 clknet_1_1__leaf_net815
+ VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__mux4_1
Xc475 net950 net962 net1058 net785 net1054 net809 VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__mux4_2
Xc486 net377 net329 net295 net926 net768 net951 VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__mux4_1
XFILLER_0_35_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_82_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c685_A3 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net56 clknet_0_net56 VGND VGND VPWR VPWR clknet_1_0__leaf_net56 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net67 clknet_0_net67 VGND VGND VPWR VPWR clknet_1_0__leaf_net67 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge852_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c222_A1 net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c683_D_N net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net474 clknet_0_net474 VGND VGND VPWR VPWR clknet_1_0__leaf_net474
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_25_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c595_A3 net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c739_S0 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s901_Q net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout220 net1080 VGND VGND VPWR VPWR net1079 sky130_fd_sc_hd__buf_4
XANTENNA_c413_B1 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c474_S0 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc261 net192 clknet_1_1__leaf_net191 net949 net773 net774 net776 VGND VGND VPWR VPWR
+ net193 sky130_fd_sc_hd__mux4_1
Xc250 clknet_1_1__leaf_net181 clknet_1_1__leaf_net177 clknet_1_0__leaf_net182 net51
+ net926 clknet_1_0__leaf_net959 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc272 net198 net201 net202 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__nor3_2
Xc283 net213 net75 net206 net198 net1019 net674 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__mux4_2
Xc294 net225 net674 net1058 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__and3b_4
XFILLER_0_99_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge771 net420 net419 net421 net1154 net424 VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__a2111oi_1
Xmerge782 clknet_4_2_0_clk net319 net323 VGND VGND VPWR VPWR net649 net648 sky130_fd_sc_hd__dfrbp_1
XFILLER_0_55_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge793 net437 net630 VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__nand2_2
XFILLER_0_15_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c101_C net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c296_B net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c244_X net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net282 clknet_0_net282 VGND VGND VPWR VPWR clknet_1_0__leaf_net282
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_s949_Q net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c408_D_N net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c469_S0 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c188_S1 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c143_B1 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c318_A0 net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap206 net215 VGND VGND VPWR VPWR net1065 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_90_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net973 clknet_0_net973 VGND VGND VPWR VPWR clknet_1_1__leaf_net973
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_88_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c449_C_N net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c500_A1 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge814_GATE_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_0__f_net778_X clknet_1_0__leaf_net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c228_A0 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c309_B net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c194_X net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c752_S0 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c199_S0 net1070 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c304_A2 net657 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c601_A0 net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c320_A1 net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c442_RESET_B net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c572_S0 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c161_B net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c230_A1 net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs909 clknet_4_9_0_clk net276 VGND VGND VPWR VPWR net793 net792 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_44_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c747_S0 net699 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c482_S0 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net50 net50 VGND VGND VPWR VPWR clknet_0_net50 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c563_SCE net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0_net971 net971 VGND VGND VPWR VPWR clknet_0_net971 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c62_X net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_rebuffer25_X net1116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c392_S0 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net815 clknet_0_net815 VGND VGND VPWR VPWR clknet_1_0__leaf_net815
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_46_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_96_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c567_S0 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c225_A1 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c271_A net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_7_0_clk_X clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_A3 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c536_A net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net245 net245 VGND VGND VPWR VPWR clknet_0_net245 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c119_A2 net1072 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc613 net378 net487 net394 clknet_1_1__leaf_net483 clknet_1_0__leaf_net834 net836
+ VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__mux4_1
Xc602 net484 net19 net249 net481 net212 net826 VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__mux4_4
Xc635 net213 net1068 net717 net929 clknet_1_0__leaf_net798 clknet_1_0__leaf_net834
+ VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__mux4_4
Xc624 net511 net481 net1068 clknet_1_0__leaf_net924 net827 net838 VGND VGND VPWR VPWR
+ net513 sky130_fd_sc_hd__mux4_1
Xc679 net529 net535 clknet_1_0__leaf_net542 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__nand3b_4
Xc668 net529 net214 net1045 net995 net1042 net723 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__mux4_2
XANTENNA_input12_A in19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output80_A net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap135_X net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_22 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net623 clknet_0_net623 VGND VGND VPWR VPWR clknet_1_0__leaf_net623
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c236_A0 net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input4_A in11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c402_A2 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c760_S0 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c146_B1 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s905_GATE_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc410 net316 net999 net1109 net317 net714 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__o2111ai_4
Xc421 clknet_1_1__leaf_net238 net865 net657 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__nand3b_1
Xc454 net347 net342 net366 net896 net1014 net953 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__mux4_2
Xc432 clknet_4_3_0_clk net342 clknet_1_0__leaf_net331 net988 net343 net1142 VGND VGND
+ VPWR VPWR net347 net346 sky130_fd_sc_hd__sdfbbn_1
Xc443 net913 net908 net1049 VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__or3b_1
XFILLER_0_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc476 net329 net391 net281 clknet_1_1__leaf_net386 net787 net810 VGND VGND VPWR VPWR
+ net392 sky130_fd_sc_hd__mux4_1
Xc465 net377 clknet_1_0__leaf_net330 clknet_1_1__leaf_net331 net1130 net738 net787
+ VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__mux4_2
Xc487 clknet_1_1__leaf_net401 net339 net764 net768 net769 net770 VGND VGND VPWR VPWR
+ net403 sky130_fd_sc_hd__mux4_1
Xc498 net340 clknet_1_0__leaf_net977 net962 net770 clknet_1_1__leaf_net798 net818
+ VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__mux4_4
XANTENNA_c565_Q net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c312_A2 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c670_S0 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net57 clknet_0_net57 VGND VGND VPWR VPWR clknet_1_0__leaf_net57 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_93_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c222_A2 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c580_S0 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net475 clknet_0_net475 VGND VGND VPWR VPWR clknet_1_0__leaf_net475
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout210 net918 VGND VGND VPWR VPWR net1069 sky130_fd_sc_hd__clkbuf_4
Xfanout221 net133 VGND VGND VPWR VPWR net1080 sky130_fd_sc_hd__buf_2
XANTENNA_c413_A1 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input7_X net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c182_C_N net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c490_S0 net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c307_A2 net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc262 clknet_1_1__leaf_net182 clknet_1_1__leaf_net62 net949 clknet_1_1__leaf_net743
+ net774 net776 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__mux4_4
Xc251 clknet_1_0__leaf_net49 net1072 clknet_1_0__leaf_net182 clknet_1_0__leaf_net177
+ clknet_1_0__leaf_net181 net963 VGND VGND VPWR VPWR net971 sky130_fd_sc_hd__mux4_1
Xc240 net168 net174 net17 net960 net929 net772 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__mux4_1
XANTENNA_clkbuf_4_15_0_clk_X clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc284 net217 net1004 net75 net214 net674 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__a2111o_1
Xc273 net1006 net1004 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__and2_1
Xc295 net657 net668 net1058 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__nand3b_1
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c696_A3 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c538_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge772 net211 net996 net1006 net1036 net420 net1085 VGND VGND VPWR VPWR net637
+ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_31_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge783 clknet_4_2_0_clk net337 net338 VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__dfrtn_1
Xmerge794 net382 net398 VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__and2b_1
XFILLER_0_70_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c217_A2 clknet_1_1__leaf_net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c575_S0 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s951_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c289_B net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net250 clknet_0_net250 VGND VGND VPWR VPWR clknet_1_0__leaf_net250
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout152_X net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_rebuffer2_A net1150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c404_X net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c424_A0 net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c485_S0 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c155_C_N net1160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c318_A1 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c334_A0 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net974 clknet_0_net974 VGND VGND VPWR VPWR clknet_1_1__leaf_net974
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_0_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net952 clknet_0_net952 VGND VGND VPWR VPWR clknet_1_1__leaf_net952
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_88_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c500_A2 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c228_A1 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c309_C net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c410_A2 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c199_S1 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc537_1 clknet_1_1__leaf_net706 VGND VGND VPWR VPWR net1084 sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_76_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_rebuffer15_A net1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c154_B1 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input42_A in46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c304_A3 net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c601_A1 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge872_Q net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c556_D_N net757 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c361_D1 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c572_S1 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net760 clknet_0_net760 VGND VGND VPWR VPWR clknet_1_1__leaf_net760
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c230_A2 clknet_1_1__leaf_net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c419_B clknet_1_1__leaf_net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c747_S1 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c702_A0 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c763_S0 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c482_S1 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net62 net62 VGND VGND VPWR VPWR clknet_0_net62 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_79_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clone35_A net1159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net972 net972 VGND VGND VPWR VPWR clknet_0_net972 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c331_A1 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_22 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_hold50_A net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c567_S1 net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c241_A1 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c271_B net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c536_B net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net246 net246 VGND VGND VPWR VPWR clknet_0_net246 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net257 net257 VGND VGND VPWR VPWR clknet_0_net257 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge827_GATE clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c758_S0 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc603 net487 net481 net1074 net721 net731 net978 VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__mux4_1
XFILLER_0_32_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c416_A1 net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c477_S1 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc636 net521 net931 clknet_1_0__leaf_net922 clknet_1_0__leaf_net762 net814 net836
+ VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__mux4_2
Xc614 net492 clknet_1_0__leaf_net499 clknet_1_1__leaf_net490 net682 net831 clknet_1_1__leaf_net835
+ VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__mux4_1
Xc625 net512 net1040 net213 net925 net820 net944 VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__mux4_1
XFILLER_0_32_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc669 net719 VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c493_S0 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s946_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net780 net780 VGND VGND VPWR VPWR clknet_0_net780 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output73_A net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c280_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c578_S0 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c236_A1 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout182_X net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c488_S0 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc411 net311 net1065 net321 net995 net866 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__o2111a_1
Xc400 net1014 net1019 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__and2b_1
Xc455 net113 net357 net953 net785 VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__or4bb_4
Xc433 net316 net994 net347 net339 net343 net802 VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__mux4_1
Xc444 clknet_4_3_0_clk net358 net950 net124 clknet_1_0__leaf_net257 net1132 VGND VGND
+ VPWR VPWR net360 net359 sky130_fd_sc_hd__sdfbbp_1
Xc422 clknet_4_2_0_clk net1137 clknet_1_0__leaf_net331 net657 net1140 VGND VGND VPWR
+ VPWR net333 sky130_fd_sc_hd__sdfrtn_1
XPHY_EDGE_ROW_8_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc477 net7 net391 net12 net955 net812 net978 VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__mux4_1
Xc466 net281 net1077 net1037 net378 net808 net810 VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__mux4_4
Xc488 net119 net340 net1068 clknet_1_0__leaf_net403 net1041 net787 VGND VGND VPWR
+ VPWR net404 sky130_fd_sc_hd__mux4_4
XFILLER_0_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc499 clknet_1_0__leaf_net947 clknet_1_0__leaf_net403 net768 net771 net787 net819
+ VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__mux4_1
XANTENNA_c312_A3 net1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output111_A net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_11_0_clk_X clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c337_A0 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_net999_4_A clknet_1_1__leaf_net706 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge771_D1 net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c222_A3 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net465 clknet_0_net465 VGND VGND VPWR VPWR clknet_1_0__leaf_net465
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net498 clknet_0_net498 VGND VGND VPWR VPWR clknet_1_0__leaf_net498
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_34_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c401_B net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c755_S1 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout200 net963 VGND VGND VPWR VPWR net1059 sky130_fd_sc_hd__buf_4
Xfanout211 net903 VGND VGND VPWR VPWR net1070 sky130_fd_sc_hd__buf_4
Xfanout222 net1082 VGND VGND VPWR VPWR net1081 sky130_fd_sc_hd__buf_12
XFILLER_0_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c281_SET_B net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc230 net1118 net34 clknet_1_1__leaf_net153 clknet_1_0__leaf_net761 net767 net768
+ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__mux4_2
XFILLER_0_60_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc263 clknet_1_1__leaf_net185 net194 clknet_1_1__leaf_net62 clknet_1_1__leaf_net743
+ net774 net776 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__mux4_4
Xc252 net175 net1077 clknet_1_0__leaf_net177 clknet_1_0__leaf_net959 clknet_1_0__leaf_net182
+ net732 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__mux4_4
Xc241 clknet_1_1__leaf_net171 net85 net169 net175 net766 net769 VGND VGND VPWR VPWR
+ net957 sky130_fd_sc_hd__mux4_4
XANTENNA_c604_A1 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c427_SCE clknet_1_0__leaf_net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc285 net1004 net206 net217 net208 net668 net674 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__mux4_4
Xc296 net892 net221 net202 net98 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__or4bb_2
Xc274 net205 net1019 net1004 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__nand3b_2
XFILLER_0_46_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c620_A0 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c363_SCD net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge773 net231 net975 clknet_1_1__leaf_net246 net243 clknet_1_0__leaf_net245 net131
+ VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_31_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge784 net362 net361 VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__nor2_1
Xmerge795 clknet_4_9_0_clk net283 net271 VGND VGND VPWR VPWR net662 net661 sky130_fd_sc_hd__dfsbp_1
Xs890 net170 clknet_4_15_0_clk VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__dlxtp_1
XFILLER_0_70_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c575_S1 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c233_A2 clknet_1_1__leaf_net762 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c591_S0 net758 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c177_A net1160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c449_B net1079 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net251 clknet_0_net251 VGND VGND VPWR VPWR clknet_1_0__leaf_net251
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_38_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net273 clknet_0_net273 VGND VGND VPWR VPWR clknet_1_0__leaf_net273
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c539_D1 net1079 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c132_X net1158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout145_X net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c424_A1 clknet_1_0__leaf_net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c485_S1 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c143_A2 net1149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_98_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s900_Q_N net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c168_C1 net1076 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c334_A1 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_64_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c500_A3 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c228_A2 clknet_1_1__leaf_net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge860_GATE clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c244_A1 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c435_A0 net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input35_A in4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c601_A2 clknet_1_1__leaf_net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net238 clknet_0_net238 VGND VGND VPWR VPWR clknet_1_1__leaf_net238
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c320_A3 net1070 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c179_D1 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c429_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c361_C1 net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net761 clknet_0_net761 VGND VGND VPWR VPWR clknet_1_1__leaf_net761
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_49_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c239_A1 net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout222_A net1082 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c683_B net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c702_A1 net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net52 net52 VGND VGND VPWR VPWR clknet_0_net52 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_94_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c149_A1 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net973 net973 VGND VGND VPWR VPWR clknet_0_net973 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_26_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c612_A1 net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input38_X net897 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_44_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c225_A3 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c583_S1 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net591 clknet_0_net591 VGND VGND VPWR VPWR clknet_1_1__leaf_net591
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_53_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c317_Y net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c758_S1 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_62_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc604 clknet_1_0__leaf_net490 net1026 net467 clknet_1_1__leaf_net483 net731 net789
+ VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__mux4_1
XFILLER_0_32_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge873_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc637 net514 net284 clknet_1_1__leaf_net515 clknet_1_1__leaf_net510 clknet_1_1__leaf_net517
+ net722 VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__mux4_2
Xc626 net1002 net1020 clknet_1_1__leaf_net483 net1040 clknet_1_1__leaf_net510 net827
+ VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__mux4_2
Xc615 clknet_1_1__leaf_net498 net500 net487 clknet_1_0__leaf_net490 net682 net837
+ VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_73_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c282_D1 net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c428_RESET_B net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_71_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c75_D1 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_80_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c326_A2 net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge864_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s882_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge828_Q net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output66_A net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c342_A1 net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge769_D1 net657 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_S0 net1074 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c252_A1 net1077 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c162_X net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c541_A net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c488_S1 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc412 net1004 net322 net1000 net315 net1011 net995 VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__mux4_1
Xc401 net73 net866 net311 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__and3b_2
Xc434 net202 clknet_1_0__leaf_net332 net340 net988 net998 net650 VGND VGND VPWR VPWR
+ net349 sky130_fd_sc_hd__mux4_4
Xc423 clknet_4_2_0_clk net200 clknet_1_0__leaf_net332 net1019 net1000 net1137 VGND
+ VGND VPWR VPWR net335 net334 sky130_fd_sc_hd__sdfbbn_2
Xc445 clknet_1_0__leaf_net245 net345 net358 net913 VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__or4bb_1
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc467 clknet_1_1__leaf_net369 net377 net793 net795 clknet_1_1__leaf_net799 net1055
+ VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__mux4_4
Xc456 net1070 net346 net1009 net1061 net758 net807 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__mux4_2
Xc478 net391 net393 net1070 net801 net811 net978 VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__mux4_2
Xc489 clknet_1_0__leaf_net403 net1017 net1095 clknet_1_0__leaf_net946 clknet_1_0__leaf_net401
+ clknet_1_0__leaf_net300 VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_28_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output104_A net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c618_A0 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net48 clknet_0_net48 VGND VGND VPWR VPWR clknet_1_0__leaf_net48 sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge778_Q net644 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c337_A1 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge771_C1 net1154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net433 clknet_0_net433 VGND VGND VPWR VPWR clknet_1_0__leaf_net433
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net499 clknet_0_net499 VGND VGND VPWR VPWR clknet_1_0__leaf_net499
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout212 net903 VGND VGND VPWR VPWR net1071 sky130_fd_sc_hd__clkbuf_4
Xfanout201 net750 VGND VGND VPWR VPWR net1060 sky130_fd_sc_hd__buf_4
Xfanout223 net1083 VGND VGND VPWR VPWR net1082 sky130_fd_sc_hd__buf_12
XFILLER_0_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c438_A0 net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c499_S0 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clone10_A net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc220 net112 net1018 net990 clknet_1_1__leaf_net946 net1050 net961 VGND VGND VPWR
+ VPWR net157 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_79_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc242 clknet_1_0__leaf_net67 net65 clknet_1_0__leaf_net62 net1037 net1125 net765 VGND
+ VGND VPWR VPWR net176 sky130_fd_sc_hd__mux4_2
Xc253 net1076 net1101 clknet_1_0__leaf_net182 clknet_1_1__leaf_net177 net65 net749
+ VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__mux4_1
Xc231 net1075 net1083 clknet_1_1__leaf_net153 net1040 net763 net770 VGND VGND VPWR
+ VPWR net167 sky130_fd_sc_hd__mux4_4
Xc264 net77 net1038 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__and2_1
Xc286 net876 net1119 net889 net777 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__or4bb_2
Xc297 net224 net230 net668 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__nand3b_2
Xc275 net205 net199 net1004 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__and3b_2
XFILLER_0_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input20_X net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c363_SCE net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c348_A0 net727 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c202_S0 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge774 net1084 net524 net987 net533 net418 net700 VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__mux4_1
Xmerge796 net629 net619 VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_31_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge785 net444 net456 VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__nor2b_1
Xs880 clknet_4_11_0_clk net155 VGND VGND VPWR VPWR net966 sky130_fd_sc_hd__dfxtp_4
Xs891 net173 clknet_4_13_0_clk VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__lpflow_inputisolatch_1
XFILLER_0_43_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c233_A3 net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput1 in0 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__buf_8
XANTENNA_c591_S1 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c177_B net1159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c539_C1 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout138_X net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c705_A1 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c721_A0 net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c318_A3 net757 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c676_S1 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c631_A0 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c692_S0 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c350_A1 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net965 clknet_0_net965 VGND VGND VPWR VPWR clknet_1_1__leaf_net965
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_0_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net954 clknet_0_net954 VGND VGND VPWR VPWR clknet_1_1__leaf_net954
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_64_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c228_A3 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c586_S1 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c400_A_N net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c287_A net1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c451_A0 net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s885_Q_N net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input28_A in33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c601_A3 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c179_C1 net1070 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c687_S0 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c626_A0 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c345_A1 clknet_1_0__leaf_net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output96_A net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c361_B1 net1078 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net762 clknet_0_net762 VGND VGND VPWR VPWR clknet_1_1__leaf_net762
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c597_S0 net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout215_A net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge849_Q_N net722 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c64_A0 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s884_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net952 net952 VGND VGND VPWR VPWR clknet_0_net952 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net974 net974 VGND VGND VPWR VPWR clknet_0_net974 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_rebuffer20_A net1157 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c356_A0 net40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_96_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net592 clknet_0_net592 VGND VGND VPWR VPWR clknet_1_1__leaf_net592
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout218_X net1077 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c416_A3 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc627 net481 net1096 net928 net1062 net716 clknet_1_0__leaf_net924 VGND VGND VPWR
+ VPWR net516 sky130_fd_sc_hd__mux4_4
XFILLER_0_32_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc605 clknet_1_0__leaf_net493 net394 net284 net487 net1026 net721 VGND VGND VPWR VPWR
+ net494 sky130_fd_sc_hd__mux4_2
Xc616 net1017 net249 net821 net827 net933 net838 VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_73_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c282_C1 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0_net760 net760 VGND VGND VPWR VPWR clknet_0_net760 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_23_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclone40 net916 net861 net1081 VGND VGND VPWR VPWR net1158 sky130_fd_sc_hd__or3_1
XANTENNA_c607_A2 net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_rebuffer23_X net1114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c326_A3 net734 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input50_X net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c192_C1 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c209_SCD net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c342_A2 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge769_C1 net644 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net604 clknet_0_net604 VGND VGND VPWR VPWR clknet_1_0__leaf_net604
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c205_S0 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_S1 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c534_A clknet_1_1__leaf_net706 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c559_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c708_A1 net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc402 net1011 net1026 net211 net1113 net1006 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__a2111oi_1
Xc413 net315 net321 net1014 net1011 net1131 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__o2111ai_4
Xc424 net880 clknet_1_0__leaf_net330 net335 clknet_1_0__leaf_net331 net317 net329
+ VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__mux4_1
Xc435 net324 net232 net229 net342 net994 net806 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__mux4_4
Xc446 net345 net734 net1060 net758 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__or4bb_1
Xc457 net366 net371 net1130 clknet_1_1__leaf_net332 net713 VGND VGND VPWR VPWR net374
+ sky130_fd_sc_hd__a2111o_4
Xc468 clknet_1_1__leaf_net369 clknet_1_1__leaf_net952 net738 net793 net807 net810
+ VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__mux4_4
Xc479 net393 clknet_1_1__leaf_net952 clknet_1_1__leaf_net330 clknet_1_1__leaf_net799
+ net807 net812 VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__mux4_4
XANTENNA_c126_D_N net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input10_A in17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge782_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net49 clknet_0_net49 VGND VGND VPWR VPWR clknet_1_0__leaf_net49 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c618_A1 clknet_1_1__leaf_net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c337_A2 net1072 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c353_A1 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net423 clknet_0_net423 VGND VGND VPWR VPWR clknet_1_0__leaf_net423
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net401 clknet_0_net401 VGND VGND VPWR VPWR clknet_1_0__leaf_net401
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c589_S1 net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c247_A2 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c115_A net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c544_A0 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout213 net1073 VGND VGND VPWR VPWR net1072 sky130_fd_sc_hd__buf_4
Xfanout224 net133 VGND VGND VPWR VPWR net1083 sky130_fd_sc_hd__buf_12
XANTENNA_input2_A in1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clone10_B net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c68_A net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc210 net990 net1075 net6 net146 net1112 net759 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_79_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc221 net1112 net4 net147 net990 net112 clknet_1_0__leaf_net761 VGND VGND VPWR VPWR
+ net158 sky130_fd_sc_hd__mux4_2
XFILLER_0_32_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input58_A in60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc254 clknet_1_0__leaf_net62 clknet_1_1__leaf_net182 net51 clknet_1_1__leaf_net177
+ clknet_1_0__leaf_net185 net956 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__mux4_1
Xc232 net913 net1112 net85 net112 net764 net767 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__mux4_1
Xc243 net1101 net1076 clknet_1_0__leaf_net959 net1072 net943 net1059 VGND VGND VPWR
+ VPWR net177 sky130_fd_sc_hd__mux4_2
Xc287 net1119 net1025 net95 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__and3_2
Xc276 net71 net206 net205 net1019 net425 net1126 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__mux4_2
Xc265 net86 net866 net1051 net1128 net1019 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__a2111o_2
Xc298 net230 net224 net889 net1006 net880 net1058 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_5_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A2 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input13_X net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c629_A0 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c198_D1 net1052 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c202_S1 net1125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge786 clknet_4_0_0_clk net553 net559 VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__dfrtp_2
Xmerge775 net418 net995 net1108 net982 net532 net1042 VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_31_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge797 net491 net494 VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__and2_2
Xs881 clknet_4_11_0_clk net156 VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__dlclkp_1
Xs892 clknet_4_15_0_clk net183 VGND VGND VPWR VPWR net956 net773 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput2 in1 VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_67_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net275 clknet_0_net275 VGND VGND VPWR VPWR clknet_1_0__leaf_net275
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net253 clknet_0_net253 VGND VGND VPWR VPWR clknet_1_0__leaf_net253
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout200_X net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c705_A2 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c721_A1 net1080 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c184_A0 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c334_A3 clknet_1_0__leaf_net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c281_SCE net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c631_A1 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net922 clknet_0_net922 VGND VGND VPWR VPWR clknet_1_1__leaf_net922
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c551_C_N net1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net977 clknet_0_net977 VGND VGND VPWR VPWR clknet_1_1__leaf_net977
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c213_S0 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c294_C net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c287_B net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout195_A net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout150_X net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c716_A1 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c179_B1 net1072 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c329_A3 net657 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c626_A1 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c345_A2 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c239_A3 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_8_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c597_S1 net814 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput60 in7 VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__buf_1
XANTENNA_fanout208_A net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c552_B1 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s917_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s958_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net54 net54 VGND VGND VPWR VPWR clknet_0_net54 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_67_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c727_A0 net541 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s939_SLEEP_B clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c462_A0 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input40_A in44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c181_A1 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c540_CLK_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_46_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c300_A_N net1159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c698_S0 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c356_A1 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net560 clknet_0_net560 VGND VGND VPWR VPWR clknet_1_1__leaf_net560
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout158_A net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net238 net238 VGND VGND VPWR VPWR clknet_0_net238 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc617 net481 net505 net771 net1056 clknet_1_1__leaf_net927 net839 VGND VGND VPWR VPWR
+ net506 sky130_fd_sc_hd__mux4_2
Xc606 clknet_1_1__leaf_net493 net1002 net492 net487 net1010 net939 VGND VGND VPWR
+ VPWR net495 sky130_fd_sc_hd__mux4_2
Xc628 clknet_1_1__leaf_net508 net930 net1068 clknet_1_0__leaf_net762 net771 net1056
+ VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_73_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c713_A2 net1078 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c282_B1 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c457_B1 net1130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net761 net761 VGND VGND VPWR VPWR clknet_0_net761 sky130_fd_sc_hd__clkbuf_16
Xclone41 net72 VGND VGND VPWR VPWR net1159 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c607_A3 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c623_A2 clknet_1_1__leaf_net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_s900_GATE_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c221_S0 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c252_A3 clknet_1_0__leaf_net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c708_A2 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s922_Q net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c315_X net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc403 net75 net88 net1119 net1026 net309 net866 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__mux4_1
XFILLER_0_4_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc425 net220 net880 clknet_1_0__leaf_net331 net882 net804 VGND VGND VPWR VPWR net337
+ sky130_fd_sc_hd__o2111ai_1
Xc436 net1108 net339 net329 net315 net805 net1055 VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__mux4_1
Xc414 net866 net324 net1000 net1014 net312 net649 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__mux4_4
Xc458 net347 net357 net684 net713 net1059 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__o2111a_1
Xc447 clknet_4_3_0_clk net360 clknet_1_1__leaf_net332 net882 net1049 net808 VGND VGND
+ VPWR VPWR net364 net363 sky130_fd_sc_hd__sdfbbn_1
Xc469 clknet_1_1__leaf_net330 net329 net962 net793 net1054 net809 VGND VGND VPWR VPWR
+ net385 sky130_fd_sc_hd__mux4_2
XFILLER_0_99_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_28_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c618_A2 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net591 net591 VGND VGND VPWR VPWR clknet_0_net591 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_93_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c353_A2 net740 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output71_A net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c247_A3 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c544_A1 clknet_1_0__leaf_net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout203 net698 VGND VGND VPWR VPWR net1062 sky130_fd_sc_hd__buf_4
Xfanout214 net901 VGND VGND VPWR VPWR net1073 sky130_fd_sc_hd__buf_2
XFILLER_0_1_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout180_X net1159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c710_A3 net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c272_Y net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c719_A1 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_81_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c438_A2 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c735_A0 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc200 net909 net23 net1015 net68 net708 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__a2111oi_1
XTAP_TAPCELL_ROW_79_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc211 net138 net146 net106 net141 net759 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__a2111oi_4
Xc222 net1050 net36 net913 net106 net1041 net666 VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__mux4_2
Xc244 clknet_1_1__leaf_net177 net926 clknet_1_0__leaf_net62 net969 clknet_1_0__leaf_net744
+ net755 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__mux4_4
Xc233 net147 clknet_1_1__leaf_net744 clknet_1_1__leaf_net762 net929 net768 net769
+ VGND VGND VPWR VPWR net972 sky130_fd_sc_hd__mux4_4
XPHY_EDGE_ROW_68_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc255 clknet_1_1__leaf_net67 net35 clknet_1_1__leaf_net184 net949 clknet_1_1__leaf_net761
+ net773 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__mux4_4
Xc288 net96 net1126 net1063 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__nand3b_4
Xc277 net1034 net207 net201 net205 net199 net1078 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__mux4_2
Xc266 net425 net197 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__nor2_1
Xc299 net223 net98 net232 net222 c299/S0 net757 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__mux4_4
XANTENNA_c470_A0 clknet_1_0__leaf_net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c198_C1 net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge776 net53 net59 VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__nor2_2
Xmerge787 net109 net110 VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__or2_1
Xmerge765 net83 net418 net419 net88 net802 VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__a2111o_1
Xmerge798 clknet_4_14_0_clk net47 net633 VGND VGND VPWR VPWR net666 net665 sky130_fd_sc_hd__dfsbp_1
Xs882 clknet_4_14_0_clk net157 VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__dlclkp_2
Xs893 clknet_4_15_0_clk net187 VGND VGND VPWR VPWR net775 net774 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 in10 VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_67_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c539_A1 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c705_A3 net1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c440_A3 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c303_S1 clknet_1_1__leaf_net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c80_A net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c465_A0 net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c201_CLK_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c631_A2 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c350_A3 net727 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net934 clknet_0_net934 VGND VGND VPWR VPWR clknet_1_1__leaf_net934
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net945 clknet_0_net945 VGND VGND VPWR VPWR clknet_1_1__leaf_net945
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c359_A1 net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_16_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c182_B net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c287_C net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_4_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout143_X net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c285_A0 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c716_A2 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c732_A1 clknet_1_1__leaf_net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c451_A2 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c179_A1 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c345_A3 net1125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net742 clknet_0_net742 VGND VGND VPWR VPWR clknet_1_1__leaf_net742
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_49_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_max_cap206_X net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net797 clknet_0_net797 VGND VGND VPWR VPWR clknet_1_1__leaf_net797
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput50 in53 VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__clkbuf_2
Xinput61 in8 VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c557_A net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c279_C_N net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s952_Q net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c64_A2 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c727_A1 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net965 net965 VGND VGND VPWR VPWR clknet_0_net965 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net954 net954 VGND VGND VPWR VPWR clknet_0_net954 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s894_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c462_A1 net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c181_A2 net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input33_A in38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c698_S1 net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c637_A1 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge863_Q net740 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c356_A2 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge867_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c372_A1 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_22_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c138_A net1066 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout220_A net1080 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s876_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc618 net1040 clknet_1_1__leaf_net934 net939 net1054 net827 clknet_1_1__leaf_net833
+ VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__mux4_4
Xc607 net485 net492 net237 net378 net789 clknet_1_0__leaf_net833 VGND VGND VPWR VPWR
+ net496 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_73_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc629 net455 net507 clknet_1_1__leaf_net483 net928 clknet_1_1__leaf_net927 net836
+ VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_31_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c713_A3 net1073 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c674_A net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_40_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c100_D1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clone26_A net1158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclone42 net90 VGND VGND VPWR VPWR net1160 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net762 net762 VGND VGND VPWR VPWR clknet_0_net762 sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge849_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_12_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c623_A3 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net606 clknet_0_net606 VGND VGND VPWR VPWR clknet_1_0__leaf_net606
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net617 clknet_0_net617 VGND VGND VPWR VPWR clknet_1_0__leaf_net617
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c502_S0 net814 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c277_A1 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c412_S0 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c131_S1 clknet_1_0__leaf_net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout223_X net1082 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c724_A2 net541 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc426 clknet_1_0__leaf_net332 net1019 net214 net1142 net805 VGND VGND VPWR VPWR net338
+ sky130_fd_sc_hd__a2111oi_1
Xc437 net351 net345 net333 net220 net343 net1055 VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__mux4_1
Xc404 net307 net1011 net314 net202 VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__or4bb_4
Xc415 net322 net197 net312 net995 net316 net714 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__mux4_4
Xc459 net373 net371 net672 net1058 net807 VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__a2111o_4
Xc448 net360 net341 net1055 VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__nor3_1
XANTENNA_c677_X net541 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c740_A1 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c86_A0 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c618_A3 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net592 net592 VGND VGND VPWR VPWR clknet_0_net592 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge771_A2 net419 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output64_A net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s938_GATE clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net403 clknet_0_net403 VGND VGND VPWR VPWR clknet_1_0__leaf_net403
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net469 clknet_0_net469 VGND VGND VPWR VPWR clknet_1_0__leaf_net469
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_6_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout204 net698 VGND VGND VPWR VPWR net1063 sky130_fd_sc_hd__buf_4
Xfanout215 net894 VGND VGND VPWR VPWR net1074 sky130_fd_sc_hd__clkbuf_8
XANTENNA_c560_A1 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c719_A2 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c68_C net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc201 clknet_4_11_0_clk net134 net20 net1075 net130 net878 VGND VGND VPWR VPWR net138
+ net137 sky130_fd_sc_hd__sdfbbn_2
XTAP_TAPCELL_ROW_79_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc212 net135 net130 net12 net991 clknet_1_0__leaf_net743 net759 VGND VGND VPWR VPWR
+ net150 sky130_fd_sc_hd__mux4_4
Xc223 clknet_1_1__leaf_net153 net35 net961 net755 net966 clknet_1_0__leaf_net761 VGND
+ VGND VPWR VPWR net159 sky130_fd_sc_hd__mux4_4
Xc245 clknet_1_1__leaf_net177 net1037 net51 clknet_1_1__leaf_net744 net1059 net966
+ VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__mux4_1
Xc234 net147 net1114 net1070 net966 net763 net770 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__mux4_1
XANTENNA_c751_A0 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc256 clknet_1_0__leaf_net182 net1077 net749 net929 net956 net775 VGND VGND VPWR VPWR
+ net188 sky130_fd_sc_hd__mux4_2
Xc267 net89 net198 net1025 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__nand3_2
Xc278 net208 net196 net202 net1004 net988 net425 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__mux4_1
Xc289 net206 net95 net1019 net1128 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__or4bb_2
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c470_A1 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge766_A2 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c198_B1 net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output102_A net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge766 net31 net44 net872 net907 clknet_1_0__leaf_net48 net32 VGND VGND VPWR VPWR
+ net631 sky130_fd_sc_hd__mux4_2
Xmerge777 net176 net186 VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__and2_4
Xmerge788 net472 net480 VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__nor2b_4
Xs894 clknet_4_15_0_clk net190 VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__dfxtp_1
Xmerge799 clknet_4_14_0_clk net163 net164 VGND VGND VPWR VPWR net960 sky130_fd_sc_hd__dfstp_1
Xs883 clknet_4_14_0_clk net158 VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c364_A2 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c227_S0 clknet_1_1__leaf_net762 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput4 in11 VGND VGND VPWR VPWR net863 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_67_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c258_A3 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_0__f_net959_X clknet_1_0__leaf_net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_4_0_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c555_A1 net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_30_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_5_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c465_A1 clknet_1_0__leaf_net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c631_A3 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net924 clknet_0_net924 VGND VGND VPWR VPWR clknet_1_1__leaf_net924
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net946 clknet_0_net946 VGND VGND VPWR VPWR clknet_1_1__leaf_net946
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net957 clknet_0_net957 VGND VGND VPWR VPWR clknet_1_1__leaf_net957
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c359_A2 net725 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c129_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_87_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c566_B1 net757 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge855_RESET_B net489 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_96_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout136_X net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c67_D_N net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c732_A2 net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c451_A3 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c103_D1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c476_A0 net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c195_A1 net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c626_A3 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_max_cap146_A net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net743 clknet_0_net743 VGND VGND VPWR VPWR clknet_1_1__leaf_net743
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_49_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net798 clknet_0_net798 VGND VGND VPWR VPWR clknet_1_1__leaf_net798
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c240_S0 net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput40 in44 VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__clkbuf_2
Xinput51 in54 VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__buf_1
Xinput62 in9 VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__buf_1
XFILLER_0_12_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c552_A2 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net56 net56 VGND VGND VPWR VPWR clknet_0_net56 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net67 net67 VGND VGND VPWR VPWR clknet_0_net67 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_67_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c99_C_N net1071 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net922 net922 VGND VGND VPWR VPWR clknet_0_net922 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c727_A2 clknet_1_1__leaf_net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net977 net977 VGND VGND VPWR VPWR clknet_0_net977 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c743_A1 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c462_A2 clknet_1_0__leaf_net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c181_A3 net1068 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input26_A in31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c356_A3 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge856_Q net734 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_output94_A net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c235_S0 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net562 clknet_0_net562 VGND VGND VPWR VPWR clknet_1_1__leaf_net562
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net595 clknet_0_net595 VGND VGND VPWR VPWR clknet_1_1__leaf_net595
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c678_D1 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c547_A2 net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout213_A net1073 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc608 net394 clknet_1_0__leaf_net493 net683 net783 net831 clknet_1_0__leaf_net833
+ VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__mux4_2
Xc619 clknet_1_0__leaf_net506 net1017 net357 net930 clknet_1_0__leaf_net927 clknet_1_1__leaf_net834
+ VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__mux4_2
XFILLER_0_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_73_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c667_A net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s895_Q net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclone10 net916 net920 net1066 VGND VGND VPWR VPWR net1101 sky130_fd_sc_hd__or3b_1
XFILLER_0_35_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge769_A2 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c355_RESET_B net740 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c367_A2 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c277_A2 net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c412_S1 net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c574_A0 net1152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c308_Y net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c293_A1 net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout216_X net1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c724_A3 net699 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net934_X clknet_1_1__leaf_net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s908_Q net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc416 net317 net324 net1000 net1004 net995 net648 VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__mux4_1
Xc405 net314 net307 net214 VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__and3b_2
Xc427 clknet_4_3_0_clk net329 net1006 clknet_1_0__leaf_net331 clknet_1_0__leaf_net330
+ net220 VGND VGND VPWR VPWR net340 net339 sky130_fd_sc_hd__sdfbbn_2
Xmax_cap170 net1030 VGND VGND VPWR VPWR net1029 sky130_fd_sc_hd__clkbuf_2
Xc438 net222 clknet_1_0__leaf_net332 net1006 net650 net800 net804 VGND VGND VPWR VPWR
+ net353 sky130_fd_sc_hd__mux4_4
Xc449 net365 net1079 net1061 net783 VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__or4bb_1
XANTENNA_c740_A2 net1077 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c749_A0 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net560 net560 VGND VGND VPWR VPWR clknet_0_net560 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c484_A0 net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c544_A3 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout205 net5 VGND VGND VPWR VPWR net1064 sky130_fd_sc_hd__buf_4
XFILLER_0_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout216 net891 VGND VGND VPWR VPWR net1075 sky130_fd_sc_hd__buf_4
XANTENNA_c560_A2 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c153_X net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout166_X net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net971 clknet_0_net971 VGND VGND VPWR VPWR clknet_1_0__leaf_net971
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_33_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_79_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc202 net121 net1075 net112 net21 net119 net1125 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__mux4_1
XANTENNA_c454_A3 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc224 net969 net1118 clknet_1_1__leaf_net153 net666 net681 net764 VGND VGND VPWR VPWR
+ net160 sky130_fd_sc_hd__mux4_1
Xc213 clknet_1_1__leaf_net145 net149 net137 net92 net1020 net708 VGND VGND VPWR VPWR
+ net151 sky130_fd_sc_hd__mux4_2
Xc235 net4 net990 net961 net767 net769 net770 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__mux4_1
XFILLER_0_32_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc257 clknet_1_1__leaf_net188 clknet_1_1__leaf_net182 net64 net756 net773 net775 VGND
+ VGND VPWR VPWR net189 sky130_fd_sc_hd__mux4_4
Xc246 clknet_1_1__leaf_net179 net46 clknet_1_0__leaf_net959 net1077 clknet_1_0__leaf_net177
+ net966 VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__mux4_2
Xc279 net201 net199 net207 net668 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__or4bb_2
Xc268 net197 net83 net425 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__or3b_4
XANTENNA_c470_A2 net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c629_A3 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge778 clknet_4_10_0_clk net125 net126 VGND VGND VPWR VPWR net644 net643 sky130_fd_sc_hd__dfrbp_2
Xmerge767 net987 net1086 net995 net1111 net424 net217 VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__mux4_4
Xs884 net159 clknet_4_15_0_clk VGND VGND VPWR VPWR net764 net763 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_24_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge789 net410 net411 VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__and2b_1
Xs895 clknet_4_8_0_clk net219 VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c227_S1 net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput5 in12 VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_36_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c243_S0 net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net245 clknet_0_net245 VGND VGND VPWR VPWR clknet_1_0__leaf_net245
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c270_X net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c153_S0 net1101 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c600_S1 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c184_A3 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_rebuffer29_A net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c481_A1 net1072 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input56_A in59 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net947 clknet_0_net947 VGND VGND VPWR VPWR clknet_1_1__leaf_net947
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_87_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c359_A3 net740 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c238_S0 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c701_S0 net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c566_A1 net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c285_A2 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout129_X net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c330_S1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c69_X net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_merge801_Q net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net744 clknet_0_net744 VGND VGND VPWR VPWR clknet_1_1__leaf_net744
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c505_S1 net725 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net799 clknet_0_net799 VGND VGND VPWR VPWR clknet_1_1__leaf_net799
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput30 in35 VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__buf_4
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput41 in45 VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__buf_2
Xinput52 in55 VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__buf_1
XFILLER_0_12_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c557_C net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net57 net57 VGND VGND VPWR VPWR clknet_0_net57 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c727_A3 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net934 net934 VGND VGND VPWR VPWR clknet_0_net934 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c431_S0 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s938_Q net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_526 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net945 net945 VGND VGND VPWR VPWR clknet_0_net945 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c743_A2 net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c462_A3 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s952_GATE_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c606_S0 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input19_A in25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c322_CLK_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c691_SET_B net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output87_A clknet_1_1__leaf_net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c372_A3 net1068 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c235_S1 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net552 clknet_0_net552 VGND VGND VPWR VPWR clknet_1_1__leaf_net552
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net585 clknet_0_net585 VGND VGND VPWR VPWR clknet_1_1__leaf_net585
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net934_X clknet_1_0__leaf_net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc609 net882 net487 net1056 net1054 clknet_1_0__leaf_net833 clknet_1_1__leaf_net835
+ VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_73_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c288_Y net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c667_B net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout196_X net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c183_X net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s888_Q net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c738_A2 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net742 net742 VGND VGND VPWR VPWR clknet_0_net742 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclone11 net1039 net1015 net1070 net757 VGND VGND VPWR VPWR net1151 sky130_fd_sc_hd__or4bb_1
XTAP_TAPCELL_ROW_23_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclone22 net72 VGND VGND VPWR VPWR net1113 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net797 net797 VGND VGND VPWR VPWR clknet_0_net797 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c473_A2 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c336_S0 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge799_Q net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c367_A3 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout209_X net1068 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_1_1__f_net927_X clknet_1_1__leaf_net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc417 net312 net1039 net1000 net714 net800 net803 VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__mux4_2
Xc428 clknet_4_2_0_clk net333 net988 net1000 net334 net200 VGND VGND VPWR VPWR net342
+ net341 sky130_fd_sc_hd__sdfbbp_1
Xc406 net1021 net311 net312 VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__or3_4
Xmax_cap171 net1031 VGND VGND VPWR VPWR net1030 sky130_fd_sc_hd__buf_1
XFILLER_0_13_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc439 net348 net228 net346 net232 net351 net807 VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c749_A1 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c603_S1 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input41_X net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c286_D_N net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout217 net890 VGND VGND VPWR VPWR net1076 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_19_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c704_S0 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c569_A1 net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout159_X net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_81_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net972 clknet_0_net972 VGND VGND VPWR VPWR clknet_1_0__leaf_net972
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c418_Y net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c735_A3 net1078 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_28_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s920_Q net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_61_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc203 net1068 net127 net1018 net7 net130 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__a2111oi_2
XANTENNA_c106_CLK_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc214 net878 net6 clknet_1_0__leaf_net145 clknet_1_0__leaf_net705 clknet_1_0__leaf_net743
+ VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__a2111oi_0
Xc225 net147 net926 clknet_1_1__leaf_net705 net966 clknet_1_1__leaf_net762 net765
+ VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__mux4_2
Xc236 net40 net1067 clknet_1_0__leaf_net761 net764 net769 net770 VGND VGND VPWR VPWR
+ net171 sky130_fd_sc_hd__mux4_2
XFILLER_0_20_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc258 clknet_1_0__leaf_net184 clknet_1_0__leaf_net62 clknet_1_1__leaf_net744 net966
+ net956 net775 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__mux4_1
Xc247 net65 clknet_1_0__leaf_net177 net967 net960 net966 clknet_1_1__leaf_net761 VGND
+ VGND VPWR VPWR net180 sky130_fd_sc_hd__mux4_4
XANTENNA_c751_A2 net724 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc269 net199 net866 net200 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__and3b_2
XANTENNA_c470_A3 net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c614_S0 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c333_S1 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clone34_X net1125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c495_A0 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge768 net29 net31 net28 net16 net25 VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__o2111ai_1
Xmerge779 net287 net304 VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__nor2b_4
Xs885 net160 clknet_4_15_0_clk VGND VGND VPWR VPWR net929 net765 sky130_fd_sc_hd__dlxbn_2
XFILLER_0_24_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c428_SET_B net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs896 clknet_4_8_0_clk net226 VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge831_Q net702 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput6 in13 VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c243_S1 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net246 clknet_0_net246 VGND VGND VPWR VPWR clknet_1_0__leaf_net246
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net257 clknet_0_net257 VGND VGND VPWR VPWR clknet_1_0__leaf_net257
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c299_A1 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c434_S0 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c535_Y net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c430_X net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net780 clknet_0_net780 VGND VGND VPWR VPWR clknet_1_0__leaf_net780
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c465_A3 net1130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input49_A in52 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net937 clknet_0_net937 VGND VGND VPWR VPWR clknet_1_1__leaf_net937
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net959 clknet_0_net959 VGND VGND VPWR VPWR clknet_1_1__leaf_net959
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_87_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_1_0__f_net330_X clknet_1_0__leaf_net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c238_S1 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c697_D1 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c566_A2 net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c285_A3 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c404_D_N net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c478_X net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c78_A3 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_87_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c611_S1 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c195_A3 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s897_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net778 clknet_0_net778 VGND VGND VPWR VPWR clknet_1_1__leaf_net778
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c693_C_N net1157 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput31 in36 VGND VGND VPWR VPWR net890 sky130_fd_sc_hd__buf_1
Xinput20 in26 VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__buf_2
XFILLER_0_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput53 in56 VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__buf_1
Xinput42 in46 VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_560 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c204_C1 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c684_C_N net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c712_S0 net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s918_GATE clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net924 net924 VGND VGND VPWR VPWR clknet_0_net924 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net946 net946 VGND VGND VPWR VPWR clknet_0_net946 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net957 net957 VGND VGND VPWR VPWR clknet_0_net957 sky130_fd_sc_hd__clkbuf_16
XANTENNA_s879_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c743_A3 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c159_S0 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c606_S1 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c487_A1 net339 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c81_X net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net542 clknet_0_net542 VGND VGND VPWR VPWR clknet_1_1__leaf_net542
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c251_S1 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c176_X net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c588_A0 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_84_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s890_GATE clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_47_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net743 net743 VGND VGND VPWR VPWR clknet_0_net743 sky130_fd_sc_hd__clkbuf_16
Xclone34 net133 VGND VGND VPWR VPWR net1125 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_23_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net798 net798 VGND VGND VPWR VPWR clknet_0_net798 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_95_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c617_S0 clknet_1_1__leaf_net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input31_A in36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c336_S1 net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c498_A0 net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c352_S0 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge861_Q net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c246_S1 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c689_C1 net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c293_A3 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc418 net315 net200 net803 VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__nor3_4
Xc407 net317 net308 net1129 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__nand3b_1
XFILLER_0_13_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c590_A1 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc429 clknet_4_2_0_clk net340 net324 net333 net650 VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__sdfrtp_2
Xmax_cap172 net80 VGND VGND VPWR VPWR net1031 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_99_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c460_X net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c749_A2 net1078 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net562 net562 VGND VGND VPWR VPWR clknet_0_net562 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c484_A2 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net595 net595 VGND VGND VPWR VPWR clknet_0_net595 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_50_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c347_S0 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout207 net68 VGND VGND VPWR VPWR net1066 sky130_fd_sc_hd__buf_12
Xfanout218 net885 VGND VGND VPWR VPWR net1077 sky130_fd_sc_hd__buf_6
XFILLER_0_66_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net191 clknet_0_net191 VGND VGND VPWR VPWR clknet_1_1__leaf_net191
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c704_S1 net824 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c569_A2 net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_53_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net973 clknet_0_net973 VGND VGND VPWR VPWR clknet_1_0__leaf_net973
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout221_X net1080 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc204 net138 net913 net14 net1062 net708 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__o2111a_1
XTAP_TAPCELL_ROW_79_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc215 net20 net1071 clknet_1_1__leaf_net946 net149 clknet_1_0__leaf_net743 VGND VGND
+ VPWR VPWR net152 sky130_fd_sc_hd__o2111ai_2
Xc226 net926 net30 net1018 net1108 net756 clknet_1_0__leaf_net761 VGND VGND VPWR VPWR
+ net162 sky130_fd_sc_hd__mux4_2
XFILLER_0_32_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_92_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc259 net949 clknet_1_1__leaf_net761 net765 net956 net775 net776 VGND VGND VPWR VPWR
+ net191 sky130_fd_sc_hd__mux4_4
Xc237 net30 net1016 net168 net763 net766 net771 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__mux4_1
Xc248 net36 clknet_1_0__leaf_net177 clknet_1_0__leaf_net179 net732 net749 clknet_1_1__leaf_net761
+ VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__mux4_2
XFILLER_0_99_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge769 net240 net209 net131 net644 net657 VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__o2111ai_1
Xs886 net161 clknet_4_15_0_clk VGND VGND VPWR VPWR net767 net766 sky130_fd_sc_hd__dlxbp_1
Xs897 clknet_4_8_0_clk net235 VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__dlclkp_1
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc760 net1123 net697 net736 net747 net813 net840 VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__mux4_1
Xinput7 in14 VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__buf_2
XFILLER_0_36_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c686_B1 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_30_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c432_SCD net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c715_S0 net824 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c596_A0 net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c746_A3 net724 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c66_C net1083 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c481_A3 clknet_1_0__leaf_net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s935_GATE_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c423_SCD net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net927 clknet_0_net927 VGND VGND VPWR VPWR clknet_1_1__leaf_net927
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net938 clknet_0_net938 VGND VGND VPWR VPWR clknet_1_1__leaf_net938
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c344_S1 net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output100_A clknet_1_0__leaf_net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_1_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c177_D_N net757 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_47_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc590 clknet_1_1__leaf_net475 net378 net1058 net1055 net829 net830 VGND VGND VPWR
+ VPWR net479 sky130_fd_sc_hd__mux4_4
XFILLER_0_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_35_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_65_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c582_A2 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c180_S0 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c476_A3 clknet_1_1__leaf_net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c128_D1 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c492_A2 net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input61_A in8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_92_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net779 clknet_0_net779 VGND VGND VPWR VPWR clknet_1_1__leaf_net779
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c310_C1 net657 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput10 in17 VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_12_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput21 in27 VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__buf_2
Xinput54 in57 VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__clkbuf_4
Xinput43 in47 VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__buf_1
Xinput32 in37 VGND VGND VPWR VPWR net891 sky130_fd_sc_hd__buf_2
XFILLER_0_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c249_S1 net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net48 net48 VGND VGND VPWR VPWR clknet_0_net48 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_79_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c133_C_N net1066 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout179_A net1159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout134_X net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net947 net947 VGND VGND VPWR VPWR clknet_0_net947 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_7_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c159_S1 net1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c588_X net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c175_S0 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c411_D1 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_46_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net510 clknet_0_net510 VGND VGND VPWR VPWR clknet_1_1__leaf_net510
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_28_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c707_S1 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c290_B net1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c723_S0 net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s943_Q net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_net744 net744 VGND VGND VPWR VPWR clknet_0_net744 sky130_fd_sc_hd__clkbuf_16
Xclone35 net1039 VGND VGND VPWR VPWR net1126 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_23_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net799 net799 VGND VGND VPWR VPWR clknet_0_net799 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_50_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input24_A in3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c352_S1 net115 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_s960_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output92_A net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c689_B1 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c543_S0 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_442 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout211_A net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc408 net314 net211 net317 net999 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__or4bb_1
Xc419 net232 clknet_1_1__leaf_net778 clknet_1_0__leaf_net799 VGND VGND VPWR VPWR net330
+ sky130_fd_sc_hd__or3b_1
XANTENNA_c590_A2 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_6_0_clk_X clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap173 net1033 VGND VGND VPWR VPWR net1032 sky130_fd_sc_hd__buf_6
XFILLER_0_13_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c437_S1 net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c665_A net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c453_X net370 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c453_S0 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_s942_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c89_B net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net552 net552 VGND VGND VPWR VPWR clknet_0_net552 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net585 net585 VGND VGND VPWR VPWR clknet_0_net585 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c628_S0 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c347_S1 net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input27_X net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s885_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c675_A2 net1079 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout208 net865 VGND VGND VPWR VPWR net1067 sky130_fd_sc_hd__clkbuf_8
Xfanout219 net872 VGND VGND VPWR VPWR net1078 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_66_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_82_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net181 clknet_0_net181 VGND VGND VPWR VPWR clknet_1_1__leaf_net181
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout161_A net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net952 clknet_0_net952 VGND VGND VPWR VPWR clknet_1_0__leaf_net952
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net974 clknet_0_net974 VGND VGND VPWR VPWR clknet_1_0__leaf_net974
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_64_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c585_A2 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s924_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout214_X net1073 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc205 net909 net138 net140 net1112 net1050 net708 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__mux4_1
Xc216 net141 clknet_1_1__leaf_net946 net7 net14 clknet_1_0__leaf_net744 VGND VGND
+ VPWR VPWR net153 sky130_fd_sc_hd__a2111oi_1
Xc227 net92 net1071 net926 net681 clknet_1_1__leaf_net762 net765 VGND VGND VPWR VPWR
+ net163 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_79_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s906_Q net789 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_92_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc249 net46 clknet_1_0__leaf_net62 net1072 net732 net749 net929 VGND VGND VPWR VPWR
+ net182 sky130_fd_sc_hd__mux4_4
Xc238 net85 clknet_1_0__leaf_net171 net172 net169 net961 net771 VGND VGND VPWR VPWR
+ net173 sky130_fd_sc_hd__mux4_2
XFILLER_0_99_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c122_B1 net942 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c183_S0 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s915_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c495_A2 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs876 clknet_4_14_0_clk net43 VGND VGND VPWR VPWR net756 net755 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_70_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs887 net162 clknet_4_14_0_clk VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__dlxtn_4
Xs898 clknet_4_8_0_clk net239 VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__dlclkp_2
XFILLER_0_23_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c358_S0 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc761 net613 net1017 net620 net625 net752 net840 VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__mux4_1
Xc750 clknet_1_1__leaf_net542 net1020 clknet_1_0__leaf_net510 net1123 clknet_1_0__leaf_net798
+ net840 VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__mux4_4
XANTENNA_c313_C1 net644 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput8 in15 VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_78_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c686_A1 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c299_A3 net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c731_S0 net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c596_A1 clknet_1_1__leaf_net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c530_A net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net760 clknet_0_net760 VGND VGND VPWR VPWR clknet_1_0__leaf_net760
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c450_S1 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c442_Q net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c360_S1 net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_4_14_0_clk_X clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc591 clknet_1_1__leaf_net475 clknet_1_0__leaf_net469 net715 net724 net758 net939
+ VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__mux4_2
Xc580 net452 net1130 net1002 clknet_1_0__leaf_net461 net806 net828 VGND VGND VPWR
+ VPWR net469 sky130_fd_sc_hd__mux4_1
XFILLER_0_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c582_A3 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c726_S0 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c180_S1 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer27_A net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c492_A3 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input54_A in57 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c144_D1 net1149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c636_S0 net814 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c310_B1 net644 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c371_S0 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput22 in28 VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__buf_1
Xinput11 in18 VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__buf_1
XANTENNA_max_cap177_X net1149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput44 in48 VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__buf_1
Xinput55 in58 VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__buf_1
XFILLER_0_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput33 in38 VGND VGND VPWR VPWR net892 sky130_fd_sc_hd__buf_1
XFILLER_0_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net49 net49 VGND VGND VPWR VPWR clknet_0_net49 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c220_A0 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c577_A3 net1078 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net937 net937 VGND VGND VPWR VPWR clknet_0_net937 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net959 net959 VGND VGND VPWR VPWR clknet_0_net959 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_7_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c593_A2 net481 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c456_S0 net758 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input1_X net133 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c411_C1 net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c487_A3 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c74_Y net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input57_X net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net522 clknet_0_net522 VGND VGND VPWR VPWR clknet_1_1__leaf_net522
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c694_A1 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c215_B1 clknet_1_1__leaf_net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout191_A net1052 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_2_0_clk_X clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c443_A net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c109_A1 net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net778 net778 VGND VGND VPWR VPWR clknet_0_net778 sky130_fd_sc_hd__clkbuf_16
Xclone36 net1036 net1074 net861 net1081 net73 VGND VGND VPWR VPWR net1157 sky130_fd_sc_hd__a2111o_1
XFILLER_0_50_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c290_C_N net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c633_S1 net722 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c498_A2 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input17_A in23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net330 clknet_0_net330 VGND VGND VPWR VPWR clknet_1_1__leaf_net330
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net396 clknet_0_net396 VGND VGND VPWR VPWR clknet_1_1__leaf_net396
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_71_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc409 net999 net315 net649 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__nor3_1
Xmax_cap130 net149 VGND VGND VPWR VPWR net989 sky130_fd_sc_hd__dlymetal6s2s_1
XANTENNA_c590_A3 net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap163 net13 VGND VGND VPWR VPWR net1022 sky130_fd_sc_hd__buf_1
Xmax_cap174 net80 VGND VGND VPWR VPWR net1033 sky130_fd_sc_hd__buf_6
XANTENNA_input9_A in16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c665_B net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout194_X net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c734_S0 net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c599_A1 net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net542 net542 VGND VGND VPWR VPWR clknet_0_net542 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge840_X net711 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c136_C1 net1082 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c628_S1 net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout209 net918 VGND VGND VPWR VPWR net1068 sky130_fd_sc_hd__buf_4
XFILLER_0_10_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge851_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c212_A1 net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net182 clknet_0_net182 VGND VGND VPWR VPWR clknet_1_1__leaf_net182
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net171 clknet_0_net171 VGND VGND VPWR VPWR clknet_1_1__leaf_net171
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c565_CLK_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_61_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc206 net23 net121 net138 net106 net1008 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__a2111o_1
Xc217 clknet_1_0__leaf_net153 net146 clknet_1_1__leaf_net946 clknet_1_0__leaf_net744
+ net1059 net759 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_79_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout207_X net1066 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_92_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c98_SCE net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc228 net106 net92 clknet_1_1__leaf_net153 net1050 clknet_1_1__leaf_net760 net766
+ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__mux4_1
Xc239 net169 net765 net767 net769 net771 net772 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__mux4_2
XANTENNA_merge842_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c183_S1 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs877 clknet_4_10_0_clk net108 VGND VGND VPWR VPWR net758 net757 sky130_fd_sc_hd__dfxbp_2
XFILLER_0_63_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs888 net165 clknet_4_14_0_clk VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__dlxtn_4
Xs899 clknet_4_8_0_clk net244 VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc740 clknet_1_0__leaf_net591 net998 net1077 net751 net832 net858 VGND VGND VPWR VPWR
+ net605 sky130_fd_sc_hd__mux4_1
Xc762 clknet_1_0__leaf_net623 clknet_1_0__leaf_net510 net697 net716 clknet_1_0__leaf_net778
+ clknet_1_0__leaf_net815 VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__mux4_4
Xc751 net1017 clknet_1_0__leaf_net522 net724 net747 net821 net860 VGND VGND VPWR VPWR
+ net616 sky130_fd_sc_hd__mux4_4
XANTENNA_c313_B1 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_10_0_clk_X clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput9 in16 VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__buf_1
XFILLER_0_86_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net238 clknet_0_net238 VGND VGND VPWR VPWR clknet_1_0__leaf_net238
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c207_A1 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c223_A0 clknet_1_1__leaf_net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s964_GATE_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c596_A2 net789 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c530_B net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net761 clknet_0_net761 VGND VGND VPWR VPWR clknet_1_0__leaf_net761
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_S1 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c117_A1 net1076 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c97_X net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_0_net191 net191 VGND VGND VPWR VPWR clknet_0_net191 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc581 net1014 net1130 clknet_1_0__leaf_net462 clknet_1_0__leaf_net465 net824 net829
+ VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__mux4_1
Xc570 net447 net454 net451 net453 net685 net825 VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__mux4_1
Xc592 net1028 net684 net717 net724 net737 net936 VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__mux4_2
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput110 net969 VGND VGND VPWR VPWR out55 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c102_SCE net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_87_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c359_X net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net591 clknet_0_net591 VGND VGND VPWR VPWR clknet_1_0__leaf_net591
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_98_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c144_C1 net1066 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input47_A in50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clone10_C_N net1066 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c160_D1 net897 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput12 in19 VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_12_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput23 in29 VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__buf_4
Xinput45 in49 VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__clkbuf_1
Xinput34 in39 VGND VGND VPWR VPWR net893 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_24_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput56 in59 VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__buf_2
XFILLER_0_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c546_S1 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c204_A2 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c220_A1 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net927 net927 VGND VGND VPWR VPWR clknet_0_net927 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net938 net938 VGND VGND VPWR VPWR clknet_0_net938 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c737_S0 clknet_1_1__leaf_net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c456_S1 net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c472_S0 net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c191_S1 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c139_C1 net1066 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c366_S1 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c321_A0 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_73_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c231_A0 net1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout184_A net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c588_A3 net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c443_B net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclone26 net68 VGND VGND VPWR VPWR net1117 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_23_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c109_A2 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net779 net779 VGND VGND VPWR VPWR clknet_0_net779 sky130_fd_sc_hd__clkbuf_16
Xclone37 net1082 VGND VGND VPWR VPWR net1128 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c85_S0 net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_95_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c498_A3 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_500 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c316_A0 net897 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net331 clknet_0_net331 VGND VGND VPWR VPWR clknet_1_1__leaf_net331
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap202_X net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net386 clknet_0_net386 VGND VGND VPWR VPWR clknet_1_1__leaf_net386
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net397 clknet_0_net397 VGND VGND VPWR VPWR clknet_1_1__leaf_net397
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_71_22 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s954_GATE clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmax_cap131 net140 VGND VGND VPWR VPWR net990 sky130_fd_sc_hd__dlymetal6s2s_1
Xmax_cap153 net100 VGND VGND VPWR VPWR net1012 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c226_A0 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap142 net241 VGND VGND VPWR VPWR net1001 sky130_fd_sc_hd__buf_1
XFILLER_0_40_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap164 net99 VGND VGND VPWR VPWR net1023 sky130_fd_sc_hd__buf_1
Xmax_cap175 net79 VGND VGND VPWR VPWR net1034 sky130_fd_sc_hd__buf_2
XFILLER_0_96_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c537_1_A clknet_1_1__leaf_net706 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c734_S1 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c599_A2 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net510 net510 VGND VGND VPWR VPWR clknet_0_net510 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c427_RESET_B net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c302_A2 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output116_A net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c444_SCD net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c190_C_N net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c212_A2 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net954 clknet_0_net954 VGND VGND VPWR VPWR clknet_1_0__leaf_net954
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_53_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net965 clknet_0_net965 VGND VGND VPWR VPWR clknet_1_0__leaf_net965
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout147_A net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc218 net1029 clknet_1_0__leaf_net153 net92 net680 clknet_1_0__leaf_net743 net759
+ VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__mux4_2
Xc207 net991 net119 net98 net137 clknet_1_0__leaf_net705 net1059 VGND VGND VPWR VPWR
+ net144 sky130_fd_sc_hd__mux4_1
XFILLER_0_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc229 net990 net908 net926 clknet_1_1__leaf_net762 net765 net766 VGND VGND VPWR VPWR
+ net165 sky130_fd_sc_hd__mux4_1
XANTENNA_c464_S1 net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c403_A1 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c480_S0 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c94_B net891 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_101_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs878 clknet_4_10_0_clk net120 VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__dfxtp_2
Xs889 net166 clknet_4_14_0_clk VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__dlxtn_2
XFILLER_0_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c147_C1 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc730 clknet_1_1__leaf_net592 net1062 net844 clknet_1_1__leaf_net852 net855 net857
+ VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__mux4_2
Xc763 net626 net627 net736 net741 net832 net837 VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__mux4_1
Xc741 net1093 clknet_1_0__leaf_net483 clknet_1_0__leaf_net604 clknet_1_1__leaf_net542
+ net751 clknet_1_0__leaf_net853 VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__mux4_1
Xc752 net1080 net614 clknet_1_0__leaf_net522 net747 net846 net860 VGND VGND VPWR VPWR
+ net617 sky130_fd_sc_hd__mux4_1
XANTENNA_c163_D1 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c313_A1 net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input32_X net891 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c549_S1 net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c207_A2 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c596_A3 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c530_C net1079 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net762 clknet_0_net762 VGND VGND VPWR VPWR clknet_1_0__leaf_net762
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c304_X net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c117_A2 net942 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c414_A0 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c475_S0 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c194_S1 net644 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net181 net181 VGND VGND VPWR VPWR clknet_0_net181 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_3_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc582 net1097 clknet_1_1__leaf_net465 net889 net822 net826 net830 VGND VGND VPWR VPWR
+ net471 sky130_fd_sc_hd__mux4_2
Xc571 net440 net231 net446 net726 net805 net936 VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__mux4_1
Xc560 net429 net228 net889 net650 net805 net806 VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__mux4_2
Xc593 clknet_1_1__leaf_net469 clknet_1_0__leaf_net475 net481 clknet_1_0__leaf_net465
+ net717 net724 VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_16_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c697_A2 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_35_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_25_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c218_A1 clknet_1_0__leaf_net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput100 clknet_1_0__leaf_net959 VGND VGND VPWR VPWR out46 sky130_fd_sc_hd__clkbuf_1
Xoutput111 net970 VGND VGND VPWR VPWR out56 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_100_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_34_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_43_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net592 clknet_0_net592 VGND VGND VPWR VPWR clknet_1_0__leaf_net592
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c425_C1 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net705 clknet_0_net705 VGND VGND VPWR VPWR clknet_1_1__leaf_net705
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c280_Q net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c160_C1 net1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c310_A2 net897 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput13 in2 VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_12_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput24 in3 VGND VGND VPWR VPWR net883 sky130_fd_sc_hd__buf_1
Xinput46 in5 VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__buf_1
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput35 in4 VGND VGND VPWR VPWR net894 sky130_fd_sc_hd__buf_2
XFILLER_0_12_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput57 in6 VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_70_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c107_Y net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_97_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c472_S1 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer32_A net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c305_A2 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c321_A1 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout190 net249 VGND VGND VPWR VPWR net1049 sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_net568 clknet_0_net568 VGND VGND VPWR VPWR clknet_1_1__leaf_net568
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s963_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c694_A3 net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_hold48_A net757 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c215_A2 net1071 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c573_S0 net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c231_A1 net1083 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c269_B net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclone38 net1083 VGND VGND VPWR VPWR net1129 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c467_S1 net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c125_A2 net942 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c483_S0 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s945_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge826_GATE clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c393_S0 net702 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net332 clknet_0_net332 VGND VGND VPWR VPWR clknet_1_1__leaf_net332
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap132 net140 VGND VGND VPWR VPWR net991 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap154 net1148 VGND VGND VPWR VPWR net1013 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_96_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap165 net99 VGND VGND VPWR VPWR net1024 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_0_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c599_A3 clknet_1_0__leaf_net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c553_B net1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s927_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net522 net522 VGND VGND VPWR VPWR clknet_0_net522 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c152_A0 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input22_A in28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c302_A3 net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net184 clknet_0_net184 VGND VGND VPWR VPWR clknet_1_1__leaf_net184
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net922 clknet_0_net922 VGND VGND VPWR VPWR clknet_1_0__leaf_net922
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c570_S1 net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net977 clknet_0_net977 VGND VGND VPWR VPWR clknet_1_0__leaf_net977
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c301_B net657 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c298_S0 net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc208 net1147 net909 net21 net20 clknet_1_0__leaf_net744 net759 VGND VGND VPWR VPWR
+ net145 sky130_fd_sc_hd__mux4_2
XFILLER_0_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc219 net14 net3 net991 net137 net680 net759 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__mux4_4
XANTENNA_c403_A2 net1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net330 net330 VGND VGND VPWR VPWR clknet_0_net330 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xs879 clknet_4_14_0_clk net144 VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_23_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net396 net396 VGND VGND VPWR VPWR clknet_0_net396 sky130_fd_sc_hd__clkbuf_16
Xc720 net1048 net1009 clknet_1_1__leaf_net706 net1061 net849 net851 VGND VGND VPWR
+ VPWR net585 sky130_fd_sc_hd__mux4_2
Xc731 clknet_1_0__leaf_net483 net998 clknet_1_1__leaf_net386 net394 net556 net1062
+ VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__mux4_4
Xc742 net1065 net284 net328 net715 net751 net837 VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__mux4_1
Xc764 clknet_1_1__leaf_net623 net615 net625 net628 net1028 net896 VGND VGND VPWR VPWR
+ net629 sky130_fd_sc_hd__mux4_4
Xc753 clknet_1_1__leaf_net617 net1017 clknet_1_0__leaf_net778 net813 net817 net832
+ VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__mux4_1
XFILLER_0_31_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c163_C1 net1074 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c313_A2 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c102_CLK_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c223_A2 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c363_D clknet_1_1__leaf_net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c581_S0 net824 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_38_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge855_D net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout212_X net1071 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s904_Q net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c756_S0 net724 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c414_A1 net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net182 net182 VGND VGND VPWR VPWR clknet_0_net182 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net171 net171 VGND VGND VPWR VPWR clknet_0_net171 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc550 net999 net335 net998 net1055 net823 VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__a2111o_1
Xc561 net446 net228 net1080 net983 net1139 VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__a2111oi_1
Xc572 net376 clknet_1_0__leaf_net934 net882 net1049 net1014 net822 VGND VGND VPWR
+ VPWR net461 sky130_fd_sc_hd__mux4_4
Xc594 net19 net448 net928 clknet_1_1__leaf_net934 net1074 net1026 VGND VGND VPWR VPWR
+ net483 sky130_fd_sc_hd__mux4_2
Xc583 net464 net1097 clknet_1_1__leaf_net471 net1062 net713 net822 VGND VGND VPWR
+ VPWR net472 sky130_fd_sc_hd__mux4_4
XFILLER_0_47_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_63_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c218_A2 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c270_D_N net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput101 net960 VGND VGND VPWR VPWR out47 sky130_fd_sc_hd__buf_2
XFILLER_0_88_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput112 clknet_1_1__leaf_net971 VGND VGND VPWR VPWR out57 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c576_S0 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c234_A1 net1114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_87_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net560 clknet_0_net560 VGND VGND VPWR VPWR clknet_1_0__leaf_net560
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_80_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c486_S0 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net706 clknet_0_net706 VGND VGND VPWR VPWR clknet_1_1__leaf_net706
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c441_C1 net1079 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c160_B1 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c319_A1 net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput14 in20 VGND VGND VPWR VPWR net873 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput36 in40 VGND VGND VPWR VPWR net895 sky130_fd_sc_hd__buf_1
Xinput25 in30 VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__buf_1
Xinput47 in50 VGND VGND VPWR VPWR net906 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput58 in60 VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_75_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c428_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c501_A2 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c220_A3 clknet_1_1__leaf_net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c229_A1 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c753_S1 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c411_A2 net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c531_X net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c139_A1 net1149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input52_A in55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c602_A1 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout191 net1052 VGND VGND VPWR VPWR net1050 sky130_fd_sc_hd__clkbuf_4
Xfanout180 net72 VGND VGND VPWR VPWR net1039 sky130_fd_sc_hd__buf_8
XFILLER_0_44_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c538_SCD net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_45_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c231_A2 clknet_1_1__leaf_net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_7_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c269_C net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclone17 net1110 VGND VGND VPWR VPWR net1108 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclone39 net1010 VGND VGND VPWR VPWR net1130 sky130_fd_sc_hd__clkbuf_1
Xclone28 net1120 VGND VGND VPWR VPWR net1119 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_90_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c748_S1 net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_524 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c764_S0 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s897_GCLK net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c483_S1 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c141_A2 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c113_RESET_B net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c65_X net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge863_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s881_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c613_A0 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c393_S1 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net300 clknet_0_net300 VGND VGND VPWR VPWR clknet_1_1__leaf_net300
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c446_D_N net758 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmax_cap133 net107 VGND VGND VPWR VPWR net992 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c226_A2 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap177 net74 VGND VGND VPWR VPWR net1036 sky130_fd_sc_hd__buf_8
XFILLER_0_0_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c759_S0 net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s934_Q net821 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c417_A1 net1159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c478_S1 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge845_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input15_A in21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c608_A0 net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output83_A net942 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s953_GATE_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge836_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c343_A0 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net185 clknet_0_net185 VGND VGND VPWR VPWR clknet_1_1__leaf_net185
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net934 clknet_0_net934 VGND VGND VPWR VPWR clknet_1_0__leaf_net934
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_81_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net945 clknet_0_net945 VGND VGND VPWR VPWR clknet_1_0__leaf_net945
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_33_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c298_S1 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc209 clknet_4_11_0_clk net127 net135 net913 net137 net991 VGND VGND VPWR VPWR net147
+ net146 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_25_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c253_A0 net1076 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c403_A3 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input7_A in14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c277_X net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_101_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net331 net331 VGND VGND VPWR VPWR clknet_0_net331 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0_net386 net386 VGND VGND VPWR VPWR clknet_0_net386 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net397 net397 VGND VGND VPWR VPWR clknet_0_net397 sky130_fd_sc_hd__clkbuf_16
Xc710 net557 clknet_1_0__leaf_net568 clknet_1_0__leaf_net474 net1065 net555 net849
+ VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__mux4_4
Xc721 net547 net1080 clknet_1_0__leaf_net585 net751 net845 clknet_1_0__leaf_net854
+ VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__mux4_4
Xc732 clknet_1_0__leaf_net592 clknet_1_1__leaf_net542 net741 net754 net844 net859
+ VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__mux4_1
Xc743 clknet_1_1__leaf_net606 net1017 net454 net1062 net736 net751 VGND VGND VPWR
+ VPWR net608 sky130_fd_sc_hd__mux4_2
Xc754 clknet_1_1__leaf_net522 clknet_1_0__leaf_net617 net736 net752 net1056 net850
+ VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__mux4_4
XANTENNA_clkbuf_4_15_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c338_A0 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net742 clknet_0_net742 VGND VGND VPWR VPWR clknet_1_0__leaf_net742
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c248_A0 net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net797 clknet_0_net797 VGND VGND VPWR VPWR clknet_1_0__leaf_net797
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_5_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout205_X net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c711_A0 net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c430_A1 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c73_D1 net1083 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc540 clknet_4_0_0_clk net987 net1091 net1014 net217 net426 VGND VGND VPWR VPWR net429
+ net428 sky130_fd_sc_hd__sdfbbn_1
XANTENNA_c605_A1 net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc562 net445 net428 net439 net1155 net804 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__a2111o_1
Xc551 net882 net999 net1075 net1152 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__or4bb_2
Xc573 clknet_1_0__leaf_net246 net440 net1047 net1068 net448 net368 VGND VGND VPWR
+ VPWR net462 sky130_fd_sc_hd__mux4_4
Xc595 net467 net1009 net1049 net976 net789 net978 VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__mux4_1
Xc584 clknet_1_0__leaf_net471 net213 net364 net1107 net1100 net830 VGND VGND VPWR
+ VPWR net473 sky130_fd_sc_hd__mux4_1
XFILLER_0_47_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c280_SCD net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput113 clknet_1_1__leaf_net972 VGND VGND VPWR VPWR out58 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c576_S1 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput102 net961 VGND VGND VPWR VPWR out48 sky130_fd_sc_hd__buf_2
XFILLER_0_100_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c234_A2 net1070 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c187_A net1151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c592_S0 net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout155_X net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s934_GATE clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c142_X net1157 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c706_A0 net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c486_S1 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c441_B1 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c565_SCE net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput15 in21 VGND VGND VPWR VPWR net874 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput26 in31 VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_12_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput37 in41 VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__buf_4
XANTENNA_c616_A0 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput48 in51 VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__buf_1
Xinput59 in61 VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__buf_1
XANTENNA_c335_A1 net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc370 net297 net292 net1040 net961 net772 clknet_1_1__leaf_net797 VGND VGND VPWR VPWR
+ net302 sky130_fd_sc_hd__mux4_4
Xc392 net942 clknet_1_0__leaf_net972 clknet_1_0__leaf_net965 clknet_1_0__leaf_net971
+ net960 clknet_1_1__leaf_net779 VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_48_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c229_A2 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_3_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c245_A1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c139_A2 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c436_A0 net1108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input45_A in49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c171_B1 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c602_A2 net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout192 net70 VGND VGND VPWR VPWR net1051 sky130_fd_sc_hd__buf_6
Xfanout181 net1041 VGND VGND VPWR VPWR net1040 sky130_fd_sc_hd__buf_2
Xclkbuf_1_1__f_net515 clknet_0_net515 VGND VGND VPWR VPWR clknet_1_1__leaf_net515
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c362_C1 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c231_A3 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c161_D_N net1101 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c157_B net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net705 net705 VGND VGND VPWR VPWR clknet_0_net705 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c703_A1 net1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c764_S1 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c141_A3 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clone38_A net1083 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c81_D1 net1071 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_max_cap128_A net419 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_58_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c226_A3 net1108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c447_SCD net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c274_B net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout182_A net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c267_A net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge790_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c222_X net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c759_S1 net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net568 net568 VGND VGND VPWR VPWR clknet_0_net568 sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s927_Q net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c433_A1 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_11_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c458_D1 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c685_S0 net1077 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net153 clknet_0_net153 VGND VGND VPWR VPWR clknet_1_1__leaf_net153
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net924 clknet_0_net924 VGND VGND VPWR VPWR clknet_1_0__leaf_net924
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_81_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net957 clknet_0_net957 VGND VGND VPWR VPWR clknet_1_0__leaf_net957
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net946 clknet_0_net946 VGND VGND VPWR VPWR clknet_1_0__leaf_net946
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c595_S0 net789 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c253_A1 net1101 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c550_C1 net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c700_A2 net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout185_X net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c551_A net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s877_Q net758 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net332 net332 VGND VGND VPWR VPWR clknet_0_net332 sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc711 net424 net1026 net993 net653 net832 net849 VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__mux4_2
Xc700 clknet_1_0__leaf_net562 net983 clknet_1_0__leaf_net560 net653 net1134 VGND VGND
+ VPWR VPWR net565 sky130_fd_sc_hd__a2111oi_1
Xc722 net1048 clknet_1_1__leaf_net585 net1020 net554 net1094 net841 VGND VGND VPWR
+ VPWR net587 sky130_fd_sc_hd__mux4_4
XANTENNA_c163_A1 net1076 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc755 net1077 clknet_1_0__leaf_net510 net1080 net716 net752 net844 VGND VGND VPWR
+ VPWR net620 sky130_fd_sc_hd__mux4_4
Xc733 net597 net556 net455 net1017 net832 net856 VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__mux4_2
Xc744 net1044 clknet_1_0__leaf_net595 net998 clknet_1_1__leaf_net604 net725 net855
+ VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__mux4_4
XANTENNA_c157_C_N net1074 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c610_A2 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_98_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c338_A1 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c354_A0 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net743 clknet_0_net743 VGND VGND VPWR VPWR clknet_1_0__leaf_net743
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net798 clknet_0_net798 VGND VGND VPWR VPWR clknet_1_0__leaf_net798
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout145_A net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c132_A net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c404_B net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c414_A3 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c711_A1 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c430_A2 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c73_C1 net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net184 net184 VGND VGND VPWR VPWR clknet_0_net184 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c174_A0 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c605_A2 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc530 net993 net201 net1079 VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__and3_1
Xc541 net737 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__clkbuf_1
Xc563 clknet_4_1_0_clk net1141 net983 net445 net999 net685 VGND VGND VPWR VPWR net452
+ net451 sky130_fd_sc_hd__sdfbbp_1
Xc552 net439 net999 net228 net440 net805 VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__a2111oi_1
Xc585 net1098 clknet_1_0__leaf_net461 net896 net715 net758 net830 VGND VGND VPWR VPWR
+ net474 sky130_fd_sc_hd__mux4_4
Xc596 net448 clknet_1_1__leaf_net934 net789 net939 net936 net827 VGND VGND VPWR VPWR
+ net485 sky130_fd_sc_hd__mux4_4
Xc574 net1153 net1100 clknet_1_1__leaf_net462 clknet_1_0__leaf_net369 net378 net1010
+ VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__mux4_4
XFILLER_0_47_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input30_X net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c621_A1 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c280_SCE net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c349_A0 clknet_1_0__leaf_net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s886_GATE clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput114 clknet_1_0__leaf_net973 VGND VGND VPWR VPWR out6 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c558_D_N net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput103 net962 VGND VGND VPWR VPWR out49 sky130_fd_sc_hd__buf_2
XANTENNA_c234_A3 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c187_B net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c592_S1 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net562 clknet_0_net562 VGND VGND VPWR VPWR clknet_1_0__leaf_net562
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net595 clknet_0_net595 VGND VGND VPWR VPWR clknet_1_0__leaf_net595
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout148_X net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_12_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c706_A1 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge846_B net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_98_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c425_A2 net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_21_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c160_A2 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c88_X net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c319_A3 net1068 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput27 in32 VGND VGND VPWR VPWR net886 sky130_fd_sc_hd__clkbuf_2
Xinput16 in22 VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_64_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_12_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput49 in52 VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__buf_4
Xinput38 in42 VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_12_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c616_A1 net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c335_A2 clknet_1_0__leaf_net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c632_A0 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc371 net296 clknet_1_1__leaf_net302 net734 net768 net781 clknet_1_1__leaf_net798
+ VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__mux4_1
Xc360 net247 net213 net1050 net288 net745 net765 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__mux4_2
Xc393 net36 net215 clknet_1_0__leaf_net959 net968 net702 net963 VGND VGND VPWR VPWR
+ net974 sky130_fd_sc_hd__mux4_4
XANTENNA_c351_A1 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c229_A3 clknet_1_1__leaf_net762 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge870 clknet_4_13_0_clk net711 net180 VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__dfrtn_1
XFILLER_0_55_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c108_S0 net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s957_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c436_A1 net339 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input38_A in42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c171_A1 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c602_A3 net481 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout182 net34 VGND VGND VPWR VPWR net1041 sky130_fd_sc_hd__buf_4
Xfanout160 net196 VGND VGND VPWR VPWR net1019 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_17_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c627_A0 net481 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c346_A1 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s936_GATE_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc190 net123 net124 net878 net118 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__or4bb_1
XANTENNA_c362_B1 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net706 net706 VGND VGND VPWR VPWR clknet_0_net706 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c429_D net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c598_S0 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c256_A1 net1077 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclone1 net70 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c65_A0 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c166_A1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c613_A2 net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net302 clknet_0_net302 VGND VGND VPWR VPWR clknet_1_1__leaf_net302
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_58_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap135 net321 VGND VGND VPWR VPWR net994 sky130_fd_sc_hd__buf_4
XANTENNA_c447_SCE net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap168 net11 VGND VGND VPWR VPWR net1027 sky130_fd_sc_hd__clkbuf_2
Xmax_cap157 net38 VGND VGND VPWR VPWR net1016 sky130_fd_sc_hd__clkbuf_2
Xmax_cap146 net204 VGND VGND VPWR VPWR net1005 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c242_A3 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c281_D net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c274_C net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c162_A net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c105_S1 net1076 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_1_1__f_net946_X clknet_1_1__leaf_net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c564_D1 net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c685_S1 net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c624_A1 net481 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output69_A net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net947 clknet_0_net947 VGND VGND VPWR VPWR clknet_1_0__leaf_net947
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_57_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_33_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_61_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c595_S1 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_92_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c550_B1 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c551_B net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout178_X net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_77_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net300 net300 VGND VGND VPWR VPWR clknet_0_net300 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c62_A1 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_86_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc701 net558 clknet_1_0__leaf_net562 clknet_1_0__leaf_net552 net729 net842 net843
+ VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__mux4_1
Xc712 net1103 net1061 net832 net1053 net842 net845 VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__mux4_1
XANTENNA_c163_A2 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc734 clknet_1_0__leaf_net483 net1067 clknet_1_1__leaf_net595 clknet_1_1__leaf_net592
+ net1056 net1053 VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__mux4_4
Xc745 net394 clknet_1_1__leaf_net604 net607 net344 net697 clknet_1_1__leaf_net852
+ VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__mux4_1
Xc723 clknet_1_1__leaf_net568 net586 net547 net751 net842 net851 VGND VGND VPWR VPWR
+ net588 sky130_fd_sc_hd__mux4_1
Xc756 clknet_1_0__leaf_net510 clknet_1_1__leaf_net542 clknet_1_1__leaf_net522 net455
+ net724 clknet_1_0__leaf_net798 VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__mux4_2
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input20_A in26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_output107_A net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c619_A1 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c338_A2 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_30_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge850_Q net724 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c635_A0 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_78_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net744 clknet_0_net744 VGND VGND VPWR VPWR clknet_1_0__leaf_net744
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net799 clknet_0_net799 VGND VGND VPWR VPWR clknet_1_0__leaf_net799
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout138_A net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c561_C1 net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c711_A2 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c439_A1 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c158_A2 net1160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net185 net185 VGND VGND VPWR VPWR clknet_0_net185 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c174_A1 net1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc531 net737 VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__clkbuf_4
Xc542 net429 net430 net426 VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__or3_1
Xc564 net429 net443 net452 net999 net448 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__o2111ai_1
Xc553 net335 net1075 net823 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__nand3_2
Xc597 net19 net928 clknet_1_1__leaf_net483 net717 net1056 net814 VGND VGND VPWR VPWR
+ net486 sky130_fd_sc_hd__mux4_2
Xc586 net928 clknet_1_0__leaf_net246 net825 net936 net830 net831 VGND VGND VPWR VPWR
+ net475 sky130_fd_sc_hd__mux4_1
Xc575 net368 net1006 net1059 clknet_1_1__leaf_net778 net806 net826 VGND VGND VPWR
+ VPWR net464 sky130_fd_sc_hd__mux4_1
XANTENNA_c621_A2 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input23_X net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_63_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_15_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c365_A0 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput115 clknet_1_1__leaf_net974 VGND VGND VPWR VPWR out60 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput104 net963 VGND VGND VPWR VPWR out5 sky130_fd_sc_hd__buf_2
XFILLER_0_100_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c187_C net1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c559_SCD net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net552 clknet_0_net552 VGND VGND VPWR VPWR clknet_1_0__leaf_net552
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net585 clknet_0_net585 VGND VGND VPWR VPWR clknet_1_0__leaf_net585
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c706_A2 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c441_A2 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c296_C_N net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c84_C1 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c185_A0 net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput28 in33 VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_12_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput17 in23 VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__buf_2
Xinput39 in43 VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c616_A2 net821 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c335_A3 net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc372 clknet_1_0__leaf_net275 net1028 clknet_1_1__leaf_net303 net1068 clknet_1_0__leaf_net946
+ clknet_1_0__leaf_net797 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__mux4_4
Xc350 clknet_1_0__leaf_net282 net12 net281 net727 net787 net794 VGND VGND VPWR VPWR
+ net283 sky130_fd_sc_hd__mux4_4
Xc361 net292 clknet_1_1__leaf_net275 net1078 net40 net1018 VGND VGND VPWR VPWR net293
+ sky130_fd_sc_hd__o2111ai_2
Xc394 clknet_1_0__leaf_net188 clknet_1_0__leaf_net974 clknet_1_0__leaf_net937 c394/A3
+ net702 clknet_1_1__leaf_net779 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_48_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge860 net189 clknet_4_15_0_clk net641 VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__dlrtp_1
Xmerge871 clknet_4_10_0_clk net114 net707 VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_28_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c108_S1 net702 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout160_X net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c717_A1 net1073 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c436_A2 net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge875_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s893_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c452_A1 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c171_A2 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout161 net122 VGND VGND VPWR VPWR net1020 sky130_fd_sc_hd__buf_4
Xfanout183 net1043 VGND VGND VPWR VPWR net1042 sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_net517 clknet_0_net517 VGND VGND VPWR VPWR clknet_1_1__leaf_net517
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net506 clknet_0_net506 VGND VGND VPWR VPWR clknet_1_1__leaf_net506
+ sky130_fd_sc_hd__clkbuf_16
Xfanout150 net1010 VGND VGND VPWR VPWR net1009 sky130_fd_sc_hd__buf_8
Xfanout194 net841 VGND VGND VPWR VPWR net1053 sky130_fd_sc_hd__buf_4
XFILLER_0_44_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s915_GCLK net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge866_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc180 net868 net92 net1070 net1024 net1028 net1060 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__mux4_2
Xc191 net123 net124 net113 net1020 net643 net1059 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__mux4_2
XFILLER_0_85_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c449_D_N net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c598_S1 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_0__f_net946_X clknet_1_0__leaf_net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout218_A net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone2 net74 VGND VGND VPWR VPWR net1149 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c728_A0 net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c65_A1 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c166_A2 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c81_B1 net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge848_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c463_A0 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input50_A in53 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net303 clknet_0_net303 VGND VGND VPWR VPWR clknet_1_1__leaf_net303
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net369 clknet_0_net369 VGND VGND VPWR VPWR clknet_1_1__leaf_net369
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_58_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c662_C_N net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c357_A1 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap125 net985 VGND VGND VPWR VPWR net984 sky130_fd_sc_hd__buf_1
XFILLER_0_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c162_B net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c267_C net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net515 net515 VGND VGND VPWR VPWR clknet_0_net515 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c564_C1 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c283_A0 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c714_A2 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c433_A3 net339 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c730_A1 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c312_S0 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c608_A3 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c624_A2 net1068 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c343_A3 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net188 clknet_0_net188 VGND VGND VPWR VPWR clknet_1_1__leaf_net188
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net177 clknet_0_net177 VGND VGND VPWR VPWR clknet_1_1__leaf_net177
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net959 clknet_0_net959 VGND VGND VPWR VPWR clknet_1_0__leaf_net959
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net937 clknet_0_net937 VGND VGND VPWR VPWR clknet_1_0__leaf_net937
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c368_A0 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c222_S0 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c550_A1 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c709_A2 net1079 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c278_A0 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc702 net228 net983 clknet_1_1__leaf_net562 net524 net729 net844 VGND VGND VPWR VPWR
+ net567 sky130_fd_sc_hd__mux4_1
Xc713 net1102 net558 net1078 net1073 net824 net851 VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__mux4_4
Xc735 net998 clknet_1_0__leaf_net592 clknet_1_1__leaf_net591 net1078 net715 net859
+ VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__mux4_4
Xc746 net593 clknet_1_0__leaf_net604 clknet_1_0__leaf_net386 net724 clknet_1_0__leaf_net853
+ net855 VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__mux4_1
Xc724 clknet_1_0__leaf_net474 net576 net541 net699 net720 clknet_1_0__leaf_net854
+ VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__mux4_2
XFILLER_0_31_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c741_A0 net1093 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc757 net607 net621 net752 clknet_1_0__leaf_net798 net832 net844 VGND VGND VPWR VPWR
+ net622 sky130_fd_sc_hd__mux4_4
XANTENNA_c460_A1 net1078 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input13_A in2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c619_A2 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c635_A1 net1068 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_78_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output81_A net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c217_S0 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_66_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net778 clknet_0_net778 VGND VGND VPWR VPWR clknet_1_0__leaf_net778
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c248_A3 net732 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c118_A net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout200_A net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xwire4 net136 VGND VGND VPWR VPWR net1147 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c561_B1 net1080 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input5_A in12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout190_X net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c275_X net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c736_A0 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net153 net153 VGND VGND VPWR VPWR clknet_0_net153 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c174_A2 net1160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc543 net426 net428 net1090 net928 net207 net418 VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__mux4_4
Xc554 net442 net335 net1078 net726 net1055 VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__o2111ai_4
Xc532 net201 net993 net1006 net994 net803 VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__a2111oi_2
XANTENNA_c471_A0 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc565 clknet_4_1_0_clk net453 net986 net439 net983 net228 VGND VGND VPWR VPWR net455
+ net454 sky130_fd_sc_hd__sdfbbn_2
Xc587 clknet_1_0__leaf_net465 clknet_1_1__leaf_net461 net1007 clknet_1_0__leaf_net475
+ clknet_1_0__leaf_net469 clknet_1_0__leaf_net462 VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__mux4_4
Xc598 net1007 net19 net684 net962 net783 net831 VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__mux4_2
Xc576 net364 net1002 net1014 clknet_1_0__leaf_net934 net1049 net783 VGND VGND VPWR
+ VPWR net465 sky130_fd_sc_hd__mux4_2
XANTENNA_c621_A3 net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c365_A1 net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput105 net964 VGND VGND VPWR VPWR out50 sky130_fd_sc_hd__clkbuf_1
Xoutput116 net975 VGND VGND VPWR VPWR out61 sky130_fd_sc_hd__buf_2
XFILLER_0_37_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net542 clknet_0_net542 VGND VGND VPWR VPWR clknet_1_0__leaf_net542
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c259_A2 net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout150_A net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c706_A3 net824 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout203_X net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c722_A2 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c169_A2 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c304_S1 net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput18 in24 VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__dlymetal6s2s_1
XANTENNA_c185_A1 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput29 in34 VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_91_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c616_A3 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc373 net295 clknet_1_0__leaf_net947 clknet_1_1__leaf_net705 net725 net796 clknet_1_1__leaf_net797
+ VGND VGND VPWR VPWR net964 sky130_fd_sc_hd__mux4_2
Xc351 net281 net4 net662 net727 net733 net795 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__mux4_2
Xc362 net289 net292 net940 net284 clknet_1_1__leaf_net282 VGND VGND VPWR VPWR net294
+ sky130_fd_sc_hd__o2111ai_2
Xc340 clknet_1_1__leaf_net250 clknet_1_0__leaf_net760 clknet_1_1__leaf_net780 net784
+ net1057 net790 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__mux4_4
Xc395 net1018 clknet_1_0__leaf_net974 net968 net702 clknet_1_1__leaf_net779 VGND VGND
+ VPWR VPWR net941 sky130_fd_sc_hd__o2111a_1
XFILLER_0_20_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c351_A3 net727 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge850 clknet_4_5_0_clk net692 net479 VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__dfstp_2
Xmerge861 net659 clknet_4_0_0_clk net718 VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__dlrtp_4
Xmerge872 clknet_4_12_0_clk net691 net701 VGND VGND VPWR VPWR net962 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_55_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c297_C net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c140_X net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer3_A net1093 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c436_A3 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c733_A1 net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout140 net318 VGND VGND VPWR VPWR net999 sky130_fd_sc_hd__clkbuf_4
XANTENNA_s965_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout151 net372 VGND VGND VPWR VPWR net1010 sky130_fd_sc_hd__buf_8
Xfanout184 net1044 VGND VGND VPWR VPWR net1043 sky130_fd_sc_hd__buf_2
Xfanout195 net951 VGND VGND VPWR VPWR net1054 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_17_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c627_A2 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc181 net911 net878 net89 net1068 net1028 net1060 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__mux4_2
Xc170 net87 net102 net103 net94 net893 net101 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__mux4_2
Xc192 net116 net117 net127 net112 net643 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__o2111a_2
XFILLER_0_18_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c225_S0 clknet_1_1__leaf_net762 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c256_A3 net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c188_X net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c728_A1 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net191 clknet_0_net191 VGND VGND VPWR VPWR clknet_1_0__leaf_net191
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c65_A2 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c166_A3 net1074 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c744_A0 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c463_A1 net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_18_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_rebuffer16_A net1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input43_A in47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge775_A1 net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c357_A2 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap126 net1146 VGND VGND VPWR VPWR net985 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_20_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap137 net320 VGND VGND VPWR VPWR net996 sky130_fd_sc_hd__buf_1
XANTENNA_c178_C_N net1151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c155_B net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c714_A3 net541 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c730_A2 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_net934_X clknet_0_net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c76_A1 net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c739_A0 net541 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c474_A0 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c193_A1 net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net145 clknet_0_net145 VGND VGND VPWR VPWR clknet_1_1__leaf_net145
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c444_RESET_B net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net927 clknet_0_net927 VGND VGND VPWR VPWR clknet_1_0__leaf_net927
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net938 clknet_0_net938 VGND VGND VPWR VPWR clknet_1_0__leaf_net938
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c503_S0 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c368_A1 net1072 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c399_C_N net1159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c272_B net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c709_A3 net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net302 net302 VGND VGND VPWR VPWR clknet_0_net302 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc703 clknet_1_1__leaf_net560 net1075 net729 net754 net844 net845 VGND VGND VPWR VPWR
+ net568 sky130_fd_sc_hd__mux4_1
XFILLER_0_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc736 net455 net284 net725 net741 net857 net860 VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__mux4_1
Xc725 net571 clknet_1_0__leaf_net474 net720 net751 net842 clknet_1_1__leaf_net854
+ VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__mux4_2
Xc747 net601 clknet_1_0__leaf_net606 clknet_1_1__leaf_net386 net1062 net699 net838
+ VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__mux4_4
Xc714 net571 net576 net997 net541 net845 net849 VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__mux4_4
Xc758 net1037 net284 clknet_1_1__leaf_net706 clknet_1_0__leaf_net778 net813 net846
+ VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_4_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c188_A1 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c323_S0 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clone39_X net1130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c619_A3 net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge772_A2 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c354_A3 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net60 clknet_0_net60 VGND VGND VPWR VPWR clknet_1_1__leaf_net60 sky130_fd_sc_hd__clkbuf_16
XANTENNA_output74_A net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c370_A2 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c233_S0 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net779 clknet_0_net779 VGND VGND VPWR VPWR clknet_1_0__leaf_net779
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_42_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c395_C1 net702 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_0_clk_X clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c545_A2 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire5 net42 VGND VGND VPWR VPWR net1148 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c127_S1 net1072 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c170_X net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer30 net1120 VGND VGND VPWR VPWR net1121 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c268_X net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c736_A1 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c752_A0 net1080 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc500 net115 net213 net940 net926 net735 clknet_1_1__leaf_net815 VGND VGND VPWR VPWR
+ net415 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_9_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc533 net737 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__buf_1
Xc544 net1047 clknet_1_0__leaf_net934 net1089 net994 net999 net803 VGND VGND VPWR
+ VPWR net433 sky130_fd_sc_hd__mux4_2
Xc555 net237 net441 net334 net726 net804 VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__o2111ai_1
XANTENNA_c471_A1 net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc588 net1049 clknet_1_1__leaf_net474 clknet_1_1__leaf_net475 net825 net829 net831
+ VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__mux4_2
Xc577 net440 clknet_1_1__leaf_net462 net1102 net1078 clknet_1_1__leaf_net465 net1020
+ VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__mux4_2
Xc566 net222 net454 net757 net802 net805 VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__a2111o_2
Xc599 clknet_1_1__leaf_net461 net394 net19 clknet_1_0__leaf_net952 net1026 net814
+ VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__mux4_4
XFILLER_0_99_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c559_Q net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge767_A2 net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c113_CLK_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c349_A3 net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c365_A2 clknet_1_1__leaf_net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput106 clknet_1_1__leaf_net965 VGND VGND VPWR VPWR out51 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput117 net976 VGND VGND VPWR VPWR out7 sky130_fd_sc_hd__buf_2
XFILLER_0_56_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net510 clknet_0_net510 VGND VGND VPWR VPWR clknet_1_0__leaf_net510
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout143_A net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c169_A3 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c90_B net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c601_S0 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c466_A1 net1077 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput19 in25 VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_91_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c185_A2 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c320_S1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc330 net221 net7 clknet_1_0__leaf_net153 net98 clknet_1_0__leaf_net760 net777 VGND
+ VGND VPWR VPWR net263 sky130_fd_sc_hd__mux4_1
XFILLER_0_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc352 net4 net1050 net119 net40 net865 net115 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__mux4_4
Xc341 net272 clknet_1_0__leaf_net250 net21 net661 net746 clknet_1_0__leaf_net779 VGND
+ VGND VPWR VPWR net274 sky130_fd_sc_hd__mux4_1
XANTENNA_c632_A3 net814 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc363 clknet_4_13_0_clk clknet_1_1__leaf_net153 clknet_1_0__leaf_net957 net975 net962
+ clknet_1_1__leaf_net779 VGND VGND VPWR VPWR net296 net295 sky130_fd_sc_hd__sdfbbp_1
Xc396 net197 net1067 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__or2b_1
XFILLER_0_99_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_max_cap206_A net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge851 clknet_4_5_0_clk net689 net599 VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__dfstp_2
Xmerge873 clknet_4_5_0_clk net603 net581 VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_28_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge862 net704 clknet_4_9_0_clk net710 VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__dlrtp_4
Xmerge840 net669 net651 VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__or2_4
XFILLER_0_28_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c230_S1 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c392_A0 net942 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c178_A net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c717_A3 net824 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c733_A2 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net508 clknet_0_net508 VGND VGND VPWR VPWR clknet_1_1__leaf_net508
+ sky130_fd_sc_hd__clkbuf_16
Xfanout152 net312 VGND VGND VPWR VPWR net1011 sky130_fd_sc_hd__clkbuf_4
Xfanout141 net318 VGND VGND VPWR VPWR net1000 sky130_fd_sc_hd__clkbuf_2
Xfanout185 net528 VGND VGND VPWR VPWR net1044 sky130_fd_sc_hd__clkbuf_2
Xfanout196 net939 VGND VGND VPWR VPWR net1055 sky130_fd_sc_hd__buf_4
XFILLER_0_88_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c477_A0 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c627_A3 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc160 net877 net879 net92 net1117 net897 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__a2111o_4
Xc171 net92 net106 net1002 net1024 net101 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__a2111oi_1
XFILLER_0_20_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc193 net123 net124 net119 net97 net643 net750 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__mux4_2
Xc182 net105 net98 net85 net1127 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__or4bb_2
XFILLER_0_79_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c225_S1 net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c416_S0 net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s955_Q net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c65_A3 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net181 clknet_0_net181 VGND VGND VPWR VPWR clknet_1_0__leaf_net181
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_22_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c81_A2 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c463_A2 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input36_A in40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge775_A2 net1108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c357_A3 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap149 net1147 VGND VGND VPWR VPWR net1008 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c236_S0 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c548_A2 net419 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net506 net506 VGND VGND VPWR VPWR clknet_0_net506 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c427_D net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net517 net517 VGND VGND VPWR VPWR clknet_0_net517 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c540_SCD net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout223_A net1083 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c684_B net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c739_A1 net725 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c76_A2 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c458_A2 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c755_A0 net1077 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c474_A1 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c193_A2 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_34_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net179 clknet_0_net179 VGND VGND VPWR VPWR clknet_1_1__leaf_net179
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c368_A2 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_0_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c272_C net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c278_A2 net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_5_0_clk_X clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_46_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net303 net303 VGND VGND VPWR VPWR clknet_0_net303 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_32_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net369 net369 VGND VGND VPWR VPWR clknet_0_net369 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_60_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc704 net554 net557 net993 net556 net997 net824 VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__mux4_1
Xc726 net237 net1067 net993 net813 net1053 clknet_1_1__leaf_net853 VGND VGND VPWR
+ VPWR net591 sky130_fd_sc_hd__mux4_1
Xc737 clknet_1_1__leaf_net592 clknet_1_0__leaf_net595 net601 net1044 clknet_1_1__leaf_net542
+ net697 VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__mux4_1
Xc715 net577 net993 net576 clknet_1_0__leaf_net474 net824 clknet_1_0__leaf_net852
+ VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__mux4_2
XFILLER_0_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc759 net284 net616 net1065 clknet_1_0__leaf_net483 net741 net842 VGND VGND VPWR VPWR
+ net624 sky130_fd_sc_hd__mux4_2
Xc748 net601 net1037 net1028 net1065 net716 net741 VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_55_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c460_A3 net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c87_A1 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c469_A1 net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c323_S1 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_64_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c485_A0 net1070 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge772_A3 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c635_A3 net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_73_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net50 clknet_0_net50 VGND VGND VPWR VPWR clknet_1_1__leaf_net50 sky130_fd_sc_hd__clkbuf_16
XANTENNA_output67_A net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c370_A3 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c538_RESET_B net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c233_S1 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c561_A2 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_1_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer20 net78 VGND VGND VPWR VPWR net1111 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_83_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer31 clknet_0_net461 VGND VGND VPWR VPWR net1122 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c736_A2 net725 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net188 net188 VGND VGND VPWR VPWR clknet_0_net188 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net177 net177 VGND VGND VPWR VPWR clknet_0_net177 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc501 clknet_1_0__leaf_net947 net735 net787 clknet_1_0__leaf_net927 net819 net821
+ VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_9_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc534 clknet_1_1__leaf_net706 VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__buf_16
Xc545 clknet_1_0__leaf_net423 net426 net994 net987 net1074 net424 VGND VGND VPWR VPWR
+ net434 sky130_fd_sc_hd__mux4_2
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc589 net932 net1156 net1014 clknet_1_0__leaf_net465 clknet_1_0__leaf_net475 net737
+ VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__mux4_1
Xc567 net1146 net452 net454 net439 net925 net983 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__mux4_1
Xc556 net443 net1080 net685 net757 VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__or4bb_1
Xc578 net1097 net1002 net726 net806 net936 net828 VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__mux4_1
XANTENNA_c471_A2 net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s907_SLEEP_B clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c318_S1 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s948_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c199_A1 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c334_S0 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_71_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c442_Q_N net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c365_A3 net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput107 net966 VGND VGND VPWR VPWR out52 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput118 clknet_1_1__leaf_net977 VGND VGND VPWR VPWR out8 sky130_fd_sc_hd__clkbuf_1
XANTENNA_wire144_X net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net522 clknet_0_net522 VGND VGND VPWR VPWR clknet_1_0__leaf_net522
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c572_A1 clknet_1_0__leaf_net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c90_C net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c601_S1 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c466_A2 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c185_A3 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s896_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c482_A1 net1073 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc320 net240 net124 clknet_1_0__leaf_net251 net1070 clknet_1_0__leaf_net245 net777
+ VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_75_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc331 clknet_1_1__leaf_net251 net1049 net989 clknet_1_0__leaf_net760 clknet_1_0__leaf_net779
+ net782 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__mux4_1
XANTENNA_c329_S0 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc342 clknet_1_0__leaf_net273 net130 net247 net661 net781 net785 VGND VGND VPWR VPWR
+ net275 sky130_fd_sc_hd__mux4_2
Xc353 clknet_1_1__leaf_net275 net1050 net740 clknet_1_1__leaf_net760 net765 net769
+ VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__mux4_1
Xc397 net675 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__inv_4
Xc364 net292 clknet_1_1__leaf_net705 net961 net745 net772 net787 VGND VGND VPWR VPWR
+ net297 sky130_fd_sc_hd__mux4_1
XFILLER_0_74_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input21_X net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_86_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge830 net660 net656 VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__or2_2
Xmerge863 clknet_4_11_0_clk merge863/D net263 VGND VGND VPWR VPWR net740 net266 sky130_fd_sc_hd__edfxbp_1
XFILLER_0_67_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge852 clknet_4_2_0_clk net427 net671 VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__dfstp_2
Xmerge841 net383 net384 VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__nor2_1
XFILLER_0_99_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge869_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge874 clknet_4_6_0_clk net712 net618 VGND VGND VPWR VPWR net955 net752 sky130_fd_sc_hd__dfsbp_2
XFILLER_0_43_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c239_S0 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net330 clknet_0_net330 VGND VGND VPWR VPWR clknet_1_0__leaf_net330
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net396 clknet_0_net396 VGND VGND VPWR VPWR clknet_1_0__leaf_net396
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout139_X net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s878_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s900_Q net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c733_A3 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c149_S0 net1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c104_C1 net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout197 net788 VGND VGND VPWR VPWR net1056 sky130_fd_sc_hd__buf_4
Xfanout186 net525 VGND VGND VPWR VPWR net1045 sky130_fd_sc_hd__buf_2
XFILLER_0_96_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c758_A0 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c120_D1 net942 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c612_S0 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c331_S1 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c79_X net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc172 net875 net105 net1024 net106 net94 net1145 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__mux4_1
Xc161 net870 net876 net886 net1101 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__or4bb_2
Xc150 net921 net871 net1117 net1035 net80 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__a2111o_2
Xc194 net1020 net906 net1077 net117 net127 net644 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__mux4_2
XFILLER_0_85_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc183 net1074 net1028 net1068 net112 net92 net1060 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__mux4_2
XFILLER_0_20_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c241_S1 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c295_B net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c455_A net1151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net182 clknet_0_net182 VGND VGND VPWR VPWR clknet_1_0__leaf_net182
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net171 clknet_0_net171 VGND VGND VPWR VPWR clknet_1_0__leaf_net171
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c728_A3 net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s948_Q net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c744_A2 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c463_A3 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c607_S0 net789 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input29_A in34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c326_S1 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c488_A0 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c342_S0 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge859_Q net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap128 net419 VGND VGND VPWR VPWR net987 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c373_A3 net725 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c670_A1 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s955_SLEEP_B clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c236_S1 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c540_SCE net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout216_A net891 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net934_A clknet_0_net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_4_1_0_clk_X clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c580_A1 net1130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer21_A net1160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c193_A3 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c368_A3 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c281_RESET_B net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c247_S0 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge855_GATE clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c278_A3 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_101_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c575_A1 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c418_A net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout219_X net1078 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc738 clknet_1_0__leaf_net386 clknet_1_0__leaf_net591 net1026 net716 net736 net858
+ VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__mux4_4
Xc705 net558 net1007 net1020 net1075 net997 net754 VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__mux4_1
Xc716 net561 net1002 net1044 net571 net1143 net1133 VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__mux4_1
Xc727 net541 net998 clknet_1_1__leaf_net542 net1002 net838 net842 VGND VGND VPWR VPWR
+ net592 sky130_fd_sc_hd__mux4_2
XFILLER_0_97_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc749 net1007 net1020 net1078 clknet_1_0__leaf_net798 net840 net850 VGND VGND VPWR
+ VPWR net614 sky130_fd_sc_hd__mux4_2
XANTENNA_c741_A3 clknet_1_1__leaf_net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c87_A2 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c201_SCD net1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c604_S1 net789 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c469_A2 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c188_A3 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_80_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_S0 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net62 clknet_0_net62 VGND VGND VPWR VPWR clknet_1_1__leaf_net62 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c676_A0 net419 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c395_A1 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c705_S0 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer21 net1015 VGND VGND VPWR VPWR net1112 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer10 net113 VGND VGND VPWR VPWR net1150 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_95_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer32 net1010 VGND VGND VPWR VPWR net1123 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c424_S1 net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout169_X net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c535_A net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c586_A0 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c440_S0 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net145 net145 VGND VGND VPWR VPWR clknet_0_net145 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_64_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c736_A3 net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s950_GATE clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc502 net1040 net1028 net735 net770 net814 net820 VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__mux4_2
XANTENNA_c107_C1 net702 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc535 net737 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__inv_6
Xc546 net217 net424 clknet_1_0__leaf_net433 net723 net726 net822 VGND VGND VPWR VPWR
+ net435 sky130_fd_sc_hd__mux4_4
Xc579 net1014 net1099 clknet_1_0__leaf_net465 net1037 clknet_1_0__leaf_net462 net1102
+ VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__mux4_2
Xc568 net447 net455 net931 net451 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__or4bb_1
Xc557 net993 net442 net806 VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__or3_1
XANTENNA_c471_A3 net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c422_SCD net657 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input11_A in18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c199_A2 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c350_S0 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput108 net967 VGND VGND VPWR VPWR out53 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput119 net978 VGND VGND VPWR VPWR out9 sky130_fd_sc_hd__buf_2
XFILLER_0_10_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput90 net949 VGND VGND VPWR VPWR out36 sky130_fd_sc_hd__buf_2
XFILLER_0_77_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout129_A net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c572_A2 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input3_A in10 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s880_Q net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c435_S0 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c747_A2 clknet_1_1__leaf_net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_363 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c466_A3 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc310 net1001 net897 net644 net657 net709 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__a2111oi_1
Xc321 net889 net247 clknet_1_0__leaf_net250 clknet_1_0__leaf_net251 net673 net709
+ VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__mux4_2
XANTENNA_c482_A2 clknet_1_0__leaf_net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input59_A in61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc354 net98 clknet_1_0__leaf_net282 clknet_1_1__leaf_net760 net782 net1057 net791
+ VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__mux4_1
Xc332 net21 clknet_1_1__leaf_net251 net989 net138 net988 net786 VGND VGND VPWR VPWR
+ net265 sky130_fd_sc_hd__mux4_1
Xc343 net7 net989 net662 net777 net786 net790 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__mux4_1
XANTENNA_c329_S1 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc365 net1040 net930 clknet_1_1__leaf_net153 net668 net745 clknet_1_1__leaf_net762
+ VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__mux4_1
Xc398 net675 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_48_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge820 net387 net293 VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__and2b_1
Xmerge831 clknet_4_15_0_clk net41 net195 VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__edfxtp_1
Xmerge864 clknet_4_4_0_clk net546 net610 VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__edfxtp_1
Xmerge853 net537 clknet_4_0_0_clk net279 VGND VGND VPWR VPWR net728 net727 sky130_fd_sc_hd__dlrbn_2
Xmerge842 clknet_4_2_0_clk net313 net367 VGND VGND VPWR VPWR net714 net713 sky130_fd_sc_hd__dfrbp_2
XFILLER_0_99_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge875 clknet_4_1_0_clk net564 net540 VGND VGND VPWR VPWR net754 net753 sky130_fd_sc_hd__dfsbp_2
XFILLER_0_28_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xnet999_2 clknet_1_0__leaf_net706 VGND VGND VPWR VPWR net1085 sky130_fd_sc_hd__inv_1
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net331 clknet_0_net331 VGND VGND VPWR VPWR clknet_1_0__leaf_net331
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c702_S1 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c567_A2 net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net386 clknet_0_net386 VGND VGND VPWR VPWR clknet_1_0__leaf_net386
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net397 clknet_0_net397 VGND VGND VPWR VPWR clknet_1_0__leaf_net397
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout201_X net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout143 net104 VGND VGND VPWR VPWR net1002 sky130_fd_sc_hd__buf_4
XANTENNA_input6_X net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout198 net788 VGND VGND VPWR VPWR net1057 sky130_fd_sc_hd__buf_2
Xfanout176 net78 VGND VGND VPWR VPWR net1035 sky130_fd_sc_hd__buf_12
Xfanout187 net525 VGND VGND VPWR VPWR net1046 sky130_fd_sc_hd__buf_1
XANTENNA_c123_C_N net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c758_A1 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c477_A2 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c196_A3 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c493_A1 net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc162 net1037 net879 net1082 net877 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__or4bb_4
Xc151 net86 net864 net1128 net1025 net1119 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__o2111ai_4
Xc140 net73 net69 net866 net1128 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__or4bb_4
Xc184 net119 net116 net118 net1028 net117 net1050 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__mux4_1
Xc173 net103 net105 net102 net992 net96 net106 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__mux4_4
Xc195 net128 net95 net129 net106 net123 net124 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__mux4_2
XFILLER_0_20_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c551_D_N net1152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c668_A1 net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c98_Q net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net934_A clknet_0_net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c295_C net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c190_B net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout196_A net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge778_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c455_B net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c713_S0 net824 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c578_A1 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout151_X net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c594_A0 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_50_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c623_S0 net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c488_A1 net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net852 clknet_0_net852 VGND VGND VPWR VPWR clknet_1_1__leaf_net852
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c252_S1 net732 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net508 net508 VGND VGND VPWR VPWR clknet_0_net508 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_61_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c708_S0 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c580_A2 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout199_X net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c589_A0 net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c739_A3 net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c755_A2 net1080 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s941_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c474_A3 net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c618_S0 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input41_A in45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c337_S1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c353_S0 net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xwire193 net70 VGND VGND VPWR VPWR net1052 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_13_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_101_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout159_A net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c575_A2 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c418_B net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_60_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc728 net237 net1062 net753 net1056 net850 net856 VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__mux4_1
Xc706 net424 net1007 net1067 net824 net1053 net846 VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__mux4_2
Xc717 net576 net1073 net751 net824 net842 clknet_1_0__leaf_net852 VGND VGND VPWR VPWR
+ net582 sky130_fd_sc_hd__mux4_2
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc739 net541 net725 net736 net842 net844 clknet_1_1__leaf_net853 VGND VGND VPWR VPWR
+ net604 sky130_fd_sc_hd__mux4_1
XANTENNA_c438_S0 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c87_A3 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c201_SCE net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clone34_A net133 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c620_S1 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net52 clknet_0_net52 VGND VGND VPWR VPWR clknet_1_1__leaf_net52 sky130_fd_sc_hd__clkbuf_16
XANTENNA_input44_X net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net705 clknet_0_net705 VGND VGND VPWR VPWR clknet_1_0__leaf_net705
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c529_C_N net1079 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c270_B net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer11 net376 VGND VGND VPWR VPWR net1102 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_65_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net490 clknet_0_net490 VGND VGND VPWR VPWR clknet_1_1__leaf_net490
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_37_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer22 net1152 VGND VGND VPWR VPWR net1153 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer33 net1010 VGND VGND VPWR VPWR net1124 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_49_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c156_Y net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c149_X net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c528_A net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net179 net179 VGND VGND VPWR VPWR clknet_0_net179 sky130_fd_sc_hd__clkbuf_16
XANTENNA_s923_Q net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc503 net1124 net948 clknet_1_0__leaf_net401 clknet_1_0__leaf_net954 net953 net820
+ VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__mux4_4
XANTENNA_c107_B1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc536 net424 net1047 clknet_1_1__leaf_net423 VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__nor3b_1
Xc547 clknet_1_0__leaf_net433 net431 net424 net1088 net994 net822 VGND VGND VPWR VPWR
+ net436 sky130_fd_sc_hd__mux4_4
Xc569 net450 net983 net310 net685 net726 net806 VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__mux4_4
Xc558 net994 net335 net222 net822 VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__or4bb_1
XANTENNA_c199_A3 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c496_A1 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_71_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput109 net968 VGND VGND VPWR VPWR out54 sky130_fd_sc_hd__buf_2
XANTENNA_output72_A net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput80 net1055 VGND VGND VPWR VPWR out24 sky130_fd_sc_hd__buf_2
Xoutput91 net950 VGND VGND VPWR VPWR out38 sky130_fd_sc_hd__buf_2
XFILLER_0_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net568 clknet_0_net568 VGND VGND VPWR VPWR clknet_1_0__leaf_net568
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_53_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c116_B net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c572_A3 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout181_X net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c435_S1 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c597_A0 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c747_A3 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c600_X net489 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc311 net1138 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__clkbuf_1
Xc300 net1039 net228 net668 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_75_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc333 net989 net119 net221 net124 c333/S0 net781 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__mux4_1
Xc322 clknet_4_8_0_clk clknet_1_0__leaf_net253 clknet_1_1__leaf_net246 net1049 net1129
+ net1060 VGND VGND VPWR VPWR net255 net254 sky130_fd_sc_hd__sdfbbn_1
Xc344 clknet_1_0__leaf_net273 net975 net1028 clknet_1_0__leaf_net275 net746 net970
+ VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__mux4_2
Xc366 net172 net1070 net1041 clknet_1_1__leaf_net946 net288 net961 VGND VGND VPWR
+ VPWR net299 sky130_fd_sc_hd__mux4_2
Xc355 clknet_4_13_0_clk net967 net740 net765 net772 net1136 VGND VGND VPWR VPWR net289
+ net288 sky130_fd_sc_hd__sdfbbn_1
XANTENNA_c134_D1 net1066 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc399 net309 net197 net1039 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__or3b_4
XTAP_TAPCELL_ROW_48_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge810 net142 net143 VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__and2b_1
XFILLER_0_74_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge821 net609 net598 VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__nand2_2
XFILLER_0_95_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge832 net258 net299 VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__nand2_1
Xmerge854 net436 clknet_4_0_0_clk net565 VGND VGND VPWR VPWR net730 net729 sky130_fd_sc_hd__dlrbn_1
XFILLER_0_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge843 clknet_4_5_0_clk net667 net468 VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__dfrtn_1
Xs960 clknet_4_4_0_clk net575 VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__dfxtp_1
Xmerge865 clknet_4_0_0_clk net539 net550 VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__sdlclkp_1
XFILLER_0_99_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c673_A2 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_net999_3_A clknet_1_1__leaf_net706 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer2 net1150 VGND VGND VPWR VPWR net1093 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xnet999_3 clknet_1_1__leaf_net706 VGND VGND VPWR VPWR net1086 sky130_fd_sc_hd__inv_1
XFILLER_0_48_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net332 clknet_0_net332 VGND VGND VPWR VPWR clknet_1_0__leaf_net332
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_80_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_88_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c400_B net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c322_SCD net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout155 net310 VGND VGND VPWR VPWR net1014 sky130_fd_sc_hd__buf_4
Xfanout166 net81 VGND VGND VPWR VPWR net1025 sky130_fd_sc_hd__buf_12
Xfanout188 net422 VGND VGND VPWR VPWR net1047 sky130_fd_sc_hd__buf_4
Xfanout199 net923 VGND VGND VPWR VPWR net1058 sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c120_B1 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c758_A2 clknet_1_1__leaf_net706 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c181_S0 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c477_A3 net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc130 clknet_1_0__leaf_net56 clknet_1_1__leaf_net62 clknet_1_1__leaf_net959 net64
+ VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__or4bb_1
Xc163 net1076 net876 net1030 net1074 net98 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__a2111oi_4
Xc141 net862 net71 net868 net76 net74 net1038 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__mux4_2
Xc152 net83 net87 net80 net86 net1126 net1101 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__mux4_2
XFILLER_0_20_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc185 net89 net112 net3 net106 net911 net119 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__mux4_2
Xc196 net121 net131 net129 net119 net105 net643 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__mux4_4
Xc174 net106 net1117 net1015 net992 net1062 net758 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__mux4_1
XANTENNA_c356_S0 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c205_A0 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c288_C net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net184 clknet_0_net184 VGND VGND VPWR VPWR clknet_1_0__leaf_net184
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c594_A1 net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c488_A2 net1068 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net853 clknet_0_net853 VGND VGND VPWR VPWR clknet_1_1__leaf_net853
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c695_B1 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c186_Y net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c589_A1 net1156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c179_X net115 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c558_A net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c279_D_N net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c346_X net279 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s953_Q net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input34_A in39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c634_S0 net722 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc90 net8 net900 net872 VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__or3_1
XANTENNA_c353_S1 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge864_Q net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge850_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c544_S0 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c202_A1 net1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c575_A3 clknet_1_1__leaf_net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_60_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout221_A net133 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_15_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc729 clknet_1_0__leaf_net592 clknet_1_0__leaf_net386 net328 clknet_1_0__leaf_net483
+ net753 net856 VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__mux4_4
Xc718 net554 net571 clknet_1_0__leaf_net568 net842 net847 clknet_1_0__leaf_net852
+ VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__mux4_2
Xc707 net547 net997 clknet_1_1__leaf_net474 net557 net720 net1053 VGND VGND VPWR VPWR
+ net572 sky130_fd_sc_hd__mux4_4
XANTENNA_s937_GATE_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c454_S0 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c173_S1 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c630_X net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c485_A3 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_33_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c629_S0 clknet_1_1__leaf_net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c303_A0 net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input37_X net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_42_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net706 clknet_0_net706 VGND VGND VPWR VPWR clknet_1_0__leaf_net706
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_51_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c447_SET_B net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_60_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer12 net1102 VGND VGND VPWR VPWR net1103 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer23 net90 VGND VGND VPWR VPWR net1114 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_65_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer34 net1152 VGND VGND VPWR VPWR net1156 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c586_A2 net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c528_B net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout224_X net1083 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_s916_Q net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c107_A1 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc504 net948 clknet_1_0__leaf_net938 clknet_1_0__leaf_net954 clknet_1_1__leaf_net977
+ net962 net818 VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__mux4_4
Xc559 clknet_4_0_0_clk net439 net985 net237 net442 VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__sdfrtp_4
Xc548 clknet_1_1__leaf_net433 net428 net419 net723 net730 net823 VGND VGND VPWR VPWR
+ net437 sky130_fd_sc_hd__mux4_4
XFILLER_0_99_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c496_A2 net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c427_Q_N net339 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s899_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c359_S0 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput70 net929 VGND VGND VPWR VPWR out15 sky130_fd_sc_hd__buf_2
XANTENNA_merge806_GATE_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c314_C1 clknet_1_1__leaf_net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput92 net951 VGND VGND VPWR VPWR out39 sky130_fd_sc_hd__buf_2
Xoutput81 net940 VGND VGND VPWR VPWR out25 sky130_fd_sc_hd__buf_2
XFILLER_0_37_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c161_X net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c732_S0 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c597_A1 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c451_S1 net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c763_A3 net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc312 net84 net241 net950 net1113 net975 net709 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__mux4_1
Xc301 net232 net657 net1063 VGND VGND VPWR VPWR net975 sky130_fd_sc_hd__or3b_4
XTAP_TAPCELL_ROW_75_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc334 net896 net1050 net137 clknet_1_0__leaf_net153 net966 clknet_1_1__leaf_net780
+ VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__mux4_1
Xc323 net118 net255 net1001 clknet_1_0__leaf_net251 net885 net215 VGND VGND VPWR VPWR
+ net256 sky130_fd_sc_hd__mux4_1
Xc345 clknet_1_1__leaf_net273 clknet_1_0__leaf_net153 net882 net1125 net1057 net794
+ VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__mux4_2
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc367 net174 net296 net284 net1040 net734 clknet_1_1__leaf_net797 VGND VGND VPWR VPWR
+ net300 sky130_fd_sc_hd__mux4_2
Xc356 net40 net908 net963 net771 net782 net786 VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__mux4_2
XANTENNA_c134_C1 net1074 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c626_S1 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge811 net151 clknet_4_14_0_clk net154 VGND VGND VPWR VPWR net681 net680 sky130_fd_sc_hd__dlrbp_1
Xmerge800 net594 net605 VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__nor2b_4
XANTENNA_merge812_GATE clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output103_A net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge822 net193 net631 VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__nand2_4
Xmerge844 clknet_4_7_0_clk net687 net596 VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_23_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge855 net178 clknet_4_7_0_clk net489 VGND VGND VPWR VPWR net732 net731 sky130_fd_sc_hd__dlrbp_1
Xmerge833 net634 net388 VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__or2b_4
XFILLER_0_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge866 clknet_4_14_0_clk net148 net693 VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__sdlclkp_2
XFILLER_0_82_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs961 clknet_4_4_0_clk net579 VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__dlclkp_1
Xs950 net504 clknet_4_7_0_clk VGND VGND VPWR VPWR net944 net839 sky130_fd_sc_hd__dlxbp_1
XTAP_TAPCELL_ROW_11_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer3 net1093 VGND VGND VPWR VPWR net1094 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c325_D1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c698_A0 net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xnet999_4 clknet_1_1__leaf_net706 VGND VGND VPWR VPWR net1087 sky130_fd_sc_hd__inv_1
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_19_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net300 clknet_0_net300 VGND VGND VPWR VPWR clknet_1_0__leaf_net300
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c210_A1 net1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_443 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout134_A net328 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c583_A3 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c727_S0 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c64_S1 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout156 net90 VGND VGND VPWR VPWR net1015 sky130_fd_sc_hd__buf_8
Xfanout134 net328 VGND VGND VPWR VPWR net993 sky130_fd_sc_hd__clkbuf_4
Xfanout145 net1005 VGND VGND VPWR VPWR net1004 sky130_fd_sc_hd__clkbuf_4
Xfanout178 net97 VGND VGND VPWR VPWR net1037 sky130_fd_sc_hd__buf_4
Xfanout189 net422 VGND VGND VPWR VPWR net1048 sky130_fd_sc_hd__clkbuf_2
Xfanout167 net77 VGND VGND VPWR VPWR net1026 sky130_fd_sc_hd__buf_4
XANTENNA_c462_S0 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c758_A3 clknet_1_0__leaf_net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c181_S1 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_7_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c493_A3 net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c201_SET_B net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc120 clknet_1_1__leaf_net50 clknet_1_1__leaf_net48 net1067 clknet_1_1__leaf_net959
+ net942 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__o2111a_2
Xc131 net66 net1072 clknet_1_1__leaf_net62 clknet_1_0__leaf_net965 clknet_1_1__leaf_net60
+ clknet_1_0__leaf_net959 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__mux4_2
Xc153 net88 net920 net87 net1035 net1101 net86 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__mux4_2
Xc142 net1036 net1074 net861 net1081 net73 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__a2111o_4
Xc175 net93 net101 net103 net992 net98 net105 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__mux4_1
Xc164 net94 net93 net85 net425 net878 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__a2111oi_2
Xc186 net886 net894 net1023 net1115 net1059 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__o2111ai_4
Xc197 net130 net129 net128 net118 net116 c197/S1 VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__mux4_2
XANTENNA_c356_S1 net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c372_S0 clknet_1_0__leaf_net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c668_A3 net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge853_Q_N net727 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_16_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_99_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c547_S0 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c578_A3 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c448_C net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net185 clknet_0_net185 VGND VGND VPWR VPWR clknet_1_0__leaf_net185
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c594_A2 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s887_GATE_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c367_S0 net734 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net854 clknet_0_net854 VGND VGND VPWR VPWR clknet_1_1__leaf_net854
+ sky130_fd_sc_hd__clkbuf_16
Xmax_cap1 net242 VGND VGND VPWR VPWR net1144 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c216_B1 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_6_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c286_A net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c589_A2 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c740_S0 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c99_D_N net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input27_A in32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c499_A2 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc80 net12 net6 net10 VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__and3_2
Xc91 net26 net885 net18 VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__nand3b_2
XFILLER_0_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c563_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xwire162 net82 VGND VGND VPWR VPWR net1021 sky130_fd_sc_hd__buf_1
XANTENNA_c691_SCD net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c202_A2 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net386_X clknet_1_1__leaf_net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc708 net561 net1065 net1043 net1048 net832 net847 VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__mux4_1
Xc719 clknet_1_1__leaf_net474 net1044 net846 net848 net850 clknet_1_1__leaf_net854
+ VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__mux4_1
XANTENNA_c591_A3 net724 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s896_Q net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c454_S1 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c470_S0 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net852 net852 VGND VGND VPWR VPWR clknet_0_net852 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c113_Q net942 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net54 clknet_0_net54 VGND VGND VPWR VPWR clknet_1_1__leaf_net54 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_30_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c364_S1 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c328_D1 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_1 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c162_C_N net1082 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer24 net77 VGND VGND VPWR VPWR net1115 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_65_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer13 net376 VGND VGND VPWR VPWR net1104 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_76_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c586_A3 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout217_X net1076 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc505 net1003 net948 clknet_1_0__leaf_net938 net943 clknet_1_1__leaf_net403 net725
+ VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__mux4_4
Xc538 clknet_4_0_0_clk clknet_1_0__leaf_net423 net1011 net993 net987 VGND VGND VPWR
+ VPWR net426 sky130_fd_sc_hd__sdfrtp_1
Xc549 net1078 net999 net1047 net420 net730 net737 VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__mux4_1
XANTENNA_c184_S1 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_14_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c359_S1 net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput82 net941 VGND VGND VPWR VPWR out27 sky130_fd_sc_hd__clkbuf_1
Xoutput93 clknet_1_0__leaf_net952 VGND VGND VPWR VPWR out4 sky130_fd_sc_hd__clkbuf_1
Xoutput71 net930 VGND VGND VPWR VPWR out16 sky130_fd_sc_hd__buf_2
XFILLER_0_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net515 clknet_0_net515 VGND VGND VPWR VPWR clknet_1_0__leaf_net515
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c208_A1 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c285_S0 net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c533_A net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout167_X net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c78_S0 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc302 net887 net232 net975 net894 net96 net657 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_75_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc324 net99 net255 clknet_1_0__leaf_net251 net1144 net1071 net1063 VGND VGND VPWR
+ VPWR net257 sky130_fd_sc_hd__mux4_4
Xc335 net128 net130 clknet_1_0__leaf_net153 net237 net966 net1056 VGND VGND VPWR VPWR
+ net268 sky130_fd_sc_hd__mux4_4
Xc313 net221 net908 net76 net644 clknet_1_0__leaf_net780 VGND VGND VPWR VPWR net245
+ sky130_fd_sc_hd__a2111oi_2
Xc346 net272 net119 net733 net739 clknet_1_1__leaf_net780 net794 VGND VGND VPWR VPWR
+ net279 sky130_fd_sc_hd__mux4_1
Xc368 net122 net1072 net4 net212 clknet_1_1__leaf_net300 clknet_1_0__leaf_net797 VGND
+ VGND VPWR VPWR net947 sky130_fd_sc_hd__mux4_4
Xc357 clknet_1_1__leaf_net282 net988 net1049 net1040 net772 net796 VGND VGND VPWR
+ VPWR net290 sky130_fd_sc_hd__mux4_2
XANTENNA_c134_B1 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge799_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c126_C_N net1125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_86_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge812 net664 clknet_4_6_0_clk net502 VGND VGND VPWR VPWR net683 net682 sky130_fd_sc_hd__dlrbp_1
Xmerge801 clknet_4_8_0_clk net218 net210 VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__dfstp_4
Xmerge823 net589 net570 VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__and2_4
Xmerge845 clknet_4_4_0_clk net678 net476 VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_28_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge834 clknet_4_13_0_clk net406 net402 VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__sdlclkp_1
Xmerge867 clknet_4_14_0_clk net679 net690 VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__sdlclkp_4
XFILLER_0_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs951 net523 clknet_4_7_0_clk VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__dlxtn_1
Xs940 clknet_4_6_0_clk net463 VGND VGND VPWR VPWR net827 net826 sky130_fd_sc_hd__dfxbp_2
Xmerge856 net703 clknet_4_12_0_clk net278 VGND VGND VPWR VPWR net734 net733 sky130_fd_sc_hd__dlrbp_1
Xs962 clknet_4_4_0_clk net580 VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__dlclkp_2
XTAP_TAPCELL_ROW_11_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net490 net490 VGND VGND VPWR VPWR clknet_0_net490 sky130_fd_sc_hd__clkbuf_16
Xrebuffer4 net113 VGND VGND VPWR VPWR net1095 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_51_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_97_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c325_C1 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xnet999_5 clknet_1_0__leaf_net706 VGND VGND VPWR VPWR net1088 sky130_fd_sc_hd__inv_1
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c727_S1 net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_net778_A net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout124 net447 VGND VGND VPWR VPWR net983 sky130_fd_sc_hd__buf_2
Xfanout179 net1039 VGND VGND VPWR VPWR net1038 sky130_fd_sc_hd__buf_12
XANTENNA_input1_A in0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c271_X net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c462_S1 net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc110 clknet_1_1__leaf_net743 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_8
XFILLER_0_60_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc121 clknet_1_1__leaf_net54 clknet_1_1__leaf_net959 net943 VGND VGND VPWR VPWR net56
+ sky130_fd_sc_hd__nor3_1
Xc143 net71 net1036 net920 net69 net1081 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__a2111oi_4
Xc154 net884 net84 net85 net1128 net1077 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__o2111ai_4
Xc132 net916 net861 net1081 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__or3_4
Xc187 net113 net112 net1075 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__or3_2
Xc176 net1 net1024 net886 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__or3_4
Xc165 net1012 net877 net95 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__nand3_2
XANTENNA_c637_S1 net722 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input57_A in6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc198 net20 net14 net0 net130 net1052 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__a2111oi_0
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s962_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c547_S1 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c502_A0 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c176_C net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c221_A1 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_2_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net153 clknet_0_net153 VGND VGND VPWR VPWR clknet_1_0__leaf_net153
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c594_A3 clknet_1_1__leaf_net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_50_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_72_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c412_A0 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c131_A1 net1072 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_83_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s944_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c568_C_N net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c306_A1 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net833 clknet_0_net833 VGND VGND VPWR VPWR clknet_1_1__leaf_net833
+ sky130_fd_sc_hd__clkbuf_16
Xmax_cap2 net107 VGND VGND VPWR VPWR net1145 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c695_A2 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c277_S1 net1078 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c232_A0 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c293_S0 net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout194_A net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c286_B net1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c279_A net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s939_Q net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c86_S0 net1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c468_S0 net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge840_A net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c499_A3 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc70 net888 net3 net7 VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__or3_4
Xc92 net25 net22 net27 VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__and3b_1
Xc81 net881 net1018 net1064 net14 net1071 VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__o2111a_4
XFILLER_0_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s903_GATE_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s908_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c560_S1 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c227_A0 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout207_A net1158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc709 clknet_1_1__leaf_net474 net1103 net1079 net841 net848 net849 VGND VGND VPWR
+ VPWR net574 sky130_fd_sc_hd__mux4_4
XFILLER_0_12_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout197_X net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s889_Q net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c751_S0 net821 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c351_X net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_rebuffer2_X net1093 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net853 net853 VGND VGND VPWR VPWR clknet_0_net853 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_10_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c303_A2 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_5_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_22 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer25 net1115 VGND VGND VPWR VPWR net1116 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer36 net1129 VGND VGND VPWR VPWR net1127 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_65_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net471 clknet_0_net471 VGND VGND VPWR VPWR clknet_1_1__leaf_net471
+ sky130_fd_sc_hd__clkbuf_16
Xrebuffer14 net1104 VGND VGND VPWR VPWR net1105 sky130_fd_sc_hd__dlygate4sd1_1
Xclkbuf_1_1__f_net493 clknet_0_net493 VGND VGND VPWR VPWR clknet_1_1__leaf_net493
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c409_A net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc528 net207 net1011 net995 VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__or3b_4
Xc539 net208 net1092 net420 net1047 net1079 VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__a2111o_4
XANTENNA_c399_X net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c465_S1 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c566_X net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c148_C1 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s966_GATE clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c164_D1 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput83 net942 VGND VGND VPWR VPWR out28 sky130_fd_sc_hd__clkbuf_4
Xoutput72 net931 VGND VGND VPWR VPWR out17 sky130_fd_sc_hd__buf_2
Xoutput94 net953 VGND VGND VPWR VPWR out40 sky130_fd_sc_hd__buf_2
XANTENNA_c330_A0 net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_610 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_62_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c339_D1 net789 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c505_A0 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s921_Q net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc303 net89 net223 net97 net1077 net1129 clknet_1_1__leaf_net778 VGND VGND VPWR VPWR
+ net236 sky130_fd_sc_hd__mux4_2
Xc336 net0 net149 net21 net1125 net781 net1056 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__mux4_1
Xc314 net129 clknet_1_0__leaf_net245 net99 clknet_1_1__leaf_net778 clknet_1_0__leaf_net780
+ VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__a2111o_1
XFILLER_0_60_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc325 net240 net255 net988 net1060 net777 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__o2111ai_2
Xc358 net285 net1116 clknet_1_1__leaf_net282 net765 net770 net791 VGND VGND VPWR VPWR
+ net291 sky130_fd_sc_hd__mux4_4
XANTENNA_c683_X net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c476_S0 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc347 clknet_1_1__leaf_net245 net272 net7 net1049 net1060 net970 VGND VGND VPWR VPWR
+ net280 sky130_fd_sc_hd__mux4_2
Xc369 net872 clknet_1_1__leaf_net153 clknet_1_1__leaf_net300 net292 net745 net796
+ VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__mux4_2
XANTENNA_c195_S1 net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c150_B1 net1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_86_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge802 net572 net578 VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__nor2b_4
XFILLER_0_23_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge835 clknet_4_14_0_clk net645 net647 VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__sdlclkp_2
Xmerge824 net167 net150 VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__nor2b_2
XFILLER_0_28_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge846 net637 net477 VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__nor2_2
Xmerge813 net352 clknet_4_3_0_clk net655 VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__dlrtn_1
Xmerge868 clknet_4_12_0_clk net269 net291 VGND VGND VPWR VPWR net746 net745 sky130_fd_sc_hd__dfrbp_2
Xs952 net534 clknet_4_0_0_clk VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__dlxtn_1
Xs941 clknet_4_1_0_clk net466 VGND VGND VPWR VPWR net829 net828 sky130_fd_sc_hd__dfxbp_1
Xmerge857 net414 clknet_4_13_0_clk net405 VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__dlrtn_1
Xs930 clknet_4_13_0_clk net407 VGND VGND VPWR VPWR net815 sky130_fd_sc_hd__dlclkp_2
XFILLER_0_55_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs963 clknet_4_4_0_clk net582 VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__dlclkp_4
XANTENNA_c281_Q_N net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer5 net1095 VGND VGND VPWR VPWR net1096 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c325_B1 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output70_A net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xnet999_6 clknet_1_0__leaf_net706 VGND VGND VPWR VPWR net1089 sky130_fd_sc_hd__inv_1
XANTENNA_c698_A2 net1108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net302 clknet_0_net302 VGND VGND VPWR VPWR clknet_1_0__leaf_net302
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c121_C net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c219_A1 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c235_A0 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout136 net320 VGND VGND VPWR VPWR net995 sky130_fd_sc_hd__buf_2
Xfanout147 net203 VGND VGND VPWR VPWR net1006 sky130_fd_sc_hd__clkbuf_4
Xfanout158 net18 VGND VGND VPWR VPWR net1017 sky130_fd_sc_hd__clkbuf_4
Xfanout169 net115 VGND VGND VPWR VPWR net1028 sky130_fd_sc_hd__buf_4
XFILLER_0_77_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge783_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc100 net28 net15 net26 net35 net1041 VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__a2111oi_4
Xc111 clknet_1_1__leaf_net743 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__dlygate4sd3_1
Xc122 clknet_1_0__leaf_net52 net5 net942 clknet_1_0__leaf_net56 clknet_1_1__leaf_net48
+ VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__o2111ai_4
Xc144 net1038 net861 net1051 net1066 net1036 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__a2111oi_4
Xc133 net916 net920 net1066 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__or3b_4
Xc166 net898 net1037 net92 net1074 net94 net100 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__mux4_1
Xc177 net1039 net1015 net1070 net757 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__or4bb_4
Xc155 net874 net889 net1015 net1126 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__or4bb_1
Xc188 net906 net97 net123 net879 net1020 net1059 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__mux4_2
Xc199 net6 net1050 net889 net122 net1070 net85 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__mux4_1
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c502_A1 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge853_RESET_B net279 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge871_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c754_S0 net1056 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c156_C1 net1076 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s880_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net834 clknet_0_net834 VGND VGND VPWR VPWR clknet_1_1__leaf_net834
+ sky130_fd_sc_hd__clkbuf_16
Xmax_cap3 net441 VGND VGND VPWR VPWR net1146 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c445_D_N net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c216_A2 clknet_1_1__leaf_net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c574_S0 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c293_S1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c684_D_N net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c446_B net734 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c86_S1 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge844_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_7_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c142_A1 net1074 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc71 net8 net915 net1069 VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__nand3_4
Xc82 net16 net14 net910 VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__nor3_2
Xc93 net919 net25 net28 VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__nand3_2
XFILLER_0_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c322_SET_B net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire120 net242 VGND VGND VPWR VPWR net979 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_80_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge835_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c394_S0 net702 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c227_A1 net1071 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c243_A0 net1101 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net706_X clknet_1_1__leaf_net706 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c177_X net1151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net854 net854 VGND VGND VPWR VPWR clknet_0_net854 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c479_S0 net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge858_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net56 clknet_0_net56 VGND VGND VPWR VPWR clknet_1_1__leaf_net56 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net67 clknet_0_net67 VGND VGND VPWR VPWR clknet_1_1__leaf_net67 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c153_A0 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c303_A3 net1077 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input32_A in37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold50 net925 VGND VGND VPWR VPWR net1141 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_11_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c600_A1 net1073 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output119_A net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c213_A3 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net483 clknet_0_net483 VGND VGND VPWR VPWR clknet_1_1__leaf_net483
+ sky130_fd_sc_hd__clkbuf_16
Xrebuffer26 net1152 VGND VGND VPWR VPWR net1154 sky130_fd_sc_hd__dlygate4sd1_1
Xclkbuf_1_1__f_net461 net1122 VGND VGND VPWR VPWR clknet_1_1__leaf_net461 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c571_S1 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer15 net1113 VGND VGND VPWR VPWR net1106 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_65_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c423_D net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c238_A0 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c409_B net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc529 net1106 net996 net1079 VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__nor3b_2
XANTENNA_c294_X net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c762_S0 clknet_1_0__leaf_net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput73 net932 VGND VGND VPWR VPWR out18 sky130_fd_sc_hd__buf_2
XFILLER_0_37_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput84 net943 VGND VGND VPWR VPWR out29 sky130_fd_sc_hd__buf_2
Xoutput95 clknet_1_1__leaf_net954 VGND VGND VPWR VPWR out41 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input35_X net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c330_A1 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net506 clknet_0_net506 VGND VGND VPWR VPWR clknet_1_0__leaf_net506
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net517 clknet_0_net517 VGND VGND VPWR VPWR clknet_1_0__leaf_net517
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_42_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c224_A2 clknet_1_1__leaf_net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c582_S0 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c147_Y net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c265_D1 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c757_S0 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc304 net221 net96 net657 net668 net674 net1063 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__mux4_2
Xc326 clknet_1_1__leaf_net253 net254 net0 net734 clknet_1_0__leaf_net780 net782 VGND
+ VGND VPWR VPWR net259 sky130_fd_sc_hd__mux4_2
Xc315 net672 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__clkbuf_2
Xc337 net12 net18 net1072 net989 net746 net777 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__mux4_4
Xc348 net727 net733 net790 net791 net794 net795 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__mux4_2
Xc359 net289 net930 net725 net740 net768 net786 VGND VGND VPWR VPWR net940 sky130_fd_sc_hd__mux4_2
XANTENNA_c431_A0 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_99_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge803 net252 net256 VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__nand2b_4
XFILLER_0_67_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge825 net632 clknet_4_0_0_clk net658 VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__dlrtn_4
Xmerge836 clknet_4_1_0_clk net980 net686 VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__sdlclkp_4
XFILLER_0_23_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge814 net652 clknet_4_1_0_clk net449 VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__dlrtn_1
XFILLER_0_55_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge847 clknet_4_0_0_clk net640 net639 VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__dfrtp_1
Xmerge858 net612 clknet_4_5_0_clk net602 VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__dlrtn_2
Xmerge869 clknet_4_4_0_clk net549 net608 VGND VGND VPWR VPWR net748 net747 sky130_fd_sc_hd__dfrbp_2
Xs942 clknet_4_4_0_clk net470 VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__dfxtp_1
Xs931 clknet_4_7_0_clk net408 VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_48_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xs920 net350 clknet_4_3_0_clk VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__dlxtn_2
XFILLER_0_55_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clone28_X net1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs964 net583 clknet_4_4_0_clk VGND VGND VPWR VPWR net856 net855 sky130_fd_sc_hd__dlxbn_1
Xs953 net545 clknet_4_0_0_clk VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__dlxtn_4
XTAP_TAPCELL_ROW_11_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_360 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer6 net373 VGND VGND VPWR VPWR net1097 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xnet999_7 clknet_1_0__leaf_net706 VGND VGND VPWR VPWR net1090 sky130_fd_sc_hd__inv_1
XANTENNA_c698_A3 net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net303 clknet_0_net303 VGND VGND VPWR VPWR clknet_1_0__leaf_net303
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net369 clknet_0_net369 VGND VGND VPWR VPWR clknet_1_0__leaf_net369
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_27_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c114_C net1076 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c532_C1 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout159 net17 VGND VGND VPWR VPWR net1018 sky130_fd_sc_hd__buf_4
Xfanout148 net203 VGND VGND VPWR VPWR net1007 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c529_Y net419 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c426_B1 net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc101 net1016 net29 net1041 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__nor3_1
XANTENNA_c487_S0 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc112 net22 clknet_1_0__leaf_net48 net40 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__nand3b_4
Xc123 clknet_1_1__leaf_net48 clknet_1_1__leaf_net959 net17 VGND VGND VPWR VPWR net58
+ sky130_fd_sc_hd__or3b_1
Xc134 net871 net921 net920 net1066 net1074 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__a2111oi_4
Xc145 net75 net73 net1032 net1034 net1035 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__o2111ai_4
Xc178 net879 net992 net113 net909 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__or4bb_1
Xc167 net102 net100 net91 net879 net87 net1029 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__mux4_1
Xc156 net869 net87 net1031 net1076 net875 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__o2111ai_4
Xc189 net992 net121 net894 net116 net123 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__o2111ai_1
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output101_A net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c336_A0 net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge770_D1 net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc690 net551 net1048 net1079 net547 net748 VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__o2111ai_4
XANTENNA_s949_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_3_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge843_CLK_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge829_Q_N net699 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net188 clknet_0_net188 VGND VGND VPWR VPWR clknet_1_0__leaf_net188
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net177 clknet_0_net177 VGND VGND VPWR VPWR clknet_1_0__leaf_net177
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge828_D net370 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input62_A in9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c603_A1 net481 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net835 clknet_0_net835 VGND VGND VPWR VPWR clknet_1_1__leaf_net835
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c574_S1 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c232_A2 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c67_C_N net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c484_S1 net1055 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c142_A2 net1149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s932_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc72 net915 net9 net8 VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__nand3_4
Xc83 net15 net8 net20 VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__and3_2
Xc94 net28 net891 net30 VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__or3_4
XFILLER_0_93_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clone10_X net1101 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xwire121 net981 VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c333_A1 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c569_S1 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c227_A2 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c585_S0 net758 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c243_A1 net1076 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c556_B net1080 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s944_Q net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net833 net833 VGND VGND VPWR VPWR clknet_0_net833 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c137_A2 net1082 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c434_A0 net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net57 clknet_0_net57 VGND VGND VPWR VPWR clknet_1_1__leaf_net57 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c153_A1 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold40 net648 VGND VGND VPWR VPWR net1131 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input25_A in30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold51 net334 VGND VGND VPWR VPWR net1142 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c600_A2 net1130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c609_A0 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge855_Q net732 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output93_A clknet_1_0__leaf_net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c691_CLK_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer27 net68 VGND VGND VPWR VPWR net1118 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_1_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net462 clknet_0_net462 VGND VGND VPWR VPWR clknet_1_1__leaf_net462
+ sky130_fd_sc_hd__clkbuf_16
Xrebuffer16 net1113 VGND VGND VPWR VPWR net1107 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_88_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c299_S1 net757 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout212_A net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c287_X net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c461_Y net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c148_A1 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c164_B1 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput63 clknet_1_0__leaf_net922 VGND VGND VPWR VPWR out0 sky130_fd_sc_hd__clkbuf_1
Xoutput74 net933 VGND VGND VPWR VPWR out19 sky130_fd_sc_hd__buf_2
Xoutput85 net944 VGND VGND VPWR VPWR out3 sky130_fd_sc_hd__buf_2
Xoutput96 net955 VGND VGND VPWR VPWR out42 sky130_fd_sc_hd__buf_2
XFILLER_0_37_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c672_S1 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c611_A1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c330_A2 clknet_1_0__leaf_net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c301_C_N net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c339_B1 net740 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
.ends
