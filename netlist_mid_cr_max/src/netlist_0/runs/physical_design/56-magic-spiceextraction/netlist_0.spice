* NGSPICE file created from netlist_0.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_2 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_2 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_2 abstract view
.subckt sky130_fd_sc_hd__dlclkp_2 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_1 abstract view
.subckt sky130_fd_sc_hd__dfxbp_1 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_1 abstract view
.subckt sky130_fd_sc_hd__dlxtn_1 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_4 abstract view
.subckt sky130_fd_sc_hd__a41oi_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_4 abstract view
.subckt sky130_fd_sc_hd__mux4_4 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_2 abstract view
.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_2 abstract view
.subckt sky130_fd_sc_hd__a41oi_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtn_1 abstract view
.subckt sky130_fd_sc_hd__dfrtn_1 CLK_N D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_2 abstract view
.subckt sky130_fd_sc_hd__dlxtn_2 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_4 abstract view
.subckt sky130_fd_sc_hd__dlclkp_4 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_4 abstract view
.subckt sky130_fd_sc_hd__a41o_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_1 abstract view
.subckt sky130_fd_sc_hd__a41oi_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbp_1 CLK D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q
+ Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_4 abstract view
.subckt sky130_fd_sc_hd__dlxtn_4 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_1 abstract view
.subckt sky130_fd_sc_hd__dlxbn_1 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_2 abstract view
.subckt sky130_fd_sc_hd__a41o_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfsbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfsbp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_2 abstract view
.subckt sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtp_1 abstract view
.subckt sky130_fd_sc_hd__dlxtp_1 D GATE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_4 abstract view
.subckt sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbp_1 abstract view
.subckt sky130_fd_sc_hd__dlxbp_1 D GATE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__lpflow_inputisolatch_1 abstract view
.subckt sky130_fd_sc_hd__lpflow_inputisolatch_1 D SLEEP_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_4 abstract view
.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_1 abstract view
.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_1 abstract view
.subckt sky130_fd_sc_hd__dlclkp_1 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_1 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_4 abstract view
.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_2 abstract view
.subckt sky130_fd_sc_hd__dlxbn_2 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_4 abstract view
.subckt sky130_fd_sc_hd__o21ba_4 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtn_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtn_1 CLK_N D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_4 abstract view
.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_2 abstract view
.subckt sky130_fd_sc_hd__dfrbp_2 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_4 abstract view
.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_2 abstract view
.subckt sky130_fd_sc_hd__dlrtn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_0 abstract view
.subckt sky130_fd_sc_hd__o21ai_0 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_0 abstract view
.subckt sky130_fd_sc_hd__a21boi_0 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_1 abstract view
.subckt sky130_fd_sc_hd__dlrtp_1 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_2 abstract view
.subckt sky130_fd_sc_hd__dfsbp_2 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_4 abstract view
.subckt sky130_fd_sc_hd__a21bo_4 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_2 abstract view
.subckt sky130_fd_sc_hd__dfstp_2 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_2 abstract view
.subckt sky130_fd_sc_hd__dlrtp_2 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_2 abstract view
.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_4 abstract view
.subckt sky130_fd_sc_hd__dfstp_4 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_4 abstract view
.subckt sky130_fd_sc_hd__dlrtp_4 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_4 abstract view
.subckt sky130_fd_sc_hd__and2b_4 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxbp_1 abstract view
.subckt sky130_fd_sc_hd__edfxbp_1 CLK D DE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_16 abstract view
.subckt sky130_fd_sc_hd__buf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_8 abstract view
.subckt sky130_fd_sc_hd__mux2_8 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_1 abstract view
.subckt sky130_fd_sc_hd__dlrbn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxtp_1 abstract view
.subckt sky130_fd_sc_hd__edfxtp_1 CLK D DE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_1 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_1 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_8 abstract view
.subckt sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_2 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_2 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbp_2 abstract view
.subckt sky130_fd_sc_hd__dlrbp_2 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbp_1 abstract view
.subckt sky130_fd_sc_hd__dlrbp_1 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_4 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_4 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrbp_2 abstract view
.subckt sky130_fd_sc_hd__sdfrbp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfstp_2 abstract view
.subckt sky130_fd_sc_hd__sdfstp_2 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_2 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_4 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_4 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_1 abstract view
.subckt sky130_fd_sc_hd__dfsbp_1 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_4 abstract view
.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_1 abstract view
.subckt sky130_fd_sc_hd__dlrtn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_12 abstract view
.subckt sky130_fd_sc_hd__inv_12 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_4 abstract view
.subckt sky130_fd_sc_hd__dlrtn_4 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

.subckt netlist_0 VGND VPWR clk in0 in1 in10 in11 in12 in13 in14 in15 in16 in17 in18
+ in19 in2 in20 in21 in22 in23 in24 in25 in26 in27 in28 in29 in3 in30 in31 in32 in33
+ in34 in35 in36 in37 in38 in39 in4 in40 in41 in42 in43 in44 in45 in46 in47 in48 in49
+ in5 in50 in51 in52 in53 in54 in55 in56 in57 in58 in59 in6 in60 in61 in7 in8 in9
+ out0 out1 out10 out11 out12 out13 out14 out15 out16 out17 out18 out19 out2 out20
+ out21 out22 out23 out24 out25 out26 out27 out28 out29 out3 out30 out31 out32 out33
+ out34 out35 out36 out37 out38 out39 out4 out40 out41 out42 out43 out44 out45 out46
+ out47 out48 out49 out5 out50 out51 out52 out53 out54 out55 out56 out57 out58 out59
+ out6 out60 out61 out7 out8 out9 rst
XFILLER_0_94_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net292 clknet_0_net292 VGND VGND VPWR VPWR clknet_1_1__leaf_net292
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c249_B1 net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge817_A2 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc327 net249 net258 net947 net974 net783 net800 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__mux4_1
Xc316 net249 net247 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__xor2_4
Xc305 clknet_4_2_0_clk net234 net239 net229 net954 net781 VGND VGND VPWR VPWR net241
+ net240 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_60_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc338 net765 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__clkbuf_1
Xc349 net6 net277 net971 net278 net273 net729 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmerge837 net449 net450 VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__xor2_1
Xmerge804 net223 net224 net214 net228 net963 VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__a41o_1
Xmerge815 net868 net947 net12 net311 net68 net763 VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__mux4_1
Xmerge826 net426 net429 VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__xnor2_4
XFILLER_0_55_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs943 clknet_4_12_0_clk net589 VGND VGND VPWR VPWR net815 sky130_fd_sc_hd__dlclkp_2
Xs921 clknet_4_4_0_clk net58 VGND VGND VPWR VPWR net790 net789 sky130_fd_sc_hd__dfxbp_1
Xmerge848 net255 net261 VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__xnor2_1
Xs932 net376 clknet_4_9_0_clk VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__dlxtn_1
Xmerge859 net535 net321 VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_11_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer7 net15 VGND VGND VPWR VPWR net984 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_23_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c606_A1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c622_A0 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net394_A net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout127 net130 VGND VGND VPWR VPWR net952 sky130_fd_sc_hd__buf_4
Xfanout138 net83 VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__buf_6
Xfanout149 net863 VGND VGND VPWR VPWR net974 sky130_fd_sc_hd__buf_12
XFILLER_0_65_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc102 net27 net850 VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__and2b_1
Xc124 net53 net59 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__nand2b_1
Xc113 net865 net870 net833 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__o21bai_1
Xc135 net871 net71 net828 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__o21ai_4
Xc168 net102 net1042 net842 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__a21oi_4
Xc157 net887 net975 net80 net73 net74 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__a41oi_4
Xc146 net82 net79 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__nand2_4
Xc179 net830 net3 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__or2_1
XFILLER_0_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c678_S0 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc680 net549 net545 net552 net207 net555 clknet_1_0__leaf_net784 VGND VGND VPWR VPWR
+ net562 sky130_fd_sc_hd__mux4_4
Xc691 net564 net556 clknet_1_0__leaf_net902 VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__a21bo_2
XANTENNA_c352_B1 net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap130_X net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s938_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c588_S0 net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c527_A0 net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_27_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c72_B net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_94_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input55_A in58 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c172_B1 net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c207_SCE net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net814 clknet_0_net814 VGND VGND VPWR VPWR clknet_1_1__leaf_net814
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c275_B1_N net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout128_X net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c765_S1 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c423_A2 net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input2_X net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc84 net21 net880 VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__and2_2
Xc62 net872 net880 net1046 net875 net845 net878 VGND VGND VPWR VPWR net0 sky130_fd_sc_hd__mux4_2
Xc73 net5 net10 VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__and2b_1
Xc95 net873 net854 net26 VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__o21a_4
XTAP_TAPCELL_ROW_26_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c68_X net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net600 clknet_0_net600 VGND VGND VPWR VPWR clknet_1_1__leaf_net600
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net633 clknet_0_net633 VGND VGND VPWR VPWR clknet_1_1__leaf_net633
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c243_A2 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c153_A2 net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold41 net807 VGND VGND VPWR VPWR net1018 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold52 net481 VGND VGND VPWR VPWR net1029 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input18_A in24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output86_A net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer17 net992 VGND VGND VPWR VPWR net994 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_65_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer28 net1006 VGND VGND VPWR VPWR net1005 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer39 net203 VGND VGND VPWR VPWR net1036 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge806_A4 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c148_A2 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge884_GATE net476 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput64 net889 VGND VGND VPWR VPWR out1 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge870_GATE_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput75 clknet_1_0__leaf_net900 VGND VGND VPWR VPWR out2 sky130_fd_sc_hd__clkbuf_1
Xoutput86 net911 VGND VGND VPWR VPWR out3 sky130_fd_sc_hd__clkbuf_4
Xoutput97 net922 VGND VGND VPWR VPWR out41 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_70_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c355_B1 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c240_A3 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c359_D net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_8_0_clk_X clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc317 net246 net952 net251 net227 net741 net781 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__mux4_1
Xc306 net241 net954 net235 net223 net742 VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__a41oi_4
Xc339 net764 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__clkinv_8
Xc328 net243 net259 net244 net774 net783 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__a41oi_2
XFILLER_0_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c712_A1 net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c669_Y net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge816 net146 net152 net7 net182 net186 net722 VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__mux4_1
Xmerge827 net149 net680 VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__xor2_1
XANTENNA_c159_A1 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge805 net331 net228 net205 net92 net695 VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__a41o_1
XFILLER_0_82_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs922 clknet_4_5_0_clk net63 VGND VGND VPWR VPWR net792 net791 sky130_fd_sc_hd__dfxbp_1
Xmerge849 net283 net285 VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__xor2_4
Xmerge838 clknet_4_2_0_clk net670 net216 VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__dfrtn_1
Xs933 net382 clknet_4_9_0_clk VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__dlxtn_2
XFILLER_0_55_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs944 clknet_4_14_0_clk net598 VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__dlclkp_4
XTAP_TAPCELL_ROW_11_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net494 net494 VGND VGND VPWR VPWR clknet_0_net494 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c175_B1 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer8 net30 VGND VGND VPWR VPWR net985 sky130_fd_sc_hd__buf_6
XFILLER_0_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net316 clknet_0_net316 VGND VGND VPWR VPWR clknet_1_0__leaf_net316
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_47_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge883_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout128 net330 VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c251_A2 net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c417_Y net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c768_S1 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc114 net47 net43 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__and2_4
Xc103 net24 net38 net30 net34 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__a31o_1
Xc125 net61 net29 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__or2b_1
Xc136 net882 net887 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__or2_4
XANTENNA_c420_Q_N net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc158 net78 net976 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__or2_2
Xc147 net81 net827 net882 net75 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__a31o_1
Xc169 net104 net93 net887 net861 net92 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__a41o_4
XFILLER_0_68_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_52_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc681 net561 net562 net945 net556 net334 clknet_1_0__leaf_net784 VGND VGND VPWR VPWR
+ net563 sky130_fd_sc_hd__mux4_4
Xc670 net545 net551 VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__xor2_1
Xc692 net334 net570 net471 net945 net218 VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__a41oi_1
XFILLER_0_75_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap123_X net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c588_S1 net471 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c481_B net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c474_A net788 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c469_Q_N net399 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c71_B1 net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c172_A1 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input48_A in51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net815 clknet_0_net815 VGND VGND VPWR VPWR clknet_1_1__leaf_net815
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c689_S0 net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_71_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c704_A2 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc85 net847 net18 net21 net5 net12 net6 VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__mux4_2
Xc63 net873 net875 net872 net3 net845 net828 VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__mux4_2
Xc74 net10 net8 net881 VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__mux2_4
XFILLER_0_97_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc96 net29 net22 VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_26_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xwire134 net209 VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__buf_4
XANTENNA_c183_B1 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c614_A2 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c364_SCE net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c212_S0 net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold56_A net581 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c243_A3 net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_9_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c715_A1 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c153_A3 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold42 net944 VGND VGND VPWR VPWR net1019 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 net774 VGND VGND VPWR VPWR net1030 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c600_A4 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c178_B1 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c344_A2 net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge910_Q net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer18 net23 VGND VGND VPWR VPWR net995 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_88_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer29 net1007 VGND VGND VPWR VPWR net1006 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_4_0_clk_X clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net643 net643 VGND VGND VPWR VPWR clknet_0_net643 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c726_B1 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c63_A1 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c148_A3 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c164_A2 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput65 clknet_1_1__leaf_net890 VGND VGND VPWR VPWR out10 sky130_fd_sc_hd__clkbuf_1
Xoutput76 net901 VGND VGND VPWR VPWR out20 sky130_fd_sc_hd__buf_2
Xoutput87 net912 VGND VGND VPWR VPWR out30 sky130_fd_sc_hd__clkbuf_4
Xoutput98 net923 VGND VGND VPWR VPWR out42 sky130_fd_sc_hd__buf_2
XANTENNA_input30_A in35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output117_A net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_70_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c249_A2 net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_99_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout148_A net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc307 net233 net232 net239 net234 net1043 net240 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__mux4_1
Xc318 net876 net248 net107 net246 net928 net774 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__mux4_2
XFILLER_0_60_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc329 clknet_4_3_0_clk net253 net228 clknet_1_0__leaf_net755 net781 net1023 VGND VGND
+ VPWR VPWR net919 net264 sky130_fd_sc_hd__sdfbbp_1
XANTENNA_c397_Y net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c712_A2 net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge828 net288 net298 VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__xor2_1
Xmerge817 net374 net25 net947 net315 clknet_1_0__leaf_net199 net293 VGND VGND VPWR
+ VPWR net681 sky130_fd_sc_hd__mux4_2
Xmerge806 net1040 net213 net217 net219 net1021 VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__a41o_1
Xmerge839 clknet_4_10_0_clk net588 net592 VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__dfrtp_2
Xs923 clknet_4_4_0_clk net64 VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__dfxtp_2
Xs934 net383 clknet_4_9_0_clk VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__dlxtn_4
Xs945 net605 clknet_4_11_0_clk VGND VGND VPWR VPWR net818 net817 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_82_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_11_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c175_A1 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer9 net985 VGND VGND VPWR VPWR net986 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_23_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c622_A2 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input33_X net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout129 net943 VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__clkbuf_8
XANTENNA_c469_D net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c426_A3 net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc104 net41 net38 net849 net1000 net36 net1014 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__mux4_2
Xc126 net60 net61 net50 net938 net54 net790 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__mux4_4
Xc115 net51 net1011 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__nand2b_1
XANTENNA_c723_A1 net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc159 net827 net94 net841 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__o21ai_1
Xc137 net71 net882 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__and2b_2
Xc148 net963 net826 net74 net76 net84 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__a41o_2
XTAP_TAPCELL_ROW_44_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net292 net292 VGND VGND VPWR VPWR clknet_0_net292 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c633_A1 net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_12_0_clk_X clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc682 clknet_4_10_0_clk net556 net334 net551 net559 VGND VGND VPWR VPWR net565 net564
+ sky130_fd_sc_hd__sdfsbp_1
Xc671 net326 net547 net546 VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__o21ai_4
Xc660 net217 net207 net966 VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__o21ba_2
XANTENNA_c352_A2 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc693 net542 net571 clknet_1_0__leaf_net574 VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__a21o_4
XFILLER_0_75_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net169 clknet_0_net169 VGND VGND VPWR VPWR clknet_1_0__leaf_net169
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c527_A2 net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_27_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c437_A2 net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_36_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c71_A1 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c453_A1 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c172_A2 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net816 clknet_0_net816 VGND VGND VPWR VPWR clknet_1_1__leaf_net816
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_45_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c689_S1 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_54_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc490 net38 net926 net366 VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_63_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge912_GATE clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_72_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c704_A3 net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc75 net880 net968 VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__nand2b_1
Xc64 net974 net876 net865 net827 net880 net872 VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__mux4_2
Xc86 net17 net21 net23 net22 net20 net2 VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__mux4_2
Xc97 net28 net33 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_26_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A0 net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_90_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c448_A1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c302_S1 net915 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input60_A in7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c183_A1 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c630_A2 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c549_A0 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net814 net814 VGND VGND VPWR VPWR clknet_0_net814 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c225_Y net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_0_0_clk_X clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout133_X net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c120_X net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c715_A2 net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold43 net787 VGND VGND VPWR VPWR net1020 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 net782 VGND VGND VPWR VPWR net1031 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c77_A0 net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c459_A0 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c194_A0 net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c625_A2 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c360_A2 net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer19 net995 VGND VGND VPWR VPWR net996 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c369_B1 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_77_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net600 net600 VGND VGND VPWR VPWR clknet_0_net600 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net633 net633 VGND VGND VPWR VPWR clknet_0_net633 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c726_A1 net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c63_A2 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_merge834_Y net699 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput66 net891 VGND VGND VPWR VPWR out11 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c461_A1 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput77 clknet_1_1__leaf_net902 VGND VGND VPWR VPWR out21 sky130_fd_sc_hd__clkbuf_1
Xoutput99 clknet_1_1__leaf_net924 VGND VGND VPWR VPWR out43 sky130_fd_sc_hd__clkbuf_1
Xoutput88 net913 VGND VGND VPWR VPWR out31 sky130_fd_sc_hd__buf_2
XANTENNA_input23_A in29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c636_A1 clknet_1_1__leaf_net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_14_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_42_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c355_A2 net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output91_A net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c218_S0 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c128_A net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc308 net200 net876 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc319 net123 net227 net253 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__mux2_1
XANTENNA_c562_B1 net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c281_A1 net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c712_A3 net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c664_A net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge906_D net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c285_X net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c557_Y net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge818 net267 net273 net264 clknet_1_0__leaf_net755 net806 VGND VGND VPWR VPWR
+ net682 sky130_fd_sc_hd__a41o_4
Xmerge807 net228 net964 net372 net951 VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__a31oi_1
XFILLER_0_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge829 net517 net519 VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__xor2_1
Xs924 clknet_4_4_0_clk net66 VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__dfxtp_2
Xs946 net606 clknet_4_11_0_clk VGND VGND VPWR VPWR net820 net819 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_63_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xs935 net389 clknet_4_3_0_clk VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__dlxtp_1
XTAP_TAPCELL_ROW_11_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c610_SET_B net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c175_A2 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net307 clknet_0_net307 VGND VGND VPWR VPWR clknet_1_0__leaf_net307
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_47_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c364_D net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc105 net39 net38 net41 net870 net22 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__a41oi_4
Xc127 net11 net62 net60 net1012 net789 net791 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__mux4_4
Xc116 net48 net32 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__nand2b_2
XFILLER_0_20_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc138 net834 net74 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__nor2b_4
Xc149 net80 net840 net77 net75 net963 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__a41o_2
XTAP_TAPCELL_ROW_44_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c257_CLK_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c321_S0 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc672 net207 net551 net553 net832 net550 net945 VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__mux4_2
Xc661 net218 net69 net330 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__a21bo_1
Xc683 net472 net973 net962 VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__o21bai_1
Xc694 net766 VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c377_B1 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c527_A3 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c150_X net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c248_X net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c437_A3 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c71_A2 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c453_A2 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s931_Q_N net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_100_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c347_A3 net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c363_A2 net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge904_Q_N net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc491 net45 net294 net418 clknet_1_0__leaf_net307 net38 VGND VGND VPWR VPWR net419
+ sky130_fd_sc_hd__a41o_4
Xc480 net788 VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__inv_1
XFILLER_0_79_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge810_S1 net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c570_A0 net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c720_A3 net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc65 net828 net830 net845 net849 net858 net974 VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__mux4_2
Xc76 net9 net11 VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__or2_2
Xc87 net18 net24 net995 net22 net5 net847 VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__mux4_2
Xc98 net35 net28 VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__and2b_1
XFILLER_0_97_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c448_A2 net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c82_A1 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c301_S net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c183_A2 net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c614_A4 net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input53_A in56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net603 clknet_0_net603 VGND VGND VPWR VPWR clknet_1_1__leaf_net603
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge883_Q net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge792_B1 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c540_A3 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net815 net815 VGND VGND VPWR VPWR clknet_0_net815 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c565_B1 net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout126_X net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c333_SET_B net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold44 net797 VGND VGND VPWR VPWR net1021 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c609_CLK_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold55 net326 VGND VGND VPWR VPWR net1032 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c459_A1 net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c178_A2 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net422 clknet_0_net422 VGND VGND VPWR VPWR clknet_1_1__leaf_net422
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_83_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c385_A0 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c580_CLK_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c168_Y net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c726_A2 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s935_Q net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c697_X net581 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c742_A1 clknet_1_1__leaf_net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput67 clknet_1_0__leaf_net892 VGND VGND VPWR VPWR out12 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c461_A2 net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput89 clknet_1_1__leaf_net914 VGND VGND VPWR VPWR out32 sky130_fd_sc_hd__clkbuf_1
Xoutput78 clknet_1_1__leaf_net903 VGND VGND VPWR VPWR out22 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_98_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input16_A in22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c189_A1 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge895_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output84_A net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c371_A2 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c234_S0 net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c546_A2 net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc309 net764 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c409_S0 net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input8_A in15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c445_X net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge808 net332 net86 net334 net1025 VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__a31oi_2
Xmerge819 net56 net52 net185 net68 net167 net789 VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__mux4_1
Xs925 clknet_4_0_0_clk net133 VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__dfxtp_4
Xs947 net607 clknet_4_14_0_clk VGND VGND VPWR VPWR net822 net821 sky130_fd_sc_hd__dlxbp_1
Xs936 net398 clknet_4_3_0_clk VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__lpflow_inputisolatch_1
XTAP_TAPCELL_ROW_11_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_527 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c191_A2 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net308 clknet_0_net308 VGND VGND VPWR VPWR clknet_1_0__leaf_net308
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c366_A2 clknet_1_0__leaf_net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge813_S1 net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c573_B1 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc117 net996 net52 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__or2_2
Xc106 net40 net32 net872 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_96_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc128 net767 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_1
Xc139 net75 net860 net840 net973 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__a31o_4
XTAP_TAPCELL_ROW_44_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c467_A1 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c186_A2 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c321_S1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc673 net211 net553 VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__xor2_2
Xc662 net211 net832 net966 VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__o21ai_4
Xc695 net766 VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__inv_6
Xc684 net553 clknet_1_0__leaf_net902 net802 VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__o21a_1
XANTENNA_s950_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge795_B1 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c686_SET_B clknet_1_0__leaf_net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c734_A2 net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c750_A1 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c363_A3 net38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c660_A1 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc470 net396 net410 net273 net800 net1018 VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__a41oi_1
Xc481 net964 net837 VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__xor2_4
Xc492 net351 net870 net936 net268 net303 VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__a41oi_2
XFILLER_0_29_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c241_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c570_A1 net471 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc66 net827 net867 VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__nor2b_1
XFILLER_0_97_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc99 net34 net30 net983 net881 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__a31oi_4
Xc77 net6 net4 net856 net11 net8 net867 VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__mux4_2
Xc88 net839 net863 VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__nor2b_2
XFILLER_0_97_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A2 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c532_Y net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c152_S0 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c464_A2 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c761_A0 net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input46_A in5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net604 clknet_0_net604 VGND VGND VPWR VPWR clknet_1_1__leaf_net604
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c158_B net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net816 net816 VGND VGND VPWR VPWR clknet_0_net816 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold56 net581 VGND VGND VPWR VPWR net1033 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 net225 VGND VGND VPWR VPWR net1022 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c756_A0 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c178_A3 net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c625_A4 net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c491_B1 net38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net401 clknet_0_net401 VGND VGND VPWR VPWR clknet_1_1__leaf_net401
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_83_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net423 clknet_0_net423 VGND VGND VPWR VPWR clknet_1_1__leaf_net423
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net478 clknet_0_net478 VGND VGND VPWR VPWR clknet_1_1__leaf_net478
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge816_S1 net722 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_9_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge916_GCLK net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c268_A net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_69_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c442_B net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c435_A net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c576_B1 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c726_A3 net568 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_78_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput79 net904 VGND VGND VPWR VPWR out23 sky130_fd_sc_hd__buf_2
Xoutput68 net893 VGND VGND VPWR VPWR out13 sky130_fd_sc_hd__buf_2
XFILLER_0_98_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c486_B1 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge839_Q net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output77_A clknet_1_1__leaf_net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge798_A0 net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net924_X clknet_1_0__leaf_net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c409_S1 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c552_A net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c173_X net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge809 net384 clknet_1_0__leaf_net379 net256 net247 VGND VGND VPWR VPWR net673
+ sky130_fd_sc_hd__a31o_1
XFILLER_0_83_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs948 net608 clknet_4_14_0_clk VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__dlxtn_2
Xs926 clknet_4_4_0_clk net168 VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__dlclkp_1
Xs937 clknet_4_6_0_clk net427 VGND VGND VPWR VPWR net809 net808 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_90_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c472_A2 net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c297_Q net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output115_A net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xnet899_2 clknet_1_0__leaf_net917 VGND VGND VPWR VPWR net978 sky130_fd_sc_hd__clkinv_4
XFILLER_0_54_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout146_A net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c405_B net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc118 net54 net968 net55 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__o21ai_1
Xc107 net44 net1015 net38 net29 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_96_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc129 net65 net938 net42 net54 net59 net792 VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__mux4_1
XFILLER_0_41_583 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c602_S1 net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c764_A0 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc630 net529 net509 net870 net513 net268 clknet_1_1__leaf_net478 VGND VGND VPWR VPWR
+ net535 sky130_fd_sc_hd__mux4_4
Xc663 net746 VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__clkinv_4
Xc685 net565 net976 net542 VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__a21oi_4
Xc696 clknet_1_0__leaf_net567 clknet_1_0__leaf_net575 net579 net472 net548 net718
+ VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__mux4_2
Xc674 net746 VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c580_Q_N net483 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c377_A2 net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c393_A1 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge824_S1 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c163_B_N net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c250_A net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c718_A4 net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c143_Y net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout149_X net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c136_X net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c734_A3 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c750_A2 clknet_1_1__leaf_net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c759_A0 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c660_A2 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc460 clknet_1_1__leaf_net386 clknet_1_0__leaf_net379 net947 net960 net733 net804
+ VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__mux4_1
Xc471 net408 net940 net410 net404 net275 clknet_1_1__leaf_net755 VGND VGND VPWR VPWR
+ net401 sky130_fd_sc_hd__mux4_4
Xc482 net744 VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc493 clknet_1_1__leaf_net414 net418 clknet_1_0__leaf_net419 net926 clknet_1_0__leaf_net417
+ net794 VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__mux4_4
XFILLER_0_99_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_32_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc67 net4 net843 VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__and2b_2
XPHY_EDGE_ROW_50_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c579_A0 net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc89 net24 net15 VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__and2_4
Xc78 net12 net15 VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__and2b_1
XFILLER_0_78_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A3 net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c152_S1 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c745_A2 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c464_A3 clknet_1_0__leaf_net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input39_A in43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c327_S1 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_A0 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge792_A2 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge869_Q net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c671_A1 net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc290 net781 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__inv_6
XANTENNA_c390_A2 net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c399_B1 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c549_A3 net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_5_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s922_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c581_A1 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold46 net783 VGND VGND VPWR VPWR net1023 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 net144 VGND VGND VPWR VPWR net1034 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c491_A1 net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net413 clknet_0_net413 VGND VGND VPWR VPWR clknet_1_1__leaf_net413
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net424 clknet_0_net424 VGND VGND VPWR VPWR clknet_1_1__leaf_net424
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c666_A1 net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_88_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c279_A3 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net603 net603 VGND VGND VPWR VPWR clknet_0_net603 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c592_B1 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c742_A3 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput69 net894 VGND VGND VPWR VPWR out14 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_98_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c486_A1 net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input61_X net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c706_S0 net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c552_B net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c587_B1 net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs949 net618 clknet_4_15_0_clk VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__dlxtn_1
Xs938 clknet_4_15_0_clk net520 VGND VGND VPWR VPWR net944 net810 sky130_fd_sc_hd__dfxbp_1
Xs927 clknet_4_5_0_clk net189 VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__dlclkp_2
Xclkbuf_0_net422 net422 VGND VGND VPWR VPWR clknet_0_net422 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c753_A2 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c469_SET_B net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input21_A in27 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_13_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c497_B1 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output108_A net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c366_A4 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_97_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c526_S0 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_85_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c573_A2 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc108 net36 net865 net1014 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_96_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc119 net767 VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c283_X net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c436_S0 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c548_X net452 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c748_A2 net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c467_A3 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc631 net528 clknet_1_1__leaf_net533 net522 net907 net514 net811 VGND VGND VPWR VPWR
+ net910 sky130_fd_sc_hd__mux4_4
Xc620 net522 net958 clknet_1_0__leaf_net417 clknet_1_0__leaf_net425 net970 net1048
+ VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__mux4_1
Xc664 net77 net435 VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__xnor2_4
Xc697 net779 VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__buf_2
Xc675 net552 net556 net544 net543 net549 net435 VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__mux4_1
Xc686 clknet_4_11_0_clk net107 net568 net471 clknet_1_0__leaf_net558 VGND VGND VPWR
+ VPWR net570 net569 sky130_fd_sc_hd__sdfsbp_1
XANTENNA_input24_X net849 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge899_Q net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c568_A2 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_21_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_29_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge892_X net759 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c197_A3 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc450 clknet_1_1__leaf_net356 net246 VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__xor2_4
Xc461 net253 net935 net748 net803 net805 net806 VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__mux4_1
Xc472 net411 net393 net342 clknet_1_1__leaf_net401 net399 net756 VGND VGND VPWR VPWR
+ net402 sky130_fd_sc_hd__mux4_4
Xc494 clknet_1_0__leaf_net917 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__buf_12
Xc483 net747 VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__inv_2
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_82_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c570_A3 net915 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_1_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c298_B net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c714_S0 net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc79 net14 net6 net15 net968 VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__a31oi_4
Xc68 net843 net866 VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__or2_4
XFILLER_0_97_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c595_B1 net483 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c413_X net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c745_A3 net544 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net617 clknet_0_net617 VGND VGND VPWR VPWR clknet_1_1__leaf_net617
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_A1 net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc280 net85 net213 net204 net832 net205 net69 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__mux4_1
Xc291 net109 net206 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__xor2_4
XFILLER_0_46_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c399_A1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge790 net163 net68 net988 net6 net311 VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__a41oi_4
XTAP_TAPCELL_ROW_31_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout121_A net452 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net558_X clknet_1_1__leaf_net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c581_A2 net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold47 net391 VGND VGND VPWR VPWR net1024 sky130_fd_sc_hd__dlygate4sd3_1
Xhold58 net257 VGND VGND VPWR VPWR net1035 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c756_A2 net502 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input51_A in54 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net403 clknet_0_net403 VGND VGND VPWR VPWR clknet_1_1__leaf_net403
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net425 clknet_0_net425 VGND VGND VPWR VPWR clknet_1_1__leaf_net425
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net414 clknet_0_net414 VGND VGND VPWR VPWR clknet_1_1__leaf_net414
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c369_A4 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c666_A2 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_64_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net604 net604 VGND VGND VPWR VPWR clknet_0_net604 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c330_B net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c576_A2 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c323_A net745 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c439_S0 net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c709_SCD net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c64_X net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c349_S0 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net266 clknet_0_net266 VGND VGND VPWR VPWR clknet_1_1__leaf_net266
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c562_A4 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c273_A net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net902_A net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs928 clknet_4_5_0_clk net196 VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__dlclkp_4
Xclkbuf_0_net423 net423 VGND VGND VPWR VPWR clknet_0_net423 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net401 net401 VGND VGND VPWR VPWR clknet_0_net401 sky130_fd_sc_hd__clkbuf_16
Xs939 clknet_4_13_0_clk net523 VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_90_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net478 net478 VGND VGND VPWR VPWR clknet_0_net478 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c753_A3 clknet_1_1__leaf_net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input14_A in20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c497_A1 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c351_S1 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_74_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c382_A4 net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output82_A net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_85_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c261_S1 net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c119_A net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c573_A3 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc109 net37 net26 net46 net35 net881 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__a41oi_4
XTAP_TAPCELL_ROW_96_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input6_A in13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c436_S1 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c610_RESET_B net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c748_A3 net460 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c452_S0 net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c467_A4 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c764_A2 net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc621 clknet_1_1__leaf_net417 net951 net919 net948 net970 VGND VGND VPWR VPWR net527
+ sky130_fd_sc_hd__a41o_1
Xc610 clknet_4_13_0_clk net503 net888 clknet_1_1__leaf_net511 net512 net958 VGND VGND
+ VPWR VPWR net515 net514 sky130_fd_sc_hd__sdfbbn_1
Xc632 net870 clknet_1_0__leaf_net914 net480 net962 net761 net778 VGND VGND VPWR VPWR
+ net536 sky130_fd_sc_hd__mux4_1
Xc698 clknet_1_1__leaf_net577 net351 net334 net544 net464 clknet_1_1__leaf_net575
+ VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__mux4_4
Xc687 net570 net542 VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__xnor2_2
Xc676 net326 clknet_1_0__leaf_net902 VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__xnor2_2
Xc665 net832 net69 VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__xnor2_2
XFILLER_0_99_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c362_S0 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c393_A3 net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout151_A net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c65_S0 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c447_S0 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input9_X net834 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c166_S1 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c759_A2 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c121_A0 net849 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc451 net106 net378 clknet_1_0__leaf_net379 net956 net952 VGND VGND VPWR VPWR net380
+ sky130_fd_sc_hd__a41oi_4
Xc473 net412 clknet_1_0__leaf_net401 net393 net922 net395 net807 VGND VGND VPWR VPWR
+ net403 sky130_fd_sc_hd__mux4_1
Xc462 clknet_4_12_0_clk net342 net922 net975 net273 net804 VGND VGND VPWR VPWR net392
+ net391 sky130_fd_sc_hd__sdfbbp_1
Xc440 net743 VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__inv_6
Xc495 net926 clknet_1_0__leaf_net422 clknet_1_1__leaf_net308 net410 net807 VGND VGND
+ VPWR VPWR net423 sky130_fd_sc_hd__a41oi_4
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_1_0__f_net558_X clknet_1_0__leaf_net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c579_A2 net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc69 net884 net858 VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__nor2_2
XFILLER_0_78_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net494 clknet_0_net494 VGND VGND VPWR VPWR clknet_1_0__leaf_net494
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c761_A3 net399 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_A2 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c624_S1 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c432_Q net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc270 net200 net202 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__or2b_4
Xc281 net829 net703 net798 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__a21oi_2
Xc292 net94 net828 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__xor2_4
XFILLER_0_46_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c399_A2 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge791 net182 net29 net52 net167 net139 net951 VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__mux4_1
XFILLER_0_7_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge801_B1 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c62_S1 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold48 net801 VGND VGND VPWR VPWR net1025 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c460_S0 net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c756_A3 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c619_S1 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input44_A in48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net415 clknet_0_net415 VGND VGND VPWR VPWR clknet_1_1__leaf_net415
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c370_S0 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c104_X net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c439_S1 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c174_S1 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c709_SCE net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c767_A2 clknet_1_1__leaf_net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c486_A3 net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c349_S1 net729 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input47_X net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c304_B1 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge798_A3 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_72_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c433_A net747 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs929 net215 clknet_4_2_0_clk VGND VGND VPWR VPWR net798 net797 sky130_fd_sc_hd__dlxbn_2
XFILLER_0_48_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net413 net413 VGND VGND VPWR VPWR clknet_0_net413 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_196 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c221_X net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net424 net424 VGND VGND VPWR VPWR clknet_0_net424 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c695_Y net579 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c184_B_N net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c632_S1 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output75_A clknet_1_0__leaf_net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c215_B1_N net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_96_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c171_X net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c443_Y net942 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc611 net509 clknet_1_1__leaf_net379 net515 net976 VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__a31o_1
Xc622 net1047 net480 net12 net513 net870 clknet_1_1__leaf_net902 VGND VGND VPWR VPWR
+ net528 sky130_fd_sc_hd__mux4_2
Xc600 net922 net980 net493 net958 net806 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__a41oi_4
Xc633 clknet_1_1__leaf_net379 net392 clknet_1_0__leaf_net533 clknet_1_1__leaf_net169
+ net970 net811 VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__mux4_1
Xc677 net555 net549 net553 VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__o21bai_2
Xc688 net546 net571 net350 VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__a21bo_1
Xc666 net69 net77 net966 VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__a21o_2
XANTENNA_c627_S1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc699 net464 net581 net571 VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__a21bo_1
XANTENNA_c462_Q net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output113_A net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c140_A_N net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge904_GATE_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net643 clknet_0_net643 VGND VGND VPWR VPWR clknet_1_0__leaf_net643
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout144_A net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge804_B1 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c65_S1 net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c447_S1 net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c105_A2 net38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c759_A3 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s943_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c297_SCE net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc430 net739 VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__inv_2
Xc441 net107 net976 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__xnor2_2
Xc452 net378 net935 clknet_1_0__leaf_net379 net1036 net976 net263 VGND VGND VPWR VPWR
+ net381 sky130_fd_sc_hd__mux4_1
Xc463 net406 net363 net967 net837 net269 VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__a41oi_2
XFILLER_0_20_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc496 net420 clknet_1_0__leaf_net423 net366 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__o21ba_4
Xc485 net25 net978 net975 net299 VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__a31oi_4
Xc474 net788 VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__buf_2
XFILLER_0_19_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c373_S0 net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge916_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c685_A2 net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_10_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c206_A1 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c222_B1 net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c730_S1 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s925_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c595_A2 net915 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout147_X net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c132_B1 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c489_A3 clknet_1_0__leaf_net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c87_X net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc260 net186 net194 net50 net188 net49 net936 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__mux4_1
Xc271 net87 net203 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__nand2_2
Xc293 net857 net223 net960 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__o21ba_2
Xc282 net959 net798 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__xor2_4
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge792 net272 net273 net274 net254 net268 VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__a41oi_2
XTAP_TAPCELL_ROW_31_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c217_B1 net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c101_B net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge801_A1 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold49 net616 VGND VGND VPWR VPWR net1026 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net292 clknet_0_net292 VGND VGND VPWR VPWR clknet_1_0__leaf_net292
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c188_S0 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input37_A in41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c370_S1 net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge895_RESET_B net759 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c203_A2 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c280_S1 net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net617 net617 VGND VGND VPWR VPWR clknet_0_net617 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c359_SET_B clknet_1_1__leaf_net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c455_S1 net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c113_A2 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c462_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c486_A4 net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c320_B1 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c333_SCD net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c587_A3 net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net414 net414 VGND VGND VPWR VPWR clknet_0_net414 sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge807_B1 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net403 net403 VGND VGND VPWR VPWR clknet_0_net403 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net425 net425 VGND VGND VPWR VPWR clknet_0_net425 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_2_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_57_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_66_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net814 clknet_0_net814 VGND VGND VPWR VPWR clknet_1_0__leaf_net814
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_18_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_75_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_84_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net266 net266 VGND VGND VPWR VPWR clknet_0_net266 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc612 net515 net885 net905 net404 net946 net961 VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__mux4_1
Xc601 net981 net504 net919 net502 VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__a31o_1
XANTENNA_c135_B1 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc623 net907 net522 net264 net920 net870 net768 VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__mux4_2
Xc634 clknet_1_0__leaf_net478 clknet_1_0__leaf_net914 net970 net395 net525 VGND VGND
+ VPWR VPWR net538 sky130_fd_sc_hd__a41oi_1
Xc678 net555 clknet_1_0__leaf_net558 net543 net556 net334 net553 VGND VGND VPWR VPWR
+ net560 sky130_fd_sc_hd__mux4_1
Xc689 net549 net570 net945 net571 net551 net953 VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__mux4_1
Xc667 net966 net69 VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__xnor2_4
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge881_DE net660 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net600 clknet_0_net600 VGND VGND VPWR VPWR clknet_1_0__leaf_net600
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net633 clknet_0_net633 VGND VGND VPWR VPWR clknet_1_0__leaf_net633
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c229_B net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout137_A net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c402_A1 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc420 clknet_4_8_0_clk net349 net953 net205 net331 net967 VGND VGND VPWR VPWR net351
+ net350 sky130_fd_sc_hd__sdfbbn_2
Xc442 net239 net794 VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__xnor2_1
Xc464 net407 net408 net960 clknet_1_0__leaf_net924 net781 net804 VGND VGND VPWR VPWR
+ net394 sky130_fd_sc_hd__mux4_2
Xc431 net360 net358 net361 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__a21oi_2
Xc453 net227 net972 net363 clknet_1_0__leaf_net379 net885 net803 VGND VGND VPWR VPWR
+ net382 sky130_fd_sc_hd__mux4_2
XFILLER_0_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc497 net303 clknet_1_0__leaf_net419 net25 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__o21a_4
Xc486 net859 clknet_1_1__leaf_net307 net366 net954 net969 VGND VGND VPWR VPWR net414
+ sky130_fd_sc_hd__a41o_4
Xc475 net745 VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__inv_2
XANTENNA_merge791_S0 net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c205_B1_N net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_82_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c595_A3 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge815_A0 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c739_S0 net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c458_S1 net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c413_B1 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s945_GATE_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c307_A1 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc261 net833 net194 net192 net43 net188 net751 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc250 net767 VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__inv_2
Xc272 net205 net204 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__nand2_4
Xc294 net861 net205 VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__xnor2_4
Xc283 net210 net212 net217 net703 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__a31o_1
XANTENNA_c384_S0 net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c696_A2 net579 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge793 net543 net966 net219 net552 net945 VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__a41o_1
XFILLER_0_70_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c233_B1 clknet_1_0__leaf_net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold39 net731 VGND VGND VPWR VPWR net1016 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c456_A net745 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c741_S1 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c188_S1 net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net417 clknet_0_net417 VGND VGND VPWR VPWR clknet_1_1__leaf_net417
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c318_A0 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge877_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c592_A4 net483 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge812_A1 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c194_X net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c304_A2 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c601_B1 net502 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c333_SCE net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c214_A2 net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c587_A4 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge807_A1 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net415 net415 VGND VGND VPWR VPWR clknet_0_net415 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout122_X net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge823_A0 net461 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c747_S0 net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c576_X net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge864_Q_N net729 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c62_X net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_74_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net815 clknet_0_net815 VGND VGND VPWR VPWR clknet_1_0__leaf_net815
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_18_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_96_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c271_A net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge818_B1 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_net900_A net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s931_Q net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc602 clknet_1_0__leaf_net500 net505 net888 net919 clknet_1_1__leaf_net494 net748
+ VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__mux4_1
Xc613 net501 net514 net12 net395 net512 net1031 VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__mux4_2
Xc635 net536 net515 clknet_1_0__leaf_net538 net951 clknet_1_1__leaf_net379 net812
+ VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__mux4_4
Xc624 net518 net948 net907 net513 net521 net870 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__mux4_1
Xc679 clknet_1_0__leaf_net558 net556 net546 net832 clknet_1_0__leaf_net784 VGND VGND
+ VPWR VPWR net561 sky130_fd_sc_hd__a41oi_4
Xc668 net965 net545 VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__xnor2_4
XANTENNA_input12_A in19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c326_A0 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output80_A net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c699_A2 net581 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c236_B1 clknet_1_0__leaf_net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge820_A1 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input4_A in11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c105_A4 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c281_Y net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c402_A2 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_499 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc421 net205 net241 net344 VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__o21ba_1
Xc410 net333 net326 net335 VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__o21ai_4
XFILLER_0_20_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc443 net203 net371 VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__xnor2_2
Xc454 net375 net935 net373 net967 net803 net804 VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__mux4_1
Xc432 clknet_4_9_0_clk net361 net362 net967 net350 VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__sdfrtn_1
XFILLER_0_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc465 net886 net964 net407 VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__a21boi_4
Xc476 net744 VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__clkbuf_1
Xc487 net410 clknet_1_0__leaf_net308 clknet_1_0__leaf_net413 clknet_1_0__leaf_net414
+ net799 VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__a41o_2
XANTENNA_merge791_S1 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc498 clknet_1_0__leaf_net403 net268 clknet_1_1__leaf_net423 net420 clknet_1_0__leaf_net425
+ net807 VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__mux4_2
XFILLER_0_35_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge920 clknet_4_7_0_clk net711 net738 VGND VGND VPWR VPWR net788 net901 sky130_fd_sc_hd__dfrbp_2
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c420_CLK_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge815_A1 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input7_X net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c132_A2 net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc251 net49 net974 net184 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__o21bai_1
Xc240 net174 net137 net170 net875 net25 clknet_1_0__leaf_net900 VGND VGND VPWR VPWR
+ net176 sky130_fd_sc_hd__mux4_2
Xc262 clknet_4_5_0_clk net171 net193 net191 net751 clknet_1_0__leaf_net796 VGND VGND
+ VPWR VPWR net198 net197 sky130_fd_sc_hd__sdfbbp_1
XANTENNA_clkbuf_4_15_0_clk_X clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc284 net703 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__inv_2
Xc295 net781 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__clkbuf_1
Xc273 net202 net1039 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__xor2_1
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge794 net116 net115 net993 net131 net125 net951 VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__mux4_1
XFILLER_0_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c217_A2 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_rebuffer2_A net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c424_A0 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c228_A1 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge812_A2 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c244_B1 net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c752_S1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c410_A2 net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_76_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input42_A in46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge823_A1 net579 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c329_Q_N net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c334_RESET_B net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge796_X net660 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c149_B1 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c683_B1_N net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge794_S1 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input45_X net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap125_A net915 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net816 clknet_0_net816 VGND VGND VPWR VPWR clknet_1_0__leaf_net816
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_18_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_96_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c271_B net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge818_A1 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_s924_Q net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc603 net504 net402 net905 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__o21bai_4
Xc636 net534 clknet_1_1__leaf_net914 clknet_1_0__leaf_net478 net970 net811 net812
+ VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__mux4_4
Xc625 net480 net12 net529 net948 net522 VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__a41oi_4
Xc614 net518 net958 net512 net955 net777 VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__a41oi_2
XFILLER_0_32_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc669 net550 net965 VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__xnor2_4
XANTENNA_merge809_X net673 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c151_A1 net834 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c326_A1 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output73_A net949 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge919_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge820_A2 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c252_B1 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c479_A net788 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c402_A3 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c267_X net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c760_S1 net823 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s928_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc400 net76 net71 VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__xnor2_4
Xc411 net339 net336 net802 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__o21ai_4
XFILLER_0_32_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc455 net263 net246 net971 net253 net804 net805 VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__mux4_1
Xc444 net935 net366 net1036 net1017 net799 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__a41oi_4
Xc422 net826 net227 net798 VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__o21ai_2
Xc433 net747 VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_8_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc477 net19 net374 net934 VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__a21bo_1
Xc466 net275 net395 net410 VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__mux2_1
Xc488 net287 clknet_1_0__leaf_net415 net303 net969 VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__a31o_4
XFILLER_0_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc499 net291 net962 net348 net973 clknet_1_0__leaf_net425 net925 VGND VGND VPWR VPWR
+ net427 sky130_fd_sc_hd__mux4_2
XANTENNA_c262_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output111_A net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge910 net474 clknet_4_9_0_clk net416 VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__dlrtn_2
XANTENNA_clkbuf_4_11_0_clk_X clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c337_A0 net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout142_A net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge815_A2 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c401_B net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c755_S1 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c710_B1 net483 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c157_B1 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc230 net999 net43 net159 net968 net936 net975 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__mux4_1
Xc252 net183 net185 net68 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__o21ai_0
XFILLER_0_20_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc241 clknet_4_4_0_clk net175 net165 net951 net171 net719 VGND VGND VPWR VPWR net178
+ net177 sky130_fd_sc_hd__sdfbbn_1
Xc263 net190 net191 net197 net751 clknet_1_0__leaf_net900 clknet_1_0__leaf_net796
+ VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__mux4_2
Xc274 net204 net208 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__xnor2_4
Xc296 net229 net227 net857 net87 net222 net224 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__mux4_1
Xc285 net219 net220 net217 net212 net213 net703 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__mux4_2
XFILLER_0_46_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c681_S0 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge795 net571 clknet_1_0__leaf_net577 net569 net572 net831 VGND VGND VPWR VPWR
+ net659 sky130_fd_sc_hd__a41o_2
XTAP_TAPCELL_ROW_31_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c217_A3 net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge801_A4 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c132_X net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c584_RESET_B net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c408_A2 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net419 clknet_0_net419 VGND VGND VPWR VPWR clknet_1_1__leaf_net419
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_98_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c318_A2 net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c329_RESET_B net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_90_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c228_A2 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c244_A1 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge812_A3 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c580_D net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c709_SET_B net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c686_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge877_RESET_B net673 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input35_A in4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c320_A3 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c214_A4 net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c230_A3 net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net417 net417 VGND VGND VPWR VPWR clknet_0_net417 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge823_A2 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c702_A1 net461 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c676_A net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c464_X net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c149_A1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_26_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c612_A1 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input38_X net863 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_44_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge818_A2 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c758_S1 net823 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_62_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc604 net498 net493 net501 net497 net955 net782 VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__mux4_1
Xc637 net524 net540 clknet_1_0__leaf_net538 clknet_1_0__leaf_net533 net778 clknet_1_1__leaf_net902
+ VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__mux4_2
Xc626 net525 clknet_1_1__leaf_net478 clknet_1_1__leaf_net379 net518 net521 net913
+ VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__mux4_2
Xc615 clknet_1_0__leaf_net511 net907 net518 net504 net756 net777 VGND VGND VPWR VPWR
+ net520 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_73_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c493_S1 net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_80_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c623_A0 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net603 clknet_0_net603 VGND VGND VPWR VPWR clknet_1_0__leaf_net603
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge804_A4 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge855_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c769_S0 net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc401 net327 net211 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__xor2_4
Xc412 net326 net335 net339 net695 VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__a31oi_1
Xc423 net92 net342 net240 net898 net801 VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__a41oi_4
Xc434 clknet_1_1__leaf_net355 net357 net364 VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__a21boi_0
Xc445 net743 VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc478 net405 net964 net373 VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__a21boi_2
Xc467 net363 net407 net935 net928 net406 VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__a41oi_4
Xc456 net745 VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__buf_1
Xc489 net962 net392 net303 clknet_1_0__leaf_net924 net800 net807 VGND VGND VPWR VPWR
+ net417 sky130_fd_sc_hd__mux4_4
XFILLER_0_35_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge911 net611 clknet_4_12_0_clk net687 VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__dlrtp_1
Xmerge900 clknet_4_1_0_clk net305 net728 VGND VGND VPWR VPWR net765 net764 sky130_fd_sc_hd__dfsbp_2
XFILLER_0_51_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c337_A1 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net422 clknet_0_net422 VGND VGND VPWR VPWR clknet_1_0__leaf_net422
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c122_A net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout135_A net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c580_RESET_B net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_79_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc220 net153 net137 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__nor2b_1
XFILLER_0_32_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc231 net160 net162 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__nand2_1
XFILLER_0_20_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc242 net50 net49 net719 net722 net790 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__a41oi_1
Xc253 net767 VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__inv_8
Xc286 net210 net72 VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__xnor2_4
Xc297 clknet_4_0_0_clk net1043 net228 net94 net886 net1021 VGND VGND VPWR VPWR net232
+ net231 sky130_fd_sc_hd__sdfbbn_2
Xc264 net72 net73 net87 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__a21o_1
Xc275 net207 net828 net202 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__a21bo_4
XFILLER_0_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A1 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge895_Q net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge796 net953 net945 net826 net467 net746 net801 VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_31_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c233_A3 net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput1 in0 VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_67_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout138_X net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c408_A3 net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c705_A1 net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c766_S1 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c615_A1 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge908_Q net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net921 clknet_0_net921 VGND VGND VPWR VPWR clknet_1_1__leaf_net921
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_0_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c584_SCE net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c228_A3 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c559_B net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c451_B1 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input28_A in33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c601_A3 net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c320_A4 net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_87_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c287_B1_N net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c345_A1 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c361_B1 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net784 clknet_0_net784 VGND VGND VPWR VPWR clknet_1_1__leaf_net784
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net795 clknet_0_net795 VGND VGND VPWR VPWR clknet_1_1__leaf_net795
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c536_B1 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c255_A1 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c702_A2 net579 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c64_A0 net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c181_B1 net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c612_A2 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c356_B1 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge818_A3 net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout120_X net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc627 clknet_1_1__leaf_net422 net970 clknet_1_1__leaf_net478 net514 net809 net811
+ VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__mux4_1
XFILLER_0_4_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc605 net743 VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__inv_1
Xc616 clknet_4_6_0_clk net395 net513 net12 clknet_1_0__leaf_net478 net518 VGND VGND
+ VPWR VPWR net522 net521 sky130_fd_sc_hd__sdfbbp_1
XTAP_TAPCELL_ROW_73_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge811_A net747 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c151_A3 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge873_GATE clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c329_Q net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input50_X net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net604 clknet_0_net604 VGND VGND VPWR VPWR clknet_1_0__leaf_net604
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c236_A3 net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c162_Y net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c427_A2 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c724_A0 net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc402 net73 net953 net218 net959 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__a31oi_1
Xc424 net203 net205 clknet_1_0__leaf_net755 VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__mux2_2
Xc446 net372 net366 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__xnor2_1
Xc413 net335 net339 net802 VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__o21a_4
Xc435 net779 VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__buf_6
Xc468 net952 net868 net960 net964 net967 net804 VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__mux4_1
Xc457 net253 net106 net942 clknet_1_0__leaf_net365 net967 net342 VGND VGND VPWR VPWR
+ net386 sky130_fd_sc_hd__mux4_2
Xc479 net788 VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__inv_2
XFILLER_0_87_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input10_A in17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge901 clknet_4_14_0_clk net659 net628 VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__dfstp_2
Xmerge912 net698 clknet_4_11_0_clk net610 VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__dlrtp_2
XFILLER_0_51_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c618_A1 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c353_A1 net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net423 clknet_0_net423 VGND VGND VPWR VPWR clknet_1_0__leaf_net423
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net401 clknet_0_net401 VGND VGND VPWR VPWR clknet_1_0__leaf_net401
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net478 clknet_0_net478 VGND VGND VPWR VPWR clknet_1_0__leaf_net478
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge800_S0 net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout128_A net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c544_B1 net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input2_A in1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c710_A2 net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c537_X net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge911_GATE clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c499_S1 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c157_A2 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c75_B net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc210 net141 net963 net145 net114 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__a31o_4
Xc221 net1046 net31 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__or2b_2
Xc243 net52 net878 net751 net790 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__a31oi_1
Xc232 net121 net167 net147 net157 net109 net751 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__mux4_1
XANTENNA_c173_A1 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input58_A in60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc254 net184 net941 net181 net930 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__a31o_4
Xc287 net91 net94 net975 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__o21bai_2
Xc276 net208 net828 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__xor2_4
Xc265 net82 net1038 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__nor2_2
Xc298 net103 net954 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_5_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c629_A0 net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge797 net332 net1032 net327 net334 VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__a31o_1
XFILLER_0_83_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput2 in1 VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_67_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c705_A2 net544 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c721_A1 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c449_B1 net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c598_Q_N net502 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s926_GCLK net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c350_A2 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net900 clknet_0_net900 VGND VGND VPWR VPWR clknet_1_1__leaf_net900
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout150_X net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c451_A1 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c420_RESET_B net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output89_A clknet_1_1__leaf_net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge920_Q net788 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net785 clknet_0_net785 VGND VGND VPWR VPWR clknet_1_1__leaf_net785
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net796 clknet_0_net796 VGND VGND VPWR VPWR clknet_1_1__leaf_net796
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c239_A3 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net419 net419 VGND VGND VPWR VPWR clknet_0_net419 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_8_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput60 in7 VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__buf_4
XFILLER_0_12_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c149_A3 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c727_A0 net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c64_A1 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c490_S net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input40_A in44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c356_A1 net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c372_B1 net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc606 net905 net481 net768 net782 VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__a31oi_1
Xc617 net970 net509 net521 clknet_1_1__leaf_net425 net946 net809 VGND VGND VPWR VPWR
+ net523 sky130_fd_sc_hd__mux4_2
Xc628 clknet_1_0__leaf_net422 net970 clknet_1_1__leaf_net478 net768 clknet_1_1__leaf_net900
+ net811 VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__mux4_2
XANTENNA_c713_A2 net483 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c623_A2 net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input43_X net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap123_A net949 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c155_Y net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c534_B net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_334 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc403 net326 net212 net959 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__o21a_1
Xc414 clknet_4_8_0_clk net341 net325 net339 net69 net801 VGND VGND VPWR VPWR net344
+ net343 sky130_fd_sc_hd__sdfbbn_1
Xc425 clknet_1_1__leaf_net355 net967 net798 VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__mux2_4
Xc436 net862 clknet_1_0__leaf_net355 net364 net366 net975 net92 VGND VGND VPWR VPWR
+ net367 sky130_fd_sc_hd__mux4_4
Xc447 clknet_1_1__leaf_net365 net239 net253 net375 net947 net794 VGND VGND VPWR VPWR
+ net376 sky130_fd_sc_hd__mux4_2
Xc458 net377 net342 net366 net384 net803 net805 VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__mux4_1
Xc469 clknet_4_6_0_clk net267 net395 net404 net973 net947 VGND VGND VPWR VPWR net940
+ net399 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_87_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge902 clknet_4_5_0_clk net691 net707 VGND VGND VPWR VPWR net767 sky130_fd_sc_hd__dfstp_4
Xmerge913 net242 clknet_4_0_0_clk net716 VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__dlrtp_4
XFILLER_0_95_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c618_A2 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c353_A2 net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output71_A net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net424 clknet_0_net424 VGND VGND VPWR VPWR clknet_1_0__leaf_net424
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net413 clknet_0_net413 VGND VGND VPWR VPWR clknet_1_0__leaf_net413
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_556 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c157_A3 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c735_A0 net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c68_B net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c454_A1 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc211 net13 net135 net132 net143 net147 net141 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__mux4_4
Xc200 net135 net14 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_68_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc233 net162 net881 net99 clknet_1_0__leaf_net900 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__a31o_4
Xc222 net157 net137 net794 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__a21oi_1
Xc244 net7 net719 net751 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__a21o_1
XFILLER_0_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc255 net43 net938 net941 net178 net49 net936 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__mux4_1
Xc266 net76 net90 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__and2b_4
Xc288 net208 net200 net963 net81 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__a31oi_4
Xc277 net212 net202 net860 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__o21bai_2
Xc299 net851 net223 net954 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__o21ai_2
XFILLER_0_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c629_A1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge798 net348 clknet_1_1__leaf_net403 net421 net962 net303 net794 VGND VGND VPWR
+ VPWR net662 sky130_fd_sc_hd__mux4_1
XFILLER_0_3_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput3 in10 VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__buf_8
XANTENNA_merge905_GATE_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c258_A2 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c705_A3 net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c578_SCD net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c364_RESET_B net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c350_A3 clknet_1_0__leaf_net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_4_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c269_A1 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout143_X net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c285_A0 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c732_A1 net544 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c170_A3 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c345_A3 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge913_Q net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c361_A2 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput61 in8 VGND VGND VPWR VPWR net886 sky130_fd_sc_hd__buf_4
Xinput50 in53 VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__buf_2
XANTENNA_clkbuf_0_net921_A net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net921 net921 VGND VGND VPWR VPWR clknet_0_net921 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c727_A1 net568 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input33_A in38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c469_Q net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge867_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c145_B net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c138_A net834 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c563_B1 net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc618 net404 net12 net1047 net970 net976 net973 VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__mux4_1
XFILLER_0_4_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c100_Y net38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc607 net743 VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_73_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc629 net392 net905 net955 net956 net976 net760 VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__mux4_1
XFILLER_0_69_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_40_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c738_B1 net568 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c457_A1 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net784 net784 VGND VGND VPWR VPWR clknet_0_net784 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_net795 net795 VGND VGND VPWR VPWR clknet_0_net795 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_95_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_12_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c623_A3 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net617 clknet_0_net617 VGND VGND VPWR VPWR clknet_1_0__leaf_net617
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c367_A1 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge814_S0 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c558_B1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c210_X net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc415 net69 net339 net341 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__mux2_1
Xc426 net241 net353 net107 net350 VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__a31o_2
Xc437 net364 clknet_1_0__leaf_net367 net366 net363 clknet_1_0__leaf_net355 net344
+ VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__mux4_4
Xc404 net829 net826 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__xnor2_1
Xc448 net80 net976 net246 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__o21ai_1
Xc459 net928 net971 net253 clknet_1_0__leaf_net386 net733 c459/S1 VGND VGND VPWR VPWR
+ net388 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c267_A_N net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c468_A0 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge903 clknet_4_13_0_clk net499 net700 VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__dfstp_1
XFILLER_0_95_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge914 clknet_4_13_0_clk net506 net762 VGND VGND VPWR VPWR net782 net897 sky130_fd_sc_hd__edfxbp_1
XFILLER_0_67_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c334_Q net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net414 clknet_0_net414 VGND VGND VPWR VPWR clknet_1_0__leaf_net414
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net403 clknet_0_net403 VGND VGND VPWR VPWR clknet_1_0__leaf_net403
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net425 clknet_0_net425 VGND VGND VPWR VPWR clknet_1_0__leaf_net425
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c232_S0 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c263_A3 net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c589_D net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c288_B1 net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c735_A1 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c157_A4 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_79_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc212 net135 net140 net963 net867 net147 net737 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__mux4_1
Xc201 net5 net132 net1 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__mux2_2
XANTENNA_c454_A2 net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c751_A0 clknet_1_0__leaf_net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc245 net166 net50 net109 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__mux2_1
Xc223 net109 net767 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__and2b_1
Xc234 net99 net847 net121 net138 net968 net29 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__mux4_1
XFILLER_0_32_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc256 net719 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__buf_16
Xc267 net202 net87 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__and2b_4
Xc278 net703 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__inv_2
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc289 net222 net94 net210 net206 net203 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__a41oi_2
XTAP_TAPCELL_ROW_5_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c629_A2 net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c348_A3 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge799 net243 net898 net247 net947 VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__a31oi_1
XFILLER_0_55_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c380_A1 net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput4 in11 VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_67_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net266 clknet_0_net266 VGND VGND VPWR VPWR clknet_1_0__leaf_net266
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_0_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout133_A net460 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c705_A4 net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_5_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c578_SCE net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c542_X net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c83_A1 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c465_A1 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c631_A3 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net902 clknet_0_net902 VGND VGND VPWR VPWR clknet_1_1__leaf_net902
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net924 clknet_0_net924 VGND VGND VPWR VPWR clknet_1_1__leaf_net924
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_64_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge793_B1 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c375_A1 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c257_SCD net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_87_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge822_S0 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c269_A2 net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c285_A1 net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout136_X net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c716_A3 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c478_B1_N net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s946_GATE_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c240_S0 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput40 in44 VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__buf_1
Xinput51 in54 VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__clkbuf_2
Xinput62 in9 VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_24_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c292_B net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c589_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net900 net900 VGND VGND VPWR VPWR clknet_0_net900 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c727_A2 net544 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c64_A3 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c364_Q net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input26_A in31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c325_S0 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c356_A3 net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge790_A1 net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output94_A net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc619 net510 net954 net391 net970 net404 net778 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__mux4_1
Xc608 net451 net501 clknet_1_0__leaf_net494 VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__mux2_8
XFILLER_0_69_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c457_A2 net942 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net785 net785 VGND VGND VPWR VPWR clknet_0_net785 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_23_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net796 net796 VGND VGND VPWR VPWR clknet_0_net796 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_95_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_59_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c367_A2 net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c414_SET_B net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge814_S1 net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c277_A2 net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c708_A4 net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c293_A1 net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc416 net345 net341 net339 net336 net344 net953 VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__mux4_1
Xc427 net357 net967 net343 VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__o21bai_4
Xc405 net328 net69 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__xnor2_4
Xc449 net371 net377 net967 net342 net794 VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__a41o_1
Xc438 net747 VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__inv_2
XANTENNA_c740_A2 clknet_1_0__leaf_net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge904 net582 clknet_4_10_0_clk net754 VGND VGND VPWR VPWR net770 net769 sky130_fd_sc_hd__dlrbn_1
XFILLER_0_67_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c468_A1 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge915 clknet_4_0_0_clk net712 net717 VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__edfxtp_1
XFILLER_0_55_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge796_A0 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net415 clknet_0_net415 VGND VGND VPWR VPWR clknet_1_0__leaf_net415
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c232_S1 net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c78_A_N net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c719_A3 net544 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc202 net134 net9 net20 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__o21bai_2
XANTENNA_c454_A3 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc224 net28 net158 VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__and2b_4
Xc213 net4 net142 net736 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__o21a_1
Xc235 net737 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__inv_1
XFILLER_0_60_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c751_A1 net949 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc246 net697 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__inv_2
Xc257 clknet_4_5_0_clk net50 net188 net33 net793 clknet_1_0__leaf_net795 VGND VGND
+ VPWR VPWR net192 net191 sky130_fd_sc_hd__sdfbbn_1
Xc268 net202 net85 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__nand2_4
Xc279 net213 net71 net214 net886 net205 net203 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c317_S1 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c629_A3 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_306 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c661_A1 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c380_A2 net863 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap131_X net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput5 in12 VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__buf_1
XFILLER_0_36_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c389_B1 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout126_A net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s921_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c368_X net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c299_B1 net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c707_RESET_B net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c153_S0 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c449_A3 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c746_A1 net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c66_A net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input56_A in59 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net914 clknet_0_net914 VGND VGND VPWR VPWR clknet_1_1__leaf_net914
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net903 clknet_0_net903 VGND VGND VPWR VPWR clknet_1_1__leaf_net903
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_64_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c672_A0 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c257_SCE net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge822_S1 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c335_B net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c285_A2 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout129_X net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c697_A net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c732_A3 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c451_A4 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input3_X net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c757_A0 net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c492_B1 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net755 clknet_0_net755 VGND VGND VPWR VPWR clknet_1_1__leaf_net755
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_49_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c536_A4 net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c240_S1 clknet_1_0__leaf_net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput30 in35 VGND VGND VPWR VPWR net855 sky130_fd_sc_hd__buf_1
Xinput52 in55 VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__buf_1
Xinput41 in45 VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_52_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c577_B1 net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c233_X net169 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s938_Q net944 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c505_Y net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c469_SCE net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c743_A2 net949 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input19_A in25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge790_A2 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output87_A net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c372_A3 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge799_B1 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net574 clknet_0_net574 VGND VGND VPWR VPWR clknet_1_1__leaf_net574
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net596 clknet_0_net596 VGND VGND VPWR VPWR clknet_1_1__leaf_net596
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c563_A2 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc609 clknet_4_12_0_clk net488 net497 net501 clknet_1_0__leaf_net511 clknet_1_1__leaf_net507
+ VGND VGND VPWR VPWR net513 net512 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c667_B net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer1_X net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c754_A1 net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_95_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c367_A3 net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c558_A2 net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c574_A1 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c203_Y net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc417 net718 VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__clkinv_8
Xc406 net694 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__buf_6
Xc428 net353 clknet_1_0__leaf_net356 net358 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__mux2_8
Xc439 net362 net369 clknet_1_1__leaf_net368 clknet_1_1__leaf_net367 net342 net802
+ VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__mux4_4
XANTENNA_c740_A3 net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c749_A1 clknet_1_1__leaf_net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c468_A2 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge916 clknet_4_15_0_clk net699 net516 VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__sdlclkp_1
Xmerge905 net677 clknet_4_8_0_clk net441 VGND VGND VPWR VPWR net772 net771 sky130_fd_sc_hd__dlrbn_1
XFILLER_0_67_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input41_X net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge796_A1 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c198_B net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_19_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c585_B1 net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c418_Y net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_28_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc203 net867 net110 net120 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_79_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc214 net144 net99 net150 net147 net736 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__a41o_1
Xc236 net881 clknet_1_0__leaf_net169 net767 clknet_1_0__leaf_net900 VGND VGND VPWR
+ VPWR net172 sky130_fd_sc_hd__a31o_1
XFILLER_0_20_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc225 net985 net159 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_92_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c751_A2 net581 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc247 net181 net52 net789 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__o21bai_4
Xc258 net184 net109 clknet_1_0__leaf_net795 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__o21ba_1
Xc269 net203 net87 net77 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__a21bo_4
XANTENNA_c470_A3 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c661_A2 net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap124_X net949 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput6 in13 VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c389_A1 net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c555_A3 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_30_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c475_A net745 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c449_A4 net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c746_A2 net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c83_A3 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input49_A in52 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge830_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge879_Q net747 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c375_A3 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c672_A1 net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c391_A2 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c305_SET_B net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c732_A4 net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_87_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c757_A1 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c195_A3 net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c69_Y net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c492_A1 net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_579 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput20 in26 VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__buf_2
Xinput31 in36 VGND VGND VPWR VPWR net856 sky130_fd_sc_hd__clkbuf_1
Xinput53 in56 VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__clkbuf_4
Xinput42 in46 VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c577_A1 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c296_A2 net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c438_A net747 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net902 net902 VGND VGND VPWR VPWR clknet_0_net902 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net924 net924 VGND VGND VPWR VPWR clknet_0_net924 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c400_Y net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c768_A0 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c622_S0 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge911_Q net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net575 clknet_0_net575 VGND VGND VPWR VPWR clknet_1_1__leaf_net575
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c290_A net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c388_A net788 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c754_A2 net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c473_A3 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_S0 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input31_A in36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output118_A net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net394 clknet_0_net394 VGND VGND VPWR VPWR clknet_1_1__leaf_net394
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout149_A net863 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c574_A2 net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc418 net740 VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__inv_4
Xc407 net694 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__buf_6
Xc429 net352 net240 net358 VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__a21bo_1
XANTENNA_c293_X net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c749_A2 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge917 clknet_4_10_0_clk net560 net584 VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__sdlclkp_2
Xmerge906 net221 clknet_4_6_0_clk net306 VGND VGND VPWR VPWR net774 net773 sky130_fd_sc_hd__dlrbp_2
XFILLER_0_48_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input34_X net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge796_A2 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net417 clknet_0_net417 VGND VGND VPWR VPWR clknet_1_0__leaf_net417
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c358_B clknet_1_0__leaf_net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c253_A net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c288_A3 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c146_Y net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c720_S0 net581 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc226 net31 net881 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__nand2_1
Xc204 net134 net6 net25 net139 net109 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__a41oi_4
Xc215 net137 net974 net976 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__o21bai_2
XTAP_TAPCELL_ROW_92_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c751_A3 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc248 net697 VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__buf_1
Xc259 net192 net941 net722 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__a21boi_1
Xc237 net737 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__buf_6
XANTENNA_c470_A4 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge879_GATE clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c630_S0 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc760 net943 net853 net775 clknet_1_1__leaf_net785 net812 net823 VGND VGND VPWR VPWR
+ net644 sky130_fd_sc_hd__mux4_4
Xinput7 in14 VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_36_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s951_GATE clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c540_S0 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c571_A3 net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c432_SCD net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c596_B1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output100_A net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge793_A3 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c360_S0 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc590 net477 net493 net979 net488 clknet_1_0__leaf_net903 VGND VGND VPWR VPWR net494
+ sky130_fd_sc_hd__a41oi_2
XFILLER_0_37_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_63_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c223_B net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c216_A net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_65_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net902_X clknet_1_1__leaf_net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_74_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c757_A2 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_558 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c492_A2 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input61_A in8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_92_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput21 in27 VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__clkbuf_1
Xinput10 in17 VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__buf_1
XFILLER_0_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput54 in57 VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__clkbuf_1
Xinput43 in47 VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__clkbuf_2
Xinput32 in37 VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__buf_1
XFILLER_0_12_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c204_B1 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c577_A2 net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net914 net914 VGND VGND VPWR VPWR clknet_0_net914 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c296_A3 net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net903 net903 VGND VGND VPWR VPWR clknet_0_net903 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c593_A1 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c622_S1 clknet_1_1__leaf_net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c81_Y net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c74_X net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge790_A4 net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net587 clknet_0_net587 VGND VGND VPWR VPWR clknet_1_1__leaf_net587
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c678_A1 clknet_1_0__leaf_net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c563_A4 net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_73_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c165_B_N net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c176_Y net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c723_S0 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c169_X net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_84_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net755 net755 VGND VGND VPWR VPWR clknet_0_net755 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_51_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c754_A3 clknet_1_1__leaf_net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input24_A in3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c498_A1 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc419 net740 VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__inv_2
Xc408 net325 net336 net334 net326 net329 net953 VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__mux4_1
Xmax_cap140 net547 VGND VGND VPWR VPWR net965 sky130_fd_sc_hd__buf_4
XFILLER_0_13_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c138_B_N net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c665_A net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c453_S0 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c558_Y net461 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c749_A3 net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge907 net750 clknet_4_15_0_clk net727 VGND VGND VPWR VPWR net889 net775 sky130_fd_sc_hd__dlrbp_1
Xmerge918 clknet_4_14_0_clk net620 net623 VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__sdlclkp_4
XANTENNA_s942_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c765_A2 net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_net574 net574 VGND VGND VPWR VPWR clknet_0_net574 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net596 net596 VGND VGND VPWR VPWR clknet_0_net596 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c628_S0 clknet_1_1__leaf_net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c302_A0 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c675_A2 net544 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge915_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_96_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_81_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c720_S1 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s924_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_79_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc227 net120 net137 net29 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__a21boi_4
Xc205 net8 net136 net968 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__a21bo_1
Xc216 net767 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__buf_1
XFILLER_0_20_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc249 net180 net6 net177 net974 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__a31o_1
Xc238 clknet_1_0__leaf_net172 net138 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__and2b_2
XFILLER_0_99_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc750 net113 clknet_1_1__leaf_net558 clknet_1_1__leaf_net538 net897 clknet_1_1__leaf_net815
+ VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__a41o_1
Xc761 net158 net622 clknet_1_0__leaf_net633 net399 net946 clknet_1_1__leaf_net900
+ VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__mux4_4
Xinput8 in15 VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__buf_2
XFILLER_0_78_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c389_A3 net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c540_S1 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c432_SCE net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_2_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c762_A3 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net906 clknet_0_net906 VGND VGND VPWR VPWR clknet_1_1__leaf_net906
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net917 clknet_0_net917 VGND VGND VPWR VPWR clknet_1_1__leaf_net917
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_95_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c672_A3 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc580 clknet_4_11_0_clk net347 net885 net1028 net471 net971 VGND VGND VPWR VPWR net484
+ net483 sky130_fd_sc_hd__sdfbbn_2
Xc591 net491 clknet_1_0__leaf_net494 net70 net952 VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__a31o_1
XFILLER_0_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c414_SCE net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_15_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c63_S1 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c480_A net788 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c103_A2 net38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c461_S0 net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c492_A3 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input54_A in57 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c636_S0 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c371_S0 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c683_A2 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput22 in28 VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput11 in18 VGND VGND VPWR VPWR net836 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_40_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput44 in48 VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__clkbuf_1
Xinput33 in38 VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__buf_12
Xinput55 in58 VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__buf_1
XFILLER_0_24_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout127_X net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c682_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input1_X net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c130_B1 net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c293_B1_N net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net500 clknet_0_net500 VGND VGND VPWR VPWR clknet_1_1__leaf_net500
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net511 clknet_0_net511 VGND VGND VPWR VPWR clknet_1_1__leaf_net511
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net533 clknet_0_net533 VGND VGND VPWR VPWR clknet_1_1__leaf_net533
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net577 clknet_0_net577 VGND VGND VPWR VPWR clknet_1_1__leaf_net577
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge907_GATE clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c588_A2 net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c443_A net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c333_RESET_B net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c633_S1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input17_A in23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c680_A3 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc409 net336 net327 net218 net334 net326 net953 VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__mux4_4
XFILLER_0_13_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmax_cap130 net904 VGND VGND VPWR VPWR net955 sky130_fd_sc_hd__buf_4
XANTENNA_c665_B net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input9_A in16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c286_Y net915 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge908 net725 clknet_4_15_0_clk net626 VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__dlrtn_2
Xmerge919 clknet_4_11_0_clk net576 net752 VGND VGND VPWR VPWR net787 net786 sky130_fd_sc_hd__dfrbp_2
XANTENNA_c765_A3 net502 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net575 net575 VGND VGND VPWR VPWR clknet_0_net575 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c628_S1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net419 clknet_0_net419 VGND VGND VPWR VPWR clknet_1_0__leaf_net419
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c212_A1 net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_53_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_33_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c729_S0 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc217 net145 net963 net147 net146 net971 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__a41o_1
Xc206 net125 net110 net974 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_92_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc228 net26 net25 net975 net951 net31 net163 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__mux4_1
Xc239 net986 clknet_1_1__leaf_net172 net962 clknet_1_0__leaf_net169 VGND VGND VPWR
+ VPWR net175 sky130_fd_sc_hd__a31o_4
XFILLER_0_40_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c464_S0 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net394 net394 VGND VGND VPWR VPWR clknet_0_net394 sky130_fd_sc_hd__clkbuf_16
Xc740 clknet_1_1__leaf_net921 net616 clknet_1_0__leaf_net558 net779 net813 clknet_1_1__leaf_net816
+ VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__mux4_2
Xc751 clknet_1_0__leaf_net558 net949 net581 net958 clknet_1_0__leaf_net890 net822
+ VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__mux4_4
Xc762 clknet_1_1__leaf_net169 clknet_1_1__leaf_net892 clknet_1_1__leaf_net425 net769
+ net823 net825 VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__mux4_4
XANTENNA_clkbuf_4_10_0_clk_X clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput9 in16 VGND VGND VPWR VPWR net834 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_46_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c144_X net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c459_S0 net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c133_B1 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net929 clknet_0_net929 VGND VGND VPWR VPWR clknet_1_1__leaf_net929
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_68_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_24_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc570 net469 net471 net357 net915 net973 net746 VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__mux4_1
Xc581 net385 net347 net484 net451 net457 net957 VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__mux4_1
Xc592 net462 net493 net1029 net483 net778 VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__a41oi_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c111_B net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c209_B net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput110 net935 VGND VGND VPWR VPWR out54 sky130_fd_sc_hd__buf_2
XFILLER_0_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c742_S0 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c461_S1 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c492_A4 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input47_A in50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c371_S1 net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c580_SCE net471 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge877_Q net745 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput12 in19 VGND VGND VPWR VPWR net837 sky130_fd_sc_hd__buf_4
XFILLER_0_24_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput23 in29 VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__buf_1
Xinput34 in39 VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__clkbuf_4
Xinput45 in49 VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__buf_4
XFILLER_0_12_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput56 in59 VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__buf_4
XFILLER_0_24_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c204_A2 net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c593_A3 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c221_A net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c107_X net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c411_B1 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c472_S0 net399 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c245_S net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net567 clknet_0_net567 VGND VGND VPWR VPWR clknet_1_1__leaf_net567
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c305_SCE net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold55_A net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c580_SET_B net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c241_SCD net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c276_B net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c588_A3 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c224_X net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s931_GATE clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone48 in38 VGND VGND VPWR VPWR net1045 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c85_S0 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c603_B1_N net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c689_A2 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net386 clknet_0_net386 VGND VGND VPWR VPWR clknet_1_1__leaf_net386
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap131 net942 VGND VGND VPWR VPWR net956 sky130_fd_sc_hd__buf_4
XFILLER_0_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c462_SCD net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c386_A net745 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c560_B net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge909 net693 clknet_4_9_0_clk net453 VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__dlrtn_2
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net587 net587 VGND VGND VPWR VPWR clknet_0_net587 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c212_A2 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net172 clknet_0_net172 VGND VGND VPWR VPWR clknet_1_1__leaf_net172
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net921 clknet_0_net921 VGND VGND VPWR VPWR clknet_1_0__leaf_net921
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_81_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c570_S0 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout147_A net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c585_A4 net483 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc207 clknet_4_1_0_clk net132 net8 net142 net952 VGND VGND VPWR VPWR net144 net143
+ sky130_fd_sc_hd__sdfrbp_2
Xc218 net126 net140 net153 net143 net886 net736 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_92_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc229 net138 net968 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__nand2_1
XFILLER_0_40_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c291_X net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c403_A1 net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c94_B net849 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc730 net484 net946 clknet_1_1__leaf_net558 net896 net810 net813 VGND VGND VPWR VPWR
+ net615 sky130_fd_sc_hd__mux4_2
Xc763 net397 net853 net951 net776 clknet_1_1__leaf_net785 net825 VGND VGND VPWR VPWR
+ net647 sky130_fd_sc_hd__mux4_4
Xc741 clknet_1_0__leaf_net617 net581 net568 net616 clknet_1_0__leaf_net890 net813
+ VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__mux4_2
Xc752 net946 net940 clknet_1_1__leaf_net558 net956 net775 net811 VGND VGND VPWR VPWR
+ net636 sky130_fd_sc_hd__mux4_4
XANTENNA_c313_A1 net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input32_X net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c364_SET_B net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c390_S0 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c504_B1 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c596_A3 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net784 clknet_0_net784 VGND VGND VPWR VPWR clknet_1_0__leaf_net784
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net795 clknet_0_net795 VGND VGND VPWR VPWR clknet_1_0__leaf_net795
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c137_X net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c194_S1 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c88_B_N net863 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c385_S0 net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc582 net739 VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__clkbuf_1
Xc560 net456 net826 VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__xnor2_2
Xc571 net467 net369 net456 net829 net469 net786 VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__mux4_1
Xc593 net496 net347 net451 net956 net493 net1016 VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__mux4_1
XANTENNA_c364_Q_N net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_16_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_252 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c218_A1 net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c279_S1 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput100 net925 VGND VGND VPWR VPWR out44 sky130_fd_sc_hd__buf_2
XFILLER_0_88_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput111 net936 VGND VGND VPWR VPWR out55 sky130_fd_sc_hd__buf_2
XANTENNA_hold40_X net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge802_A2 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c234_A0 net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_43_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c144_B1 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c110_B_N net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c319_A0 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput13 in2 VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_40_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput24 in3 VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_24_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput46 in5 VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__buf_1
Xinput35 in4 VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__buf_2
XFILLER_0_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput57 in6 VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_70_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc390 net312 net198 net918 net290 net878 net268 VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__mux4_1
XANTENNA_c204_A3 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_48_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net906 net906 VGND VGND VPWR VPWR clknet_0_net906 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_7_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_net917 net917 VGND VGND VPWR VPWR clknet_0_net917 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_7_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge813_A1 net471 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net900_X clknet_1_1__leaf_net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c753_S0 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_97_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c139_B1 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c321_A1 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_hold48_A net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c215_A2 net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_51_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout132_X net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c217_X net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone49 in38 VGND VGND VPWR VPWR net1046 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_90_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c748_S0 clknet_1_1__leaf_net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c85_S1 net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge902_Q net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net365 clknet_0_net365 VGND VGND VPWR VPWR clknet_1_1__leaf_net365
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c462_SCE net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c599_A3 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s927_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s941_Q net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net500 net500 VGND VGND VPWR VPWR clknet_0_net500 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net533 net533 VGND VGND VPWR VPWR clknet_0_net533 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net511 net511 VGND VGND VPWR VPWR clknet_0_net511 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net577 net577 VGND VGND VPWR VPWR clknet_0_net577 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c152_A0 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input22_A in28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c302_A3 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output109_A net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output90_A net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net900 clknet_0_net900 VGND VGND VPWR VPWR clknet_1_0__leaf_net900
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_53_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge805_A2 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc208 net136 net886 net968 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__a21oi_1
XFILLER_0_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc219 net152 net99 net751 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__a21oi_4
XANTENNA_merge821_A1 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c670_B net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c556_Y net460 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c761_S0 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_101_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc720 clknet_1_0__leaf_net604 clknet_1_0__leaf_net596 net559 net484 net581 net961
+ VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__mux4_4
Xc731 clknet_4_12_0_clk net612 net479 net946 net1019 VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__sdfstp_2
XFILLER_0_31_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc753 clknet_1_1__leaf_net633 clknet_1_1__leaf_net415 net397 clknet_1_1__leaf_net890
+ net776 net810 VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__mux4_4
Xc742 net625 clknet_1_1__leaf_net558 clknet_1_1__leaf_net394 net896 net776 clknet_1_0__leaf_net785
+ VGND VGND VPWR VPWR net892 sky130_fd_sc_hd__mux4_4
Xc764 net397 net644 net432 clknet_1_1__leaf_net425 clknet_1_1__leaf_net558 net825
+ VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__mux4_1
XANTENNA_c313_A2 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c390_S1 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net785 clknet_0_net785 VGND VGND VPWR VPWR clknet_1_0__leaf_net785
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net796 clknet_0_net796 VGND VGND VPWR VPWR clknet_1_0__leaf_net796
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c666_X net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c133_A2 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc561 net463 net957 net780 VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__a21boi_4
Xc550 net218 net448 net961 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__o21ai_1
Xc572 net438 net748 net778 net805 VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__a31oi_1
Xc583 net486 net246 net107 net350 net484 VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__a41oi_1
Xc594 net270 net351 net488 net777 VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__a31o_1
XFILLER_0_47_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput101 net989 VGND VGND VPWR VPWR out45 sky130_fd_sc_hd__buf_2
XFILLER_0_88_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput112 net937 VGND VGND VPWR VPWR out56 sky130_fd_sc_hd__buf_2
XFILLER_0_100_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net900_X clknet_1_0__leaf_net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge798_S0 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput14 in20 VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__buf_1
Xinput25 in30 VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__buf_1
XFILLER_0_24_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput36 in40 VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__buf_2
XANTENNA_c311_B1_N net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput58 in60 VGND VGND VPWR VPWR net883 sky130_fd_sc_hd__clkbuf_1
Xinput47 in50 VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc380 net139 net863 net773 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__o21ba_1
Xc391 clknet_1_1__leaf_net316 net950 net290 net763 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__a31oi_2
XANTENNA_c204_A4 net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net929 net929 VGND VGND VPWR VPWR clknet_0_net929 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge890 clknet_4_3_0_clk net280 net400 VGND VGND VPWR VPWR net757 net756 sky130_fd_sc_hd__dfrbp_1
XFILLER_0_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input52_A in55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c321_A2 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net558 clknet_0_net558 VGND VGND VPWR VPWR clknet_1_1__leaf_net558
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_7_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge808_A2 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c748_S1 clknet_1_1__leaf_net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c764_S0 clknet_1_1__leaf_net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c422_A1 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net300 clknet_0_net300 VGND VGND VPWR VPWR clknet_1_1__leaf_net300
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c393_S1 net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net355 clknet_0_net355 VGND VGND VPWR VPWR clknet_1_1__leaf_net355
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_71_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge854_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c441_A net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c539_A net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s934_Q net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net567 net567 VGND VGND VPWR VPWR clknet_0_net567 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_43_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input15_A in21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc209 net142 net878 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__nand2_1
XFILLER_0_25_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input7_A in14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c284_Y net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c700_A1 net579 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c761_S1 clknet_1_1__leaf_net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c489_S0 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c147_A1 net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net386 net386 VGND VGND VPWR VPWR clknet_0_net386 sky130_fd_sc_hd__clkbuf_16
Xc721 clknet_1_0__leaf_net596 net2 clknet_1_1__leaf_net604 net593 net483 net818 VGND
+ VGND VPWR VPWR net606 sky130_fd_sc_hd__mux4_4
Xc710 net594 net0 clknet_1_0__leaf_net921 clknet_1_1__leaf_net574 net483 VGND VGND
+ VPWR VPWR net595 sky130_fd_sc_hd__a41o_1
Xc743 net624 net616 net949 clknet_1_0__leaf_net785 net821 net824 VGND VGND VPWR VPWR
+ net627 sky130_fd_sc_hd__mux4_1
Xc732 net544 clknet_1_0__leaf_net921 net2 net888 clknet_1_1__leaf_net815 VGND VGND
+ VPWR VPWR net890 sky130_fd_sc_hd__a41o_2
Xc765 net630 net641 net351 net502 net944 net911 VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__mux4_2
Xc754 clknet_1_1__leaf_net425 net158 net432 clknet_1_1__leaf_net890 net958 net812
+ VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__mux4_2
XANTENNA_clkbuf_4_15_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c568_B1_N net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_30_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_78_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c504_A2 net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c581_S1 net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge816_A2 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c404_A net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c756_S1 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c133_A3 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c711_B1 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net172 net172 VGND VGND VPWR VPWR clknet_0_net172 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc540 net966 net440 net340 net920 net347 net802 VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__mux4_2
Xc551 net445 net218 VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__xnor2_1
Xc573 net457 net972 net952 net958 VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__a31oi_2
Xc562 net357 net353 net463 net826 net957 VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__a41oi_1
XFILLER_0_47_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc584 clknet_4_9_0_clk net477 net438 net390 net479 VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__sdfrtp_2
Xc595 net1029 net915 net920 net483 VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__a31oi_2
XANTENNA_c340_A1 net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput113 net938 VGND VGND VPWR VPWR out57 sky130_fd_sc_hd__buf_2
XFILLER_0_23_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput102 net927 VGND VGND VPWR VPWR out46 sky130_fd_sc_hd__buf_2
XANTENNA_c234_A2 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c733_B1_N net823 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c409_A2 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c706_A0 net942 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c767_S0 net399 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c113_B1_N net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c425_A1 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c95_X net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge798_S1 net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput15 in21 VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__buf_1
Xinput26 in31 VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_40_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput37 in41 VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__buf_1
Xinput59 in61 VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__buf_1
Xinput48 in51 VGND VGND VPWR VPWR net873 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_75_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc370 clknet_1_0__leaf_net292 clknet_1_1__leaf_net301 net289 net870 net936 net147
+ VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__mux4_2
Xc381 net863 clknet_1_0__leaf_net300 net33 net923 net934 VGND VGND VPWR VPWR net315
+ sky130_fd_sc_hd__a41oi_2
XFILLER_0_58_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc392 net290 net927 net264 net793 net916 VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__a41oi_2
XTAP_TAPCELL_ROW_48_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge891 net650 net637 VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__xnor2_2
XFILLER_0_7_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c364_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge880 merge880/D clknet_4_3_0_clk net706 VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__dlrtp_1
XANTENNA_c526_A0 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_3_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge813_A3 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c261_A0 net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge849_X net713 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input45_A in49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c602_A2 net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge808_A3 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge910_RESET_B net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c474_X net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c598_Q net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c332_A2 net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net301 clknet_0_net301 VGND VGND VPWR VPWR clknet_1_1__leaf_net301
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_58_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net356 clknet_0_net356 VGND VGND VPWR VPWR clknet_1_1__leaf_net356
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net367 clknet_0_net367 VGND VGND VPWR VPWR clknet_1_1__leaf_net367
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_71_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap123 net949 VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c462_RESET_B net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net890 clknet_0_net890 VGND VGND VPWR VPWR clknet_1_1__leaf_net890
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c441_B net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c539_B net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c686_SCD net568 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_11_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c327_A2 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net902 clknet_0_net902 VGND VGND VPWR VPWR clknet_1_0__leaf_net902
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net924 clknet_0_net924 VGND VGND VPWR VPWR clknet_1_0__leaf_net924
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_81_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c579_S1 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge805_A4 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c172_X net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c444_Y net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net365 net365 VGND VGND VPWR VPWR clknet_0_net365 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c147_A2 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c62_A0 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c206_S net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc722 net471 net583 clknet_1_1__leaf_net604 net590 net818 net819 VGND VGND VPWR VPWR
+ net607 sky130_fd_sc_hd__mux4_2
Xc700 net579 net583 net464 net954 net770 VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__a41oi_1
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc711 net595 net594 net553 net813 VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__a31o_1
XFILLER_0_31_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc755 clknet_1_1__leaf_net633 net943 clknet_1_1__leaf_net415 net399 net931 net769
+ VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__mux4_4
Xc733 clknet_1_1__leaf_net494 net813 net823 VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__o21bai_4
Xc744 net1026 net479 net1016 net776 net824 VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__a41oi_1
Xc766 clknet_1_1__leaf_net419 net432 clknet_1_1__leaf_net890 clknet_1_1__leaf_net815
+ net825 net911 VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__mux4_1
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_98_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout145_A net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c404_B net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c264_B1 net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc530 net731 VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__clkbuf_1
Xc563 net455 net945 net464 net438 net957 VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__a41oi_1
XANTENNA_c580_Q net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc541 net675 VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__buf_6
Xc552 net829 net961 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__xor2_2
Xc596 net482 net391 net920 net777 VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__a31oi_4
Xc574 net226 net469 net351 VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__o21bai_4
XFILLER_0_47_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc585 net485 net457 net488 net483 net469 VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__a41oi_2
XFILLER_0_63_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c349_A0 net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput114 net939 VGND VGND VPWR VPWR out58 sky130_fd_sc_hd__buf_2
Xoutput103 net977 VGND VGND VPWR VPWR out47 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c142_Y net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout148_X net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c409_A3 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_12_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c706_A1 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c767_S1 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c144_A3 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c722_A0 net471 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c262_SCE net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_21_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c169_B1 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_30_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput16 in22 VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput27 in32 VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput49 in52 VGND VGND VPWR VPWR net874 sky130_fd_sc_hd__clkbuf_1
Xinput38 in42 VGND VGND VPWR VPWR net863 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_52_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c632_A0 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc382 clknet_1_1__leaf_net300 net198 net941 net933 clknet_1_0__leaf_net796 VGND VGND
+ VPWR VPWR net316 sky130_fd_sc_hd__a41o_1
Xc360 net289 clknet_1_0__leaf_net292 net6 net293 net109 net291 VGND VGND VPWR VPWR
+ net295 sky130_fd_sc_hd__mux4_4
Xc371 net286 net990 net870 clknet_1_1__leaf_net302 net969 net765 VGND VGND VPWR VPWR
+ net306 sky130_fd_sc_hd__mux4_4
XANTENNA_c351_A1 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc393 net314 net909 net937 net139 net927 net793 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_48_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_86_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge881 clknet_4_14_0_clk net726 net660 VGND VGND VPWR VPWR net891 net749 sky130_fd_sc_hd__edfxbp_1
Xmerge870 net495 clknet_4_8_0_clk net702 VGND VGND VPWR VPWR net735 net734 sky130_fd_sc_hd__dlrbn_1
XFILLER_0_28_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge892 net647 net646 VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__xor2_4
XFILLER_0_43_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c542_B1 net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_531 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c717_B1 net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c155_A2 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c602_A3 net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input38_A in42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net538 clknet_0_net538 VGND VGND VPWR VPWR clknet_1_1__leaf_net538
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c362_A0 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc190 net115 net123 net122 net972 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__a31o_1
XFILLER_0_85_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c65_A0 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c166_A1 net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c613_A2 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net302 clknet_0_net302 VGND VGND VPWR VPWR clknet_1_1__leaf_net302
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net368 clknet_0_net368 VGND VGND VPWR VPWR clknet_1_1__leaf_net368
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_58_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net379 clknet_0_net379 VGND VGND VPWR VPWR clknet_1_1__leaf_net379
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c211_S0 net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap124 net898 VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__buf_2
XFILLER_0_40_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge819_A3 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c267_B net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net558 net558 VGND VGND VPWR VPWR clknet_0_net558 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c686_SCE net471 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c730_A0 net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c152_A3 net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c327_A3 net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input60_X net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c624_A1 net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge900_Q net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net914 clknet_0_net914 VGND VGND VPWR VPWR clknet_1_0__leaf_net914
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net903 clknet_0_net903 VGND VGND VPWR VPWR clknet_1_0__leaf_net903
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c550_B1 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c551_B net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_77_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c332_X net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net300 net300 VGND VGND VPWR VPWR clknet_0_net300 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net355 net355 VGND VGND VPWR VPWR clknet_0_net355 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_86_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc701 net580 net569 clknet_1_0__leaf_net577 net564 clknet_1_1__leaf_net784 VGND VGND
+ VPWR VPWR net585 sky130_fd_sc_hd__a41o_1
Xc712 net351 net551 net479 net735 clknet_1_0__leaf_net814 VGND VGND VPWR VPWR net597
+ sky130_fd_sc_hd__a41oi_2
XFILLER_0_31_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c444_A1 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc723 clknet_1_1__leaf_net604 net330 clknet_1_0__leaf_net816 net818 net820 net822
+ VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__mux4_1
Xc745 clknet_1_1__leaf_net603 net961 net544 net621 net766 VGND VGND VPWR VPWR net629
+ sky130_fd_sc_hd__a41oi_2
Xc734 clknet_1_0__leaf_net394 clknet_1_1__leaf_net617 net351 net397 net616 clknet_1_1__leaf_net816
+ VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__mux4_4
Xc756 net962 clknet_1_0__leaf_net633 net502 net397 clknet_1_1__leaf_net538 net820
+ VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__mux4_1
XFILLER_0_31_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc767 clknet_1_0__leaf_net643 net649 clknet_1_1__leaf_net890 clknet_1_1__leaf_net921
+ net399 net911 VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__mux4_2
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input20_A in26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c619_A1 net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c696_S0 net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_78_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net755 clknet_0_net755 VGND VGND VPWR VPWR clknet_1_0__leaf_net755
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout138_A net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c282_X net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer50 net161 VGND VGND VPWR VPWR net1047 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc531 net201 net966 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__xor2_2
Xc553 net369 net438 net79 net350 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__a31o_2
Xc542 net329 net445 net966 net443 net801 VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__a41o_2
Xc564 net465 net79 net920 net218 net961 VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__a41o_1
Xc586 net446 net462 net70 net957 net477 VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__a41oi_2
Xc575 net972 net347 net350 clknet_1_0__leaf_net903 VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__a31o_4
Xc597 net962 net404 net756 VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__o21bai_4
XANTENNA_c621_A2 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c190_B1 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c340_A3 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge898_Q net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c365_B1 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput115 net940 VGND VGND VPWR VPWR out59 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput104 clknet_1_1__leaf_net929 VGND VGND VPWR VPWR out48 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net574 clknet_0_net574 VGND VGND VPWR VPWR clknet_1_0__leaf_net574
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net596 clknet_0_net596 VGND VGND VPWR VPWR clknet_1_0__leaf_net596
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c731_SCD net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c706_A2 net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_14_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput28 in33 VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_91_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput17 in23 VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_40_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput39 in43 VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__buf_1
XFILLER_0_52_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc350 net277 net279 net267 clknet_1_0__leaf_net924 net278 net925 VGND VGND VPWR VPWR
+ net285 sky130_fd_sc_hd__mux4_1
Xc372 net271 clknet_1_1__leaf_net292 net969 net923 net765 VGND VGND VPWR VPWR net307
+ sky130_fd_sc_hd__a41oi_2
Xc361 net286 net12 net276 net885 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__a31o_2
Xc383 net178 clknet_1_0__leaf_net316 net314 net197 net916 clknet_1_0__leaf_net795
+ VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__mux4_1
Xc394 net322 clknet_1_1__leaf_net316 net937 net927 net918 clknet_1_1__leaf_net903
+ VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__mux4_2
XFILLER_0_74_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c351_A2 net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_86_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge882 net634 net651 VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__xnor2_1
Xmerge860 net636 net640 VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__xnor2_1
Xmerge871 net696 clknet_4_1_0_clk net148 VGND VGND VPWR VPWR net737 net736 sky130_fd_sc_hd__dlrbn_1
XFILLER_0_82_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge893 clknet_4_13_0_clk net642 net527 VGND VGND VPWR VPWR net761 net760 sky130_fd_sc_hd__dfrbp_1
XFILLER_0_55_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c270_B_N net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c526_A2 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c542_A1 net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c717_A1 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c452_A1 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c171_A2 net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout150 net859 VGND VGND VPWR VPWR net975 sky130_fd_sc_hd__buf_6
XFILLER_0_44_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge866_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c362_A1 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc180 net844 net116 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__or2b_1
Xc191 net124 net878 net125 net122 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__a31o_1
XFILLER_0_20_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout120_A net452 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge857_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c553_B1 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c467_Y net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c728_A0 net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input50_A in53 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c357_A1 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge839_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap125 net915 VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__buf_4
XFILLER_0_20_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c242_A4 net722 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net892 clknet_0_net892 VGND VGND VPWR VPWR clknet_1_1__leaf_net892
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c121_S1 net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c714_A2 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c730_A1 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c193_B1 net722 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c624_A2 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input53_X net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net199 clknet_0_net199 VGND VGND VPWR VPWR clknet_1_1__leaf_net199
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_61_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_92_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c550_A1 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c700_A4 net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net301 net301 VGND VGND VPWR VPWR clknet_0_net301 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net356 net356 VGND VGND VPWR VPWR clknet_0_net356 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net367 net367 VGND VGND VPWR VPWR clknet_0_net367 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c62_A2 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc702 net566 net461 net579 net571 net770 clknet_1_1__leaf_net784 VGND VGND VPWR VPWR
+ net586 sky130_fd_sc_hd__mux4_4
Xc713 clknet_1_1__leaf_net587 net591 net483 net593 net787 clknet_1_0__leaf_net815
+ VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__mux4_1
XANTENNA_c444_A2 net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc746 net971 net351 net766 net824 VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__a31o_1
Xc724 net551 clknet_1_1__leaf_net600 clknet_1_0__leaf_net604 net817 net819 net822
+ VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__mux4_1
Xc735 net957 net961 clknet_1_0__leaf_net921 clknet_1_0__leaf_net890 clknet_1_0__leaf_net816
+ net823 VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__mux4_1
Xc768 net397 clknet_1_1__leaf_net643 net891 net931 net825 net911 VGND VGND VPWR VPWR
+ net652 sky130_fd_sc_hd__mux4_1
Xc757 net432 net940 net105 net931 net897 clknet_1_1__leaf_net815 VGND VGND VPWR VPWR
+ net641 sky130_fd_sc_hd__mux4_4
XFILLER_0_98_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input13_A in2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c728_S net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net890 net890 VGND VGND VPWR VPWR clknet_0_net890 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_2_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_78_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c545_A1 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c264_A2 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input5_A in12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c275_X net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c329_SCE net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer51 net1047 VGND VGND VPWR VPWR net1048 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer40 net79 VGND VGND VPWR VPWR net1037 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_64_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c174_A2 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc532 net434 net966 VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_9_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc543 net675 VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__inv_6
Xc554 net448 net353 VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__xor2_1
Xc598 clknet_4_12_0_clk clknet_1_1__leaf_net500 net501 clknet_1_1__leaf_net494 net945
+ net1024 VGND VGND VPWR VPWR net888 net502 sky130_fd_sc_hd__sdfbbp_1
Xc587 net480 net481 net484 net347 net912 VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__a41o_1
Xc565 net463 net440 net957 VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__o21a_1
Xc576 net475 net347 net972 VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__a21o_2
XANTENNA_c621_A3 net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c340_A4 net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c349_A2 net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput105 net930 VGND VGND VPWR VPWR out49 sky130_fd_sc_hd__buf_2
Xoutput116 net941 VGND VGND VPWR VPWR out60 sky130_fd_sc_hd__buf_2
XANTENNA_c381_B1 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge812_S0 net949 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net575 clknet_0_net575 VGND VGND VPWR VPWR clknet_1_0__leaf_net575
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout150_A net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c731_SCE net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c275_A1 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c706_A3 net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input8_X net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput18 in24 VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_40_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput29 in34 VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__buf_1
XFILLER_0_52_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc362 net232 net878 net42 clknet_1_0__leaf_net292 net936 net293 VGND VGND VPWR VPWR
+ net297 sky130_fd_sc_hd__mux4_2
Xc340 net270 net225 net19 net794 net799 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__a41oi_4
Xc351 net144 net907 net231 net729 net757 net925 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__mux4_1
Xc373 clknet_1_0__leaf_net307 net296 net878 net969 net765 net773 VGND VGND VPWR VPWR
+ net308 sky130_fd_sc_hd__mux4_4
Xc384 net878 net198 net139 clknet_1_0__leaf_net316 net33 net773 VGND VGND VPWR VPWR
+ net318 sky130_fd_sc_hd__mux4_4
Xc395 net320 clknet_1_1__leaf_net316 net139 net763 net901 VGND VGND VPWR VPWR net324
+ sky130_fd_sc_hd__a41oi_1
XANTENNA_c351_A3 net729 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge861 net631 net627 VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__xnor2_4
Xmerge850 net310 net318 VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__xnor2_1
Xmerge872 net654 net319 VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__xnor2_4
Xmerge894 clknet_4_12_0_clk net704 net732 VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__dfrtn_1
Xmerge883 clknet_4_4_0_clk net195 net154 VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__edfxtp_1
XANTENNA_c230_S0 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c477_B1_N net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net394 clknet_0_net394 VGND VGND VPWR VPWR clknet_1_0__leaf_net394
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c436_A3 net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c171_A3 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout151 net853 VGND VGND VPWR VPWR net976 sky130_fd_sc_hd__buf_6
Xclkbuf_1_1__f_net507 clknet_0_net507 VGND VGND VPWR VPWR clknet_1_1__leaf_net507
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c79_B1 net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc181 net874 net867 net99 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__a21oi_1
Xc170 net848 net97 net106 net844 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__a31o_4
XANTENNA_c362_A2 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc192 net721 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_34_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c686_D net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c728_A1 net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_18_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input43_A in47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge913_GATE clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c161_B_N net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c548_A1 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net538 net538 VGND VGND VPWR VPWR clknet_0_net538 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c359_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c564_B1 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c730_A2 clknet_1_1__leaf_net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c458_A1 net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c92_A0 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c193_A1 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c688_B1_N net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_130 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c384_A0 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge815_S0 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net302 net302 VGND VGND VPWR VPWR clknet_0_net302 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s925_Q net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net368 net368 VGND VGND VPWR VPWR clknet_0_net368 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net379 net379 VGND VGND VPWR VPWR clknet_0_net379 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c62_A3 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc703 net549 clknet_1_0__leaf_net575 net718 clknet_1_1__leaf_net784 clknet_1_0__leaf_net814
+ VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__a41oi_1
XANTENNA_c444_A3 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc747 net629 net940 net602 clknet_1_0__leaf_net892 net373 net616 VGND VGND VPWR VPWR
+ net631 sky130_fd_sc_hd__mux4_1
Xc725 clknet_1_0__leaf_net574 net565 clknet_1_0__leaf_net604 net733 net817 net821
+ VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__mux4_1
Xc714 net578 net594 net885 net735 net899 net787 VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__mux4_4
Xc736 net130 clknet_1_0__leaf_net617 net479 net733 net824 VGND VGND VPWR VPWR net620
+ sky130_fd_sc_hd__a41oi_2
Xc769 net946 clknet_1_1__leaf_net415 net502 net912 net899 clknet_1_0__leaf_net785
+ VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__mux4_4
XANTENNA_c741_A1 net581 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc758 clknet_1_0__leaf_net415 net581 net951 clknet_1_1__leaf_net785 net810 net823
+ VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__mux4_2
XANTENNA_c460_A2 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c188_A1 net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output74_A net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_66_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c379_B1 clknet_1_0__leaf_net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_0_clk_X clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge902_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c545_A2 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c408_S0 net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c170_X net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer30 net1008 VGND VGND VPWR VPWR net1007 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c289_B1 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer41 net90 VGND VGND VPWR VPWR net1038 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_95_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c435_X net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c736_A1 net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c455_A2 net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c752_A0 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc500 clknet_1_1__leaf_net424 net744 net809 VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__mux2_1
Xc555 net440 net369 net446 net451 VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_9_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c471_A1 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc533 net437 net966 VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__xnor2_4
Xc544 net439 net445 net955 VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__a21o_2
Xc566 net749 VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__buf_6
Xc577 net972 net748 net805 VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__o21ai_4
Xc588 net487 net477 net351 net952 net469 net471 VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__mux4_1
Xc599 net493 net982 net905 net501 VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__a31oi_1
XANTENNA_c190_A2 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c318_S0 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c621_A4 net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c365_A2 net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput106 net931 VGND VGND VPWR VPWR out5 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput117 net956 VGND VGND VPWR VPWR out7 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c420_SET_B net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c381_A1 net863 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge812_S1 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net587 clknet_0_net587 VGND VGND VPWR VPWR clknet_1_0__leaf_net587
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout143_A net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c275_A2 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c572_B1 net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_1__f_net914_X clknet_1_1__leaf_net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput19 in25 VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_40_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc330 net251 net232 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__xor2_1
XFILLER_0_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c632_A3 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc352 net173 net885 net271 net33 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__a31o_1
Xc363 net296 net147 net38 net757 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__a31o_1
Xc341 net220 net275 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__xnor2_4
Xc385 net1041 net314 clknet_1_0__leaf_net199 net177 net264 clknet_1_0__leaf_net795
+ VGND VGND VPWR VPWR net894 sky130_fd_sc_hd__mux4_4
Xc374 net901 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__buf_1
Xc396 net212 net71 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__xnor2_1
XFILLER_0_99_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge862 net639 net708 VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__xor2_2
Xmerge840 net489 net490 VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__xnor2_1
Xmerge851 net430 net304 VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__xnor2_4
Xmerge873 net669 clknet_4_8_0_clk net676 VGND VGND VPWR VPWR net740 net739 sky130_fd_sc_hd__dlrbp_1
Xmerge895 clknet_4_11_0_clk net597 net759 VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_70_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge884 clknet_4_7_0_clk net476 net724 VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__sdlclkp_1
XFILLER_0_99_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c230_S1 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c392_B1 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c567_B1 net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c140_Y net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout146_X net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c133_X net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c717_A3 net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c405_Y net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c733_A2 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c452_A3 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout141 net435 VGND VGND VPWR VPWR net966 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_17_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc160 net842 net858 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__and2b_2
Xc171 net852 net99 net106 net95 net102 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__a41o_1
XFILLER_0_20_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc182 net869 net116 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__and2b_1
Xc193 net73 net128 net122 net722 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__a31o_2
XFILLER_0_18_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge864_SET_B net713 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c387_B1 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c553_A2 net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c295_A net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c65_A3 net849 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c463_A2 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c760_A0 net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input36_A in40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net316 clknet_0_net316 VGND VGND VPWR VPWR clknet_1_1__leaf_net316
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c373_A2 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c730_A3 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c359_SCD net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c739_A1 net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c458_A2 net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_22_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c490_A0 net38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net906 clknet_0_net906 VGND VGND VPWR VPWR clknet_1_0__leaf_net906
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net917 clknet_0_net917 VGND VGND VPWR VPWR clknet_1_0__leaf_net917
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_0_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_101_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_5_0_clk_X clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_46_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c725_A3 net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc704 clknet_1_1__leaf_net574 net953 net484 clknet_1_1__leaf_net814 VGND VGND VPWR
+ VPWR net587 sky130_fd_sc_hd__a31o_4
XFILLER_0_71_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c444_A4 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc737 clknet_4_14_0_clk net602 clknet_1_1__leaf_net617 net568 net373 net976 VGND VGND
+ VPWR VPWR net622 net621 sky130_fd_sc_hd__sdfbbp_1
Xc715 net599 net953 net957 clknet_1_1__leaf_net814 clknet_1_0__leaf_net815 clknet_1_0__leaf_net816
+ VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__mux4_4
Xc726 net479 net958 net568 net397 VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__a31o_1
XFILLER_0_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc759 net956 clknet_1_1__leaf_net633 net958 net397 net761 net889 VGND VGND VPWR VPWR
+ net643 sky130_fd_sc_hd__mux4_4
Xc748 net613 clknet_1_1__leaf_net538 net971 net460 clknet_1_1__leaf_net890 clknet_1_1__leaf_net900
+ VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__mux4_2
XANTENNA_c741_A2 net568 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_55_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c460_A3 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c297_Q_N net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c604_S0 net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_80_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_64_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c485_B1 net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net892 net892 VGND VGND VPWR VPWR clknet_0_net892 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c635_A3 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c370_A3 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge797_B1 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c379_A1 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_82_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c185_B1_N net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c561_A2 net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c280_A3 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c408_S1 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer20 net16 VGND VGND VPWR VPWR net997 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer31 net1009 VGND VGND VPWR VPWR net1008 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer42 net1038 VGND VGND VPWR VPWR net1039 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_95_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net199 net199 VGND VGND VPWR VPWR clknet_0_net199 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c752_A1 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc501 net428 clknet_1_1__leaf_net413 clknet_1_0__leaf_net414 clknet_1_1__leaf_net379
+ clknet_1_0__leaf_net403 VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__a41oi_1
Xc545 net442 net446 net920 net448 net440 net434 VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_9_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc534 net860 net81 VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__xnor2_1
Xc567 net468 net334 net467 net469 net954 VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__a41o_1
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc556 net81 net960 VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__xnor2_2
Xc578 clknet_4_9_0_clk net390 net246 net226 net905 VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__sdfrtp_2
Xc589 clknet_4_12_0_clk net946 net385 net488 net912 VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__sdfrtp_4
XTAP_TAPCELL_ROW_63_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_524 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge896_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c662_A1 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput107 net932 VGND VGND VPWR VPWR out50 sky130_fd_sc_hd__buf_2
Xoutput118 net943 VGND VGND VPWR VPWR out8 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c228_S1 net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c297_CLK_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net500 clknet_0_net500 VGND VGND VPWR VPWR clknet_1_0__leaf_net500
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net533 clknet_0_net533 VGND VGND VPWR VPWR clknet_1_0__leaf_net533
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net511 clknet_0_net511 VGND VGND VPWR VPWR clknet_1_0__leaf_net511
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net577 clknet_0_net577 VGND VGND VPWR VPWR clknet_1_0__leaf_net577
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout136_A net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c572_A1 net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c707_SCD net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c747_A1 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c763_A0 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc320 net250 net245 net947 net202 net960 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__a41oi_2
XFILLER_0_32_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_75_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc353 net147 net140 net281 net1030 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__a31o_1
Xc342 net20 net1022 net277 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__o21ai_4
Xc331 net265 clknet_1_1__leaf_net755 net799 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__a21boi_2
Xc397 net718 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__inv_6
Xc364 clknet_4_5_0_clk net140 net950 clknet_1_1__leaf_net292 net6 net1017 VGND VGND
+ VPWR VPWR net918 net299 sky130_fd_sc_hd__sdfbbp_1
Xc375 net309 net938 net908 net68 net299 clknet_1_1__leaf_net795 VGND VGND VPWR VPWR
+ net310 sky130_fd_sc_hd__mux4_2
Xc386 net745 VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__inv_2
XFILLER_0_74_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge830 clknet_4_8_0_clk net337 net661 VGND VGND VPWR VPWR net695 net694 sky130_fd_sc_hd__dfrbp_1
Xmerge863 net656 net678 VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__xor2_1
Xmerge852 net238 net668 VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__xor2_1
XANTENNA_c376_A2 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge841 net354 net370 VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__xor2_4
XFILLER_0_99_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge896 clknet_4_15_0_clk net689 net758 VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__dfrtp_2
Xmerge885 net601 net473 VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__xor2_1
Xmerge874 net684 clknet_4_2_0_clk net701 VGND VGND VPWR VPWR net742 net741 sky130_fd_sc_hd__dlrbp_2
XFILLER_0_43_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c338_A net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c583_B1 net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout120 net452 VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c79_A2 net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout142 net348 VGND VGND VPWR VPWR net967 sky130_fd_sc_hd__buf_4
XFILLER_0_96_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c612_S0 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c477_A1 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc161 net846 net972 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__or2b_1
Xc172 net960 net106 net101 net95 net107 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__a41o_4
XFILLER_0_20_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc150 net972 net78 net82 net69 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__a31o_2
XFILLER_0_85_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc183 net74 net971 net830 net106 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__a31o_2
Xc194 net114 net118 net129 net122 net124 net123 VGND VGND VPWR VPWR net895 sky130_fd_sc_hd__mux4_2
XANTENNA_merge909_Q net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c553_A3 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c416_S1 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s948_Q net823 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c151_S1 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c744_A2 net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c269_B1_N net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c463_A3 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c760_A1 net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input29_A in34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c488_B1 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output97_A net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap139 net259 VGND VGND VPWR VPWR net964 sky130_fd_sc_hd__buf_4
XANTENNA_c373_A3 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_502 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net507 net507 VGND VGND VPWR VPWR clknet_0_net507 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c564_A2 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c308_B net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c283_A3 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c561_B1_N net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c193_X net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c359_SCE net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c739_A2 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c755_A1 net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c598_SCE net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net169 clknet_0_net169 VGND VGND VPWR VPWR clknet_1_1__leaf_net169
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net929 clknet_0_net929 VGND VGND VPWR VPWR clknet_1_0__leaf_net929
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_97_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c384_A2 net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c589_SCE net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c160_B net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_101_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c575_A1 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout121_X net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc705 net548 net544 net373 net484 clknet_1_0__leaf_net587 VGND VGND VPWR VPWR net588
+ sky130_fd_sc_hd__a41o_2
Xc716 clknet_1_0__leaf_net600 net965 net961 net593 clknet_1_0__leaf_net596 VGND VGND
+ VPWR VPWR net601 sky130_fd_sc_hd__a41oi_1
Xc738 clknet_1_1__leaf_net596 net616 net621 clknet_1_0__leaf_net890 net568 VGND VGND
+ VPWR VPWR net623 sky130_fd_sc_hd__a41oi_4
Xc727 net0 net568 net544 net590 net780 net823 VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__mux4_1
XANTENNA_c591_B1 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc749 net591 clknet_1_1__leaf_net558 net956 net853 net350 net811 VGND VGND VPWR VPWR
+ net633 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_4_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c485_A1 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_78_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input51_X net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge878_GATE clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap131_A net942 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer21 net997 VGND VGND VPWR VPWR net998 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer10 net188 VGND VGND VPWR VPWR net987 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_95_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer32 net1010 VGND VGND VPWR VPWR net1009 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer43 net1039 VGND VGND VPWR VPWR net1040 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_95_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c736_A3 net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s930_Q net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c752_A2 clknet_1_1__leaf_net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc502 clknet_1_0__leaf_net423 net973 clknet_1_0__leaf_net424 clknet_1_0__leaf_net425
+ net808 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__a41o_1
Xc546 net447 net329 net332 net448 net734 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__a41oi_2
XTAP_TAPCELL_ROW_9_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc535 net340 net904 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__xor2_4
Xc557 net749 VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__clkinv_8
Xc579 net469 net481 net919 net477 clknet_1_0__leaf_net478 net806 VGND VGND VPWR VPWR
+ net482 sky130_fd_sc_hd__mux4_4
Xc568 net454 net226 net469 VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__o21ba_2
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c199_A2 net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input11_A in18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_71_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c365_A4 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c662_A2 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput119 net944 VGND VGND VPWR VPWR out9 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput108 net933 VGND VGND VPWR VPWR out52 sky130_fd_sc_hd__buf_2
XANTENNA_c381_A3 net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput90 net950 VGND VGND VPWR VPWR out33 sky130_fd_sc_hd__buf_2
XFILLER_0_37_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net567 clknet_0_net567 VGND VGND VPWR VPWR clknet_1_0__leaf_net567
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout129_A net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c93_B_N net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c572_A2 net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input3_A in10 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c707_SCE net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c763_A1 net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc321 net122 net875 net962 net253 net106 net80 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__mux4_1
Xc310 net783 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_75_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input59_A in61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc354 net276 net278 VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__xor2_1
Xc332 net128 net220 net799 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__a21o_2
Xc343 net277 clknet_1_1__leaf_net755 VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__xor2_2
Xc376 net192 net109 net309 VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__o21bai_4
Xc365 net294 net139 clknet_1_1__leaf_net292 net969 net800 VGND VGND VPWR VPWR net300
+ sky130_fd_sc_hd__a41oi_1
Xc387 clknet_1_0__leaf_net302 net933 net139 clknet_1_0__leaf_net316 net878 VGND VGND
+ VPWR VPWR net319 sky130_fd_sc_hd__a41oi_1
Xc398 net71 net886 net797 VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__a21bo_2
XANTENNA_merge916_GATE net699 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge820 net245 net123 net952 net431 clknet_1_0__leaf_net906 net808 VGND VGND VPWR
+ VPWR net684 sky130_fd_sc_hd__mux4_2
XFILLER_0_67_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge831 net164 net667 VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__xor2_1
Xmerge853 net262 net663 VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__xnor2_1
Xmerge864 clknet_4_7_0_clk net723 net713 VGND VGND VPWR VPWR net893 net729 sky130_fd_sc_hd__dfsbp_1
Xmerge842 net381 net380 VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__xor2_1
XFILLER_0_99_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge897 net541 net531 VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__xor2_2
Xmerge886 net317 net313 VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__xnor2_2
Xmerge875 net671 clknet_4_6_0_clk net664 VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__dlrtn_2
Xrebuffer1 net1 VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge894_CLK_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c567_A2 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net386 clknet_0_net386 VGND VGND VPWR VPWR clknet_1_0__leaf_net386
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c488_X net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout121 net452 VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__buf_4
XANTENNA_c662_Y net544 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout143 net7 VGND VGND VPWR VPWR net968 sky130_fd_sc_hd__clkbuf_4
XANTENNA_input6_X net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout132 net958 VGND VGND VPWR VPWR net957 sky130_fd_sc_hd__buf_4
XANTENNA_c758_A1 net581 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c612_S1 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c477_A2 net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc162 net95 net97 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__nor2_4
Xc151 net84 net834 net82 net77 net85 net963 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__mux4_1
Xc140 net832 net75 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__nand2b_4
XANTENNA_c616_SCD net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc184 net119 net106 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__nor2b_1
Xc173 net97 net109 net102 net845 net963 net960 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__mux4_2
Xc195 net129 net126 net122 net99 net114 net721 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c333_Q_N net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c387_A2 net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_99_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c684_B1 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout151_X net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net172 clknet_0_net172 VGND VGND VPWR VPWR clknet_1_0__leaf_net172
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_B1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c463_A4 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net307 clknet_0_net307 VGND VGND VPWR VPWR clknet_1_1__leaf_net307
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c769_A0 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c623_S0 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c564_A3 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c186_X net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c709_CLK_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s941_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c618_S0 net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input41_A in45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c263_S0 clknet_1_0__leaf_net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c259_B1_N net722 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s923_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net316 net316 VGND VGND VPWR VPWR clknet_0_net316 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c575_A2 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc717 net2 net594 net330 net590 net548 VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__a41oi_2
Xc728 net0 net888 net779 VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__mux2_1
Xc706 net942 net945 net107 net548 net805 clknet_1_1__leaf_net814 VGND VGND VPWR VPWR
+ net589 sky130_fd_sc_hd__mux4_1
Xc739 net622 net971 net397 net616 net780 net824 VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__mux4_1
XFILLER_0_97_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c568_X net471 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c173_S0 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c766_A1 net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_80_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c620_S1 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c692_B1 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer11 net926 VGND VGND VPWR VPWR net988 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_68_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer33 net37 VGND VGND VPWR VPWR net1010 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer22 net1001 VGND VGND VPWR VPWR net999 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer44 net1044 VGND VGND VPWR VPWR net1041 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c721_S0 net483 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c586_A1 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c149_X net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c736_A4 net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s923_Q net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c752_A3 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc503 clknet_1_0__leaf_net424 clknet_1_0__leaf_net419 net744 VGND VGND VPWR VPWR net906
+ sky130_fd_sc_hd__o21bai_4
Xc536 net436 net332 net959 net329 net218 VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__a41oi_1
XTAP_TAPCELL_ROW_9_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc569 net772 VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__buf_1
Xc547 net772 VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__buf_6
Xc558 net458 net957 net777 VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__a21oi_1
XANTENNA_c574_B1_N net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c615_S1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c350_S1 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput109 net934 VGND VGND VPWR VPWR out53 sky130_fd_sc_hd__buf_2
XFILLER_0_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput80 net905 VGND VGND VPWR VPWR out24 sky130_fd_sc_hd__clkbuf_4
Xoutput91 net916 VGND VGND VPWR VPWR out34 sky130_fd_sc_hd__buf_2
XFILLER_0_37_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c260_S1 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_14_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c572_A3 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c266_X net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c440_Y net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c763_A2 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c69_B net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc300 net206 net227 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__xor2_2
XFILLER_0_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc311 net245 net107 net226 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__o21bai_4
XTAP_TAPCELL_ROW_75_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc322 net783 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__buf_6
Xc333 clknet_4_1_0_clk clknet_1_0__leaf_net266 net140 net267 net114 net781 VGND VGND
+ VPWR VPWR net907 net268 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_32_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc344 net225 net270 net276 net278 net774 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__a41o_1
XFILLER_0_20_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc366 net297 clknet_1_0__leaf_net924 net173 net969 net757 VGND VGND VPWR VPWR net301
+ sky130_fd_sc_hd__a41o_4
Xc355 net281 net163 net278 net800 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__a31o_1
Xc377 net923 net793 net916 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__a21oi_2
Xc388 net788 VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__clkbuf_2
Xc399 net1037 net211 net832 VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_48_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output110_A net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge810 net987 net179 net49 net296 clknet_1_0__leaf_net302 net299 VGND VGND VPWR
+ VPWR net674 sky130_fd_sc_hd__mux4_1
Xmerge821 net837 net201 net325 net346 net343 VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__a41o_1
Xmerge854 clknet_4_10_0_clk net709 net685 VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__dfrtp_4
Xmerge843 net666 net683 VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__xor2_1
XFILLER_0_7_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge832 clknet_4_5_0_clk net187 net655 VGND VGND VPWR VPWR net930 net697 sky130_fd_sc_hd__dfrbp_1
XFILLER_0_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge865 net492 net619 VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__xor2_1
Xmerge876 net715 clknet_4_6_0_clk net682 VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__dlrtn_1
Xmerge887 clknet_4_7_0_clk net720 net662 VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__sdlclkp_2
XFILLER_0_99_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge898 clknet_4_6_0_clk net690 net282 VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_82_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer2 net928 VGND VGND VPWR VPWR net979 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c392_A3 net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_79_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c255_S1 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c210_B1 net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net365 clknet_0_net365 VGND VGND VPWR VPWR clknet_1_0__leaf_net365
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_88_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout122 net254 VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__buf_4
XFILLER_0_10_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout144 net299 VGND VGND VPWR VPWR net969 sky130_fd_sc_hd__buf_4
Xfanout133 net460 VGND VGND VPWR VPWR net958 sky130_fd_sc_hd__clkbuf_8
XANTENNA_c104_A1 net38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c758_A2 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c81_A net834 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc130 net65 net792 net793 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__o21ai_1
Xc163 net98 net99 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__or2b_1
XFILLER_0_20_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc152 net86 net78 net84 net87 net963 net972 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__mux4_2
Xc141 net840 net72 net75 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__o21ba_1
Xc185 net117 net116 net121 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__a21bo_2
Xc196 net721 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__inv_8
Xc174 net101 net85 net110 net835 net844 net960 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c387_A3 net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c462_D net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_356 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout144_X net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c594_A1 net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c744_A4 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net308 clknet_0_net308 VGND VGND VPWR VPWR clknet_1_1__leaf_net308
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_58_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c679_A1 clknet_1_0__leaf_net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c398_A2 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c564_A4 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c755_A3 net399 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c618_S1 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input34_A in39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c499_A1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc90 net854 net15 VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__nor2b_1
XFILLER_0_97_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c681_A2 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_0_net169_A net169 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c146_B net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c575_A3 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc729 net373 net591 net946 net780 net813 clknet_1_1__leaf_net816 VGND VGND VPWR VPWR
+ net614 sky130_fd_sc_hd__mux4_4
Xc718 clknet_1_1__leaf_net596 net593 net787 net805 clknet_1_0__leaf_net816 VGND VGND
+ VPWR VPWR net603 sky130_fd_sc_hd__a41oi_4
XANTENNA_c719_S0 net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc707 clknet_4_11_0_clk net578 net373 net952 net885 clknet_1_0__leaf_net815 VGND VGND
+ VPWR VPWR net591 net590 sky130_fd_sc_hd__sdfbbn_1
XTAP_TAPCELL_ROW_4_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c737_SCD net568 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c173_S1 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c766_A2 clknet_1_1__leaf_net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_80_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c485_A3 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c629_S0 net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c348_S1 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge832_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_42_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_89_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c395_A3 net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_51_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c692_A1 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold42_A net944 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_60_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer12 net988 VGND VGND VPWR VPWR net989 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_65_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer23 net37 VGND VGND VPWR VPWR net1000 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer34 net47 VGND VGND VPWR VPWR net1011 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer45 net89 VGND VGND VPWR VPWR net1042 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c528_B net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net169 net169 VGND VGND VPWR VPWR clknet_0_net169 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc537 net434 net440 VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_9_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc504 net418 net859 clknet_1_0__leaf_net419 net969 VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__a31oi_2
Xc526 net973 clknet_1_1__leaf_net924 net935 net988 net916 clknet_1_1__leaf_net796
+ VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__mux4_2
XANTENNA_c685_Y net568 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc559 net772 net780 VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__xor2_1
Xc548 net447 net218 net340 net448 net440 net442 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__mux4_2
XFILLER_0_67_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c631_S1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput70 net895 VGND VGND VPWR VPWR out15 sky130_fd_sc_hd__clkbuf_4
XANTENNA_output65_A clknet_1_1__leaf_net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput81 clknet_1_1__leaf_net906 VGND VGND VPWR VPWR out25 sky130_fd_sc_hd__clkbuf_1
Xoutput92 clknet_1_1__leaf_net917 VGND VGND VPWR VPWR out35 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_62_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net558 clknet_0_net558 VGND VGND VPWR VPWR clknet_1_0__leaf_net558
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c208_B1 net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c597_A1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_527 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c763_A3 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_582 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc301 net96 net214 net954 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__mux2_1
Xc312 net764 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_75_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc334 clknet_4_1_0_clk net150 net2 net155 net114 VGND VGND VPWR VPWR net270 net269
+ sky130_fd_sc_hd__sdfrbp_2
Xc323 net745 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__clkbuf_1
Xc345 net248 net83 net265 net267 net278 clknet_1_1__leaf_net266 VGND VGND VPWR VPWR
+ net280 sky130_fd_sc_hd__mux4_4
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc367 clknet_1_0__leaf_net301 net885 net231 net33 net294 net969 VGND VGND VPWR VPWR
+ net302 sky130_fd_sc_hd__mux4_2
Xc356 net271 net161 net231 net800 VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__a31o_4
Xc378 net901 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__clkbuf_1
Xc389 net33 net314 net933 net927 net936 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__a41o_1
XFILLER_0_87_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge811 net747 VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__buf_6
Xmerge800 clknet_1_0__leaf_net507 net895 net508 net505 net479 net768 VGND VGND VPWR
+ VPWR net664 sky130_fd_sc_hd__mux4_2
Xmerge844 net653 net632 VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__xor2_2
Xmerge833 net470 net459 VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__xnor2_1
Xmerge855 clknet_4_4_0_clk net674 net176 VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_23_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge822 net967 net107 net362 net409 net922 net273 VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__mux4_1
XFILLER_0_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge888 net638 net635 VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__xnor2_1
Xs950 net645 clknet_4_15_0_clk VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__dlxtn_1
Xmerge866 clknet_4_11_0_clk net730 net672 VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__dfstp_2
Xmerge877 net681 clknet_4_5_0_clk net673 VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__dlrtn_4
XFILLER_0_82_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge899 clknet_4_7_0_clk net284 net753 VGND VGND VPWR VPWR net934 net763 sky130_fd_sc_hd__dfsbp_2
Xrebuffer3 net979 VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c223_A_N net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c392_A4 net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_19_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net300 clknet_0_net300 VGND VGND VPWR VPWR clknet_1_0__leaf_net300
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c567_A4 net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net355 clknet_0_net355 VGND VGND VPWR VPWR clknet_1_0__leaf_net355
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_80_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c583_A3 net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c727_S0 net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c64_S1 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout145 net918 VGND VGND VPWR VPWR net970 sky130_fd_sc_hd__buf_2
XANTENNA_c104_A2 net849 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_7_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c81_B net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc120 net32 net17 net54 VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__a21o_1
XFILLER_0_33_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c637_S0 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc131 net55 net67 net792 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__a21boi_4
Xc153 net88 net89 net81 net73 net86 net78 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__mux4_2
Xc142 net832 net77 net860 net972 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__a31oi_4
Xc175 net110 net1046 net95 net960 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__a31o_1
Xc164 net88 net92 net97 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__o21a_1
Xc186 net118 net73 net122 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__a21o_2
Xc197 net100 net884 net131 net123 net125 net132 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__mux4_1
XANTENNA_merge894_Q net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_16_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c176_B net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c336_A net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c131_Y net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c594_A2 net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout137_X net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_72_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c457_S0 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c769_A2 net502 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c488_A3 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_6_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_merge800_A1 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c740_S0 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s946_Q net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input27_A in32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c499_A2 net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc91 net22 net997 net873 VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__a21boi_4
Xc80 net15 net10 net847 net881 VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__a31oi_2
XFILLER_0_85_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge857_Q net722 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_output95_A net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_363 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c155_B1_N net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net307 net307 VGND VGND VPWR VPWR clknet_0_net307 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_32_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc708 net559 net965 net1033 net971 net1020 VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__a41oi_1
XANTENNA_c682_SCD net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc719 net455 net594 clknet_1_0__leaf_net603 net544 net899 net786 VGND VGND VPWR VPWR
+ net604 sky130_fd_sc_hd__mux4_2
XANTENNA_c591_A3 net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c737_SCE net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_89_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_1 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_65_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer24 net1002 VGND VGND VPWR VPWR net1001 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer35 net47 VGND VGND VPWR VPWR net1012 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer46 net1042 VGND VGND VPWR VPWR net1043 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer13 net926 VGND VGND VPWR VPWR net990 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c586_A3 net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc505 net742 VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__inv_4
Xc527 net366 net294 net933 net951 clknet_1_0__leaf_net929 clknet_1_1__leaf_net796
+ VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__mux4_1
Xc549 net446 net448 net434 net829 net734 net771 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__mux4_1
Xc538 net440 net771 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__xor2_1
XFILLER_0_99_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_14_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput71 net896 VGND VGND VPWR VPWR out16 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c375_S0 net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput82 net907 VGND VGND VPWR VPWR out26 sky130_fd_sc_hd__buf_2
Xoutput93 net918 VGND VGND VPWR VPWR out37 sky130_fd_sc_hd__buf_2
XFILLER_0_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc302 net232 net234 net224 net228 net93 net915 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_75_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc335 net156 net975 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__xor2_4
XFILLER_0_20_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc324 net251 net257 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__xnor2_2
Xc313 net202 net109 net247 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__o21bai_1
Xc368 net719 VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__buf_4
Xc379 net68 net309 clknet_1_1__leaf_net199 net773 clknet_1_0__leaf_net900 VGND VGND
+ VPWR VPWR net313 sky130_fd_sc_hd__a41o_2
Xc357 net875 net991 net278 VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__o21a_1
Xc346 net277 net1034 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__xnor2_2
XANTENNA_c195_S0 net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c134_B1 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_86_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge801 net947 net406 net155 net19 net806 VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__a41o_1
Xmerge812 net359 net92 net350 net945 net949 net778 VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__mux4_4
XFILLER_0_82_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge834 net554 net557 VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__xnor2_2
Xmerge845 net585 net573 VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__xnor2_2
Xmerge823 net461 net579 net962 net343 net358 net362 VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__mux4_1
Xs951 net648 clknet_4_15_0_clk VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__dlxtp_1
XANTENNA_c707_CLK_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs940 clknet_4_13_0_clk net537 VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__dfxtp_1
Xmerge878 net657 clknet_4_10_0_clk net466 VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__dlrtp_2
Xmerge867 clknet_4_5_0_clk net714 net692 VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__dfstp_2
Xmerge856 net433 net532 VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__xor2_1
Xmerge889 clknet_4_2_0_clk net252 net705 VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__sdlclkp_4
XTAP_TAPCELL_ROW_11_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer4 net980 VGND VGND VPWR VPWR net981 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c698_A1 net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c210_A2 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net301 clknet_0_net301 VGND VGND VPWR VPWR clknet_1_0__leaf_net301
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net367 clknet_0_net367 VGND VGND VPWR VPWR clknet_1_0__leaf_net367
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net356 clknet_0_net356 VGND VGND VPWR VPWR clknet_1_0__leaf_net356
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c219_B1 net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_306 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout127_A net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c583_A4 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c727_S1 net823 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c483_A net747 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout146 net113 VGND VGND VPWR VPWR net971 sky130_fd_sc_hd__buf_4
Xfanout135 net108 VGND VGND VPWR VPWR net960 sky130_fd_sc_hd__buf_4
XANTENNA_input1_A in0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c376_Y net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_net900_X clknet_0_net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net890 clknet_0_net890 VGND VGND VPWR VPWR clknet_1_0__leaf_net890
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_53_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc110 net998 net42 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__nor2b_1
XFILLER_0_33_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc121 net849 net55 net56 net48 net1013 net968 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__mux4_1
Xc154 net835 net88 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__and2b_1
Xc143 net871 net836 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__nand2b_2
Xc132 net836 net829 net832 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__o21a_4
XANTENNA_c637_S1 clknet_1_1__leaf_net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc176 net845 net875 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__nand2_2
Xc187 net879 net122 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__and2_1
Xc165 net72 net974 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__or2b_2
XANTENNA_input57_A in6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc198 net9 net110 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__and2_1
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input12_X net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_4_2_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_22_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c457_S1 net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input4_X net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c769_A3 net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c367_S1 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c383_S0 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge917_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c232_A0 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s926_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s939_Q net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c401_X net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c468_S0 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c142_B1 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c499_A3 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc81 net834 net2 VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__nor2_2
Xc70 net864 net1 VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__nor2b_4
Xc92 net872 net27 net26 net877 net29 net28 VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__mux4_2
XFILLER_0_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net308 net308 VGND VGND VPWR VPWR clknet_0_net308 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc709 clknet_4_10_0_clk net553 net471 net957 net953 net896 VGND VGND VPWR VPWR net594
+ net593 sky130_fd_sc_hd__sdfbbn_2
XANTENNA_c682_SCE net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c735_S1 net823 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_10_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c737_SET_B net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c600_B1 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge883_DE net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_81_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c692_A3 net471 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer25 net1003 VGND VGND VPWR VPWR net1002 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer36 net47 VGND VGND VPWR VPWR net1013 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer14 net990 VGND VGND VPWR VPWR net991 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c571_S0 net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer47 net42 VGND VGND VPWR VPWR net1044 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c586_A4 net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c204_Y net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc528 net959 net329 VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_9_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c107_A3 net38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge822_A0 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc539 net438 net955 VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__xor2_1
XANTENNA_c573_Y net476 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c566_X net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc484_1 clknet_1_1__leaf_net917 VGND VGND VPWR VPWR net977 sky130_fd_sc_hd__clkinv_4
XFILLER_0_94_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput94 net919 VGND VGND VPWR VPWR out38 sky130_fd_sc_hd__clkbuf_4
Xoutput72 net897 VGND VGND VPWR VPWR out17 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput83 net908 VGND VGND VPWR VPWR out27 sky130_fd_sc_hd__buf_2
XFILLER_0_37_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net538 clknet_0_net538 VGND VGND VPWR VPWR clknet_1_0__leaf_net538
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_53_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_70_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c208_A2 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge908_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge817_A0 net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c118_A2 net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc303 net112 net210 net234 net94 net235 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__a41oi_1
XFILLER_0_32_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc336 net83 net269 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__xor2_2
XFILLER_0_32_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc325 net258 net250 net256 net128 net123 net259 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__mux4_1
Xc314 net742 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__inv_4
XANTENNA_c415_A0 net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc347 net1035 net281 net150 net954 net278 net1022 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__mux4_1
Xc358 net278 clknet_1_0__leaf_net924 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__xnor2_2
Xc369 net295 net296 clknet_1_1__leaf_net302 net303 net969 VGND VGND VPWR VPWR net304
+ sky130_fd_sc_hd__a41oi_4
XFILLER_0_99_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c150_B1 net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_86_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge802 net56 net866 net55 net1027 VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__a31oi_1
XFILLER_0_23_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge813 net464 net471 net445 net86 net444 net780 VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__mux4_1
Xmerge846 net127 net658 VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__xor2_1
XFILLER_0_28_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge824 net93 clknet_1_0__leaf_net368 net364 net443 net444 net446 VGND VGND VPWR
+ VPWR net688 sky130_fd_sc_hd__mux4_1
Xmerge835 net526 net530 VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__xnor2_2
Xs941 clknet_4_10_0_clk net563 VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__dfxtp_4
Xmerge868 net539 net652 VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__xor2_1
Xmerge857 clknet_4_0_0_clk net151 net710 VGND VGND VPWR VPWR net722 net721 sky130_fd_sc_hd__dfsbp_2
Xs930 net260 clknet_4_3_0_clk VGND VGND VPWR VPWR net800 net799 sky130_fd_sc_hd__dlxbn_2
Xmerge879 net686 clknet_4_12_0_clk net688 VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__dlrtp_2
XFILLER_0_55_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer5 net979 VGND VGND VPWR VPWR net982 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output70_A net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap125_X net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c698_A2 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net302 clknet_0_net302 VGND VGND VPWR VPWR clknet_1_0__leaf_net302
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net379 clknet_0_net379 VGND VGND VPWR VPWR clknet_1_0__leaf_net379
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net368 clknet_0_net368 VGND VGND VPWR VPWR clknet_1_0__leaf_net368
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_80_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge803_A2 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout147 net70 VGND VGND VPWR VPWR net972 sky130_fd_sc_hd__clkbuf_8
Xfanout136 net108 VGND VGND VPWR VPWR net961 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c271_Y net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c703_Y net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c129_A1 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc111 net17 net6 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__nor2_2
Xc100 net850 net984 VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__nor2_4
Xc122 net767 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__buf_6
Xc133 net835 net827 net837 net885 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__a31o_2
Xc144 net838 net76 net73 net973 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__a31o_4
Xc155 net841 net858 net974 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__a21boi_4
Xc166 net97 net833 net96 net848 net102 net975 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__mux4_1
Xc177 net111 net992 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__or2b_4
Xc199 net14 net0 net13 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__o21ai_1
Xc188 net884 net87 net119 net117 net110 net833 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__mux4_2
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c311_A2 net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge814_A1 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_72_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c709_RESET_B net471 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c754_S0 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c412_A1 net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_446 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_94_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c306_A2 net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c679_A4 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c446_B net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c341_A net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout142_X net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c749_S0 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c86_S1 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c423_B1 net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c142_A1 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc93 net877 net968 VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__nor2b_1
Xc82 net886 net18 net881 net5 VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__a31o_2
Xc71 net837 net866 net4 net864 net974 VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__a41o_1
XFILLER_0_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c420_Q net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c317_A1 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge912_Q net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c394_S0 net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c291_A net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c184_Y net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c177_X net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c556_A net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s951_Q net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold50 net791 VGND VGND VPWR VPWR net1027 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input32_A in37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_11_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c600_A1 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output119_A net944 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c692_A4 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_20_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer15 net3 VGND VGND VPWR VPWR net992 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer26 net1004 VGND VGND VPWR VPWR net1003 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net494 clknet_0_net494 VGND VGND VPWR VPWR clknet_1_1__leaf_net494
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_65_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer37 net27 VGND VGND VPWR VPWR net1014 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge822_A1 net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc529 net731 VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__clkinv_4
XTAP_TAPCELL_ROW_9_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c673_A net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c762_S0 net823 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c97_B net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput73 net949 VGND VGND VPWR VPWR out18 sky130_fd_sc_hd__clkbuf_4
Xoutput84 net909 VGND VGND VPWR VPWR out28 sky130_fd_sc_hd__buf_2
Xoutput95 net920 VGND VGND VPWR VPWR out39 sky130_fd_sc_hd__buf_2
XANTENNA_c611_B1 net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c334_SCE net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_70_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_hold40_A net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c414_CLK_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge817_A1 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc315 net244 net122 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__xnor2_1
Xc304 net235 net203 net781 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__a21o_1
Xc326 net947 net123 net259 net246 net741 net783 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__mux4_1
Xc337 net114 net25 net128 net156 net272 net271 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__mux4_2
Xc359 clknet_4_4_0_clk net147 clknet_1_1__leaf_net292 net140 net794 clknet_1_1__leaf_net900
+ VGND VGND VPWR VPWR net294 net293 sky130_fd_sc_hd__sdfbbn_2
Xc348 net279 net20 net272 net267 net278 net925 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__mux4_2
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c150_A1 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge803 net170 net25 net166 net737 VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__a31oi_1
XFILLER_0_95_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge825 net614 net615 VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__xor2_4
Xmerge814 net994 net952 net114 net236 net950 net107 VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__mux4_1
XFILLER_0_23_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c333_Q net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge836 net237 net230 VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__xor2_1
XFILLER_0_55_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs942 clknet_4_10_0_clk net586 VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__dlclkp_1
Xmerge869 clknet_4_9_0_clk net387 net609 VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__dfstp_2
Xmerge847 net665 net679 VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__xnor2_1
Xmerge858 net324 net323 VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__xnor2_4
XFILLER_0_48_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs931 net338 clknet_4_8_0_clk VGND VGND VPWR VPWR net802 net801 sky130_fd_sc_hd__dlxbp_1
XFILLER_0_55_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer6 net15 VGND VGND VPWR VPWR net983 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output63_A net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c698_A3 net544 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c219_A2 net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout126 net895 VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__buf_4
Xfanout137 net105 VGND VGND VPWR VPWR net962 sky130_fd_sc_hd__buf_4
XANTENNA_clkbuf_1_1__f_net900_A clknet_0_net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout148 net831 VGND VGND VPWR VPWR net973 sky130_fd_sc_hd__clkbuf_8
XANTENNA_clkbuf_1_1__f_net890_X clknet_1_1__leaf_net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net892 clknet_0_net892 VGND VGND VPWR VPWR clknet_1_0__leaf_net892
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c129_A2 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c426_B1 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc101 net36 net975 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__or2_1
Xc112 net48 net973 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__or2b_2
Xc123 net57 net54 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__nand2_1
Xc145 net75 net80 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__and2_1
Xc134 net860 net838 net886 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__o21a_4
XFILLER_0_60_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc178 net883 net837 net114 net110 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__a31o_1
Xc156 net84 net855 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__or2b_2
Xc167 net855 net93 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__nor2_1
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc189 net123 net122 net125 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__a21boi_1
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc690 clknet_1_1__leaf_net567 net569 net786 VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__mux2_8
XANTENNA_s949_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_3_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c502_A2 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net199 clknet_0_net199 VGND VGND VPWR VPWR clknet_1_0__leaf_net199
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c224_B net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout132_A net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge814_A2 net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_58_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_67_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input62_A in9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_76_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c232_A2 net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c227_Y net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout135_X net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c749_S1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c126_A3 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c765_S0 net944 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c423_A1 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c142_A2 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc83 net16 net19 net5 net868 net13 net15 VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__mux4_2
Xc94 net856 net849 VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__and2_1
Xc72 net839 net858 VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__nor2_1
XFILLER_0_85_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge796_S1 net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c297_RESET_B net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c614_B1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net643 clknet_0_net643 VGND VGND VPWR VPWR clknet_1_1__leaf_net643
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c496_B1_N net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c556_B net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c337_X net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c106_S net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold40 net794 VGND VGND VPWR VPWR net1017 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 net480 VGND VGND VPWR VPWR net1028 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input25_A in30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output93_A net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer27 net1005 VGND VGND VPWR VPWR net1004 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer16 net992 VGND VGND VPWR VPWR net993 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_65_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer38 net1014 VGND VGND VPWR VPWR net1015 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge806_A3 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c294_Y net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c148_A1 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c661_B1_N net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput63 net888 VGND VGND VPWR VPWR out0 sky130_fd_sc_hd__clkbuf_4
Xoutput74 net899 VGND VGND VPWR VPWR out19 sky130_fd_sc_hd__clkbuf_4
Xoutput85 net910 VGND VGND VPWR VPWR out29 sky130_fd_sc_hd__clkbuf_1
Xoutput96 clknet_1_1__leaf_net921 VGND VGND VPWR VPWR out4 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input28_X net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c672_S1 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net507 clknet_0_net507 VGND VGND VPWR VPWR clknet_1_0__leaf_net507
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c112_B_N net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_1_0__f_net900_A clknet_0_net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
.ends
