* NGSPICE file created from netlist_0.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_4 abstract view
.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_4 abstract view
.subckt sky130_fd_sc_hd__a32o_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_4 abstract view
.subckt sky130_fd_sc_hd__dlrtp_4 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_4 abstract view
.subckt sky130_fd_sc_hd__and2b_4 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_4 abstract view
.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_4 abstract view
.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_2 abstract view
.subckt sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_2 abstract view
.subckt sky130_fd_sc_hd__o32a_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfsbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfsbp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_4 abstract view
.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxbp_1 abstract view
.subckt sky130_fd_sc_hd__edfxbp_1 CLK D DE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_2 abstract view
.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_2 abstract view
.subckt sky130_fd_sc_hd__o22a_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxtp_1 abstract view
.subckt sky130_fd_sc_hd__edfxtp_1 CLK D DE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_4 abstract view
.subckt sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_4 abstract view
.subckt sky130_fd_sc_hd__mux4_4 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_4 abstract view
.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_2 abstract view
.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_2 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_1 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbp_1 CLK D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q
+ Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32ai_1 abstract view
.subckt sky130_fd_sc_hd__o32ai_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_4 abstract view
.subckt sky130_fd_sc_hd__o32a_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_1 abstract view
.subckt sky130_fd_sc_hd__dfsbp_1 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfbbn_1 abstract view
.subckt sky130_fd_sc_hd__dfbbn_1 CLK_N D RESET_B SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_2 abstract view
.subckt sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_4 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32ai_4 abstract view
.subckt sky130_fd_sc_hd__o32ai_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_2 abstract view
.subckt sky130_fd_sc_hd__dfrbp_2 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_1 abstract view
.subckt sky130_fd_sc_hd__dlrbn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_4 abstract view
.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32ai_2 abstract view
.subckt sky130_fd_sc_hd__o32ai_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_2 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_2 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_1 abstract view
.subckt sky130_fd_sc_hd__dlxbn_1 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_0 abstract view
.subckt sky130_fd_sc_hd__and2_0 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_2 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtn_1 abstract view
.subckt sky130_fd_sc_hd__dfrtn_1 CLK_N D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbp_1 abstract view
.subckt sky130_fd_sc_hd__dlrbp_1 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__lpflow_inputisolatch_1 abstract view
.subckt sky130_fd_sc_hd__lpflow_inputisolatch_1 D SLEEP_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbp_1 abstract view
.subckt sky130_fd_sc_hd__dlxbp_1 D GATE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_1 abstract view
.subckt sky130_fd_sc_hd__dlclkp_1 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_1 abstract view
.subckt sky130_fd_sc_hd__dlxtn_1 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_1 abstract view
.subckt sky130_fd_sc_hd__dfxbp_1 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_4 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_4 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_2 abstract view
.subckt sky130_fd_sc_hd__dlclkp_2 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_1 abstract view
.subckt sky130_fd_sc_hd__dlrtn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_2 abstract view
.subckt sky130_fd_sc_hd__dlxtn_2 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_4 abstract view
.subckt sky130_fd_sc_hd__dlclkp_4 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtp_1 abstract view
.subckt sky130_fd_sc_hd__dlxtp_1 D GATE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfrbp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_4 abstract view
.subckt sky130_fd_sc_hd__o21ba_4 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_4 abstract view
.subckt sky130_fd_sc_hd__o22a_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_2 abstract view
.subckt sky130_fd_sc_hd__dlrtn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_1 abstract view
.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_1 abstract view
.subckt sky130_fd_sc_hd__dlrtp_1 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtn_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtn_1 CLK_N D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_2 abstract view
.subckt sky130_fd_sc_hd__dlrtp_2 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

.subckt netlist_0 VGND VPWR clk in0 in1 in10 in11 in12 in13 in14 in15 in16 in17 in18
+ in19 in2 in20 in21 in22 in23 in24 in25 in26 in27 in28 in29 in3 in30 in31 in32 in33
+ in34 in35 in36 in37 in38 in39 in4 in40 in41 in42 in43 in44 in45 in46 in47 in48 in49
+ in5 in50 in51 in52 in53 in54 in55 in56 in57 in58 in59 in6 in60 in61 in7 in8 in9
+ out0 out1 out10 out11 out12 out13 out14 out15 out16 out17 out18 out19 out2 out20
+ out21 out22 out23 out24 out25 out26 out27 out28 out29 out3 out30 out31 out32 out33
+ out34 out35 out36 out37 out38 out39 out4 out40 out41 out42 out43 out44 out45 out46
+ out47 out48 out49 out5 out50 out51 out52 out53 out54 out55 out56 out57 out58 out59
+ out6 out60 out61 out7 out8 out9 rst
XFILLER_0_94_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c366_D net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c421_B net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c684_B1_N net834 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc305 net197 net208 net218 net896 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__o22ai_4
XANTENNA_s885_GATE clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc327 net109 net230 net238 net815 net228 VGND VGND VPWR VPWR net855 sky130_fd_sc_hd__a32o_4
Xc316 net203 net228 net816 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__a21o_1
XFILLER_0_60_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc338 net249 net853 net137 net245 net895 net678 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__mux4_2
Xc349 net254 net262 net907 net96 net258 net895 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__mux4_1
XANTENNA_c431_A1 net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c492_S1 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c92_B1_N net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge804 net223 clknet_4_5_0_clk net220 VGND VGND VPWR VPWR net834 sky130_fd_sc_hd__dlrtp_4
XFILLER_0_55_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net493 net493 VGND VGND VPWR VPWR clknet_0_net493 sky130_fd_sc_hd__clkbuf_16
Xrebuffer7 net900 VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c606_A1 net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c683_S0 net411 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c622_A0 net419 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c341_B2 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net736_X clknet_1_0__leaf_net736 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout138 net826 VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__buf_4
Xfanout127 net106 VGND VGND VPWR VPWR net893 sky130_fd_sc_hd__buf_4
XANTENNA_c135_A_N net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c152_X net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s857_Q net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c707_A0 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc102 net32 net28 VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__and2b_1
XANTENNA_c426_B2 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc135 net772 net778 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__and2b_4
Xc113 net827 net29 net905 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__a21boi_4
Xc124 net51 net48 net863 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__o21ba_1
Xc146 net812 net70 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__or2b_4
Xc157 net804 net74 net66 net795 net907 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__a32o_2
Xc168 net90 net70 net909 net95 net785 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__o32a_2
Xc179 net820 net105 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__or2b_1
XANTENNA_c442_B1 net646 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c161_B2 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_A0 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s882_GATE_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge774_Q_N net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc680 net764 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__buf_4
Xc691 clknet_4_14_0_clk net216 net768 net888 net899 VGND VGND VPWR VPWR net549 net548
+ sky130_fd_sc_hd__sdfsbp_1
XFILLER_0_75_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c502_A3 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c534_X net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c437_A0 net332 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c72_B net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c498_S0 net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c172_B1 net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input55_A in58 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input10_X net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c347_B1 net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_71_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c167_B net897 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c257_B1 net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout128_X net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c704_A1 net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input2_X net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c720_A0 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc73 net789 net864 net818 VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__o21bai_4
Xc62 net808 net786 net810 net824 net2 net818 VGND VGND VPWR VPWR net0 sky130_fd_sc_hd__mux4_2
Xc84 net843 net1 net13 net0 net806 VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__o32a_2
Xc95 net15 net4 VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_26_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c68_X net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input58_X net824 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c630_A0 net444 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge800_Q net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net600 clknet_0_net600 VGND VGND VPWR VPWR clknet_1_1__leaf_net600
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c259_CLK_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c715_A0 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c450_B1 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold30 net251 VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input18_A in24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c600_A3 net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c328_A2 net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c344_A1 net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output86_A net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c360_B1 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer17 net74 VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_65_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net485 clknet_0_net485 VGND VGND VPWR VPWR clknet_1_1__leaf_net485
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c596_S0 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c666_B net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c429_B2 net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c500_SCD net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c445_B1 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c164_B2 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput75 net841 VGND VGND VPWR VPWR out25 sky130_fd_sc_hd__buf_2
Xoutput64 net830 VGND VGND VPWR VPWR out10 sky130_fd_sc_hd__buf_2
Xoutput97 net863 VGND VGND VPWR VPWR out5 sky130_fd_sc_hd__buf_2
Xoutput86 net852 VGND VGND VPWR VPWR out37 sky130_fd_sc_hd__buf_2
XANTENNA_c611_A2 net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c339_A1 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s842_D net505 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c71_S net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c355_B1 net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c505_A3 net288 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c240_A3 net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c359_D net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_8_0_clk_X clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc317 net84 net218 net224 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__a21oi_2
Xc306 net87 net221 net211 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__a21oi_2
Xc328 net236 net954 net241 net855 net234 net907 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__mux4_1
XFILLER_0_13_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc339 net224 net227 net252 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__mux2_1
XANTENNA_c397_X net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c712_A1 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge805 clknet_4_5_0_clk net243 net643 VGND VGND VPWR VPWR net673 net672 sky130_fd_sc_hd__edfxbp_1
XFILLER_0_55_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer8 net916 VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_63_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c606_A2 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c175_B1 net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_rebuffer13_X net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c325_A3 net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c683_S1 net680 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c622_A1 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input40_X net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout128 net102 VGND VGND VPWR VPWR net894 sky130_fd_sc_hd__buf_4
Xfanout139 net802 VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_89_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c145_X net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c703_SCD net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc136 net768 net61 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__and2b_2
XFILLER_0_13_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc103 net25 net14 net904 VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__a21bo_2
Xc114 net43 net25 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__and2b_1
Xc125 net671 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c723_A0 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc147 net75 net72 net823 net61 net812 net63 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__mux4_2
Xc169 net87 net93 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__and2b_1
XFILLER_0_13_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc158 net783 net786 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__nor2b_2
XFILLER_0_68_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c633_A0 net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc670 net665 VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__buf_1
Xc681 net534 net414 net533 net531 net532 net666 VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__mux4_1
XANTENNA_c352_A1 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc692 net912 net890 net518 net305 net308 net898 VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__mux4_2
XFILLER_0_75_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c246_A2 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c718_A0 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c498_S1 net847 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c71_A0 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c172_B2 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input48_A in51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c603_A3 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c347_A1 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s856_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c363_B1 net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c257_B2 net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c273_B1 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c704_A2 net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c477_X net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c720_A1 net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc63 net817 net821 net806 net816 net824 net818 VGND VGND VPWR VPWR net836 sky130_fd_sc_hd__mux4_2
Xc85 net15 net785 net17 net905 VGND VGND VPWR VPWR net856 sky130_fd_sc_hd__o22a_2
Xc74 net864 net820 net6 VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__mux2_1
XFILLER_0_97_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc96 net779 net26 VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_26_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c183_B1 net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c614_A2 net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c630_A1 net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_88_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c358_B1 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s829_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c540_A1 net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_9_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout140_X net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c715_A1 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c434_A2 net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_A0 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold31 net726 VGND VGND VPWR VPWR net940 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c450_A1 net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c609_A2 net795 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c178_B1 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c328_A3 net855 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c625_A1 net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output79_A net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer18 net928 VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_88_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c596_S1 net690 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_4_0_clk_X clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c175_X net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c429_A2 net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c63_A1 net821 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c726_A0 net540 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c164_A2 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput65 net831 VGND VGND VPWR VPWR out11 sky130_fd_sc_hd__clkbuf_4
Xoutput76 net842 VGND VGND VPWR VPWR out26 sky130_fd_sc_hd__buf_2
XANTENNA_c461_A0 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c180_A1 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput98 net864 VGND VGND VPWR VPWR out50 sky130_fd_sc_hd__buf_2
Xoutput87 net853 VGND VGND VPWR VPWR out38 sky130_fd_sc_hd__buf_2
XANTENNA_input30_A in35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c611_A3 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c697_S0 net540 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c355_A1 net115 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_99_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc307 net202 net860 net216 net219 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_13_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc318 net110 net198 net233 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__o21bai_4
Xc329 net242 net1 net237 net234 net209 net225 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__mux4_1
XFILLER_0_13_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c712_A2 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c564_Y net444 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge806 clknet_4_2_0_clk net403 net183 VGND VGND VPWR VPWR net674 sky130_fd_sc_hd__edfxtp_1
XANTENNA_c486_RESET_B net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c95_B net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c74_A0 net864 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c88_A net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c456_B1 net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net462 net462 VGND VGND VPWR VPWR clknet_0_net462 sky130_fd_sc_hd__clkbuf_16
Xrebuffer9 net900 VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c175_A1 net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c175_B2 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c191_B1 net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input33_X net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout129 net18 VGND VGND VPWR VPWR net895 sky130_fd_sc_hd__buf_4
XFILLER_0_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c276_B1 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c707_A2 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c703_CLK_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc104 net34 net33 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__nand2b_1
Xc126 net39 net635 net50 net818 net863 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__a32o_1
Xc115 net33 net841 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__and2b_1
XFILLER_0_20_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc137 net64 net62 VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__or2_4
Xc148 net69 net778 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__nor2b_4
Xc159 net907 net85 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__nand2_2
XANTENNA_c442_A2 net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c617_A2 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_12_0_clk_X clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c633_A1 net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc682 net628 VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__clkbuf_1
Xc671 net520 net517 net301 VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__a21boi_1
Xc660 net777 net305 net411 VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__o21a_1
XANTENNA_c352_A2 net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc693 net541 net447 net331 VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__o21ba_1
XANTENNA_max_cap116_X net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c262_A2 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge792_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c422_X net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c718_A1 net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net681 clknet_0_net681 VGND VGND VPWR VPWR clknet_1_0__leaf_net681
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_36_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c734_A0 net452 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c71_A1 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c172_A2 net788 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_45_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c347_A2 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_54_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c363_B2 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc490 net821 net867 net885 net906 clknet_1_0__leaf_net681 net692 VGND VGND VPWR VPWR
+ net396 sky130_fd_sc_hd__mux4_4
XPHY_EDGE_ROW_63_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c160_B_N net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_82_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c704_A3 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c720_A2 net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc75 net815 net906 VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__or2_2
Xc64 net803 net819 net800 net815 net816 net820 VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__mux4_2
Xc97 net26 net782 VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__and2b_1
Xc86 net6 net12 net15 net815 net19 net828 VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__mux4_2
XANTENNA_c637_X net515 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_26_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c729_A0 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_90_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c448_A1 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c82_B1 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c70_A net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c464_B1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input60_A in7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c183_A1 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c614_A3 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c630_A2 net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge776_B1 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c194_B1_N net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c358_B2 net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c540_A2 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c133_B_N net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c218_X net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c284_B1 net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c715_A2 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c450_A2 net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold32 net259 VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c77_B1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c178_A1 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c609_A3 net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c625_A2 net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer19 net321 VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_88_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c535_A2 net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_77_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c282_A net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c554_B net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c429_A3 net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net600 net600 VGND VGND VPWR VPWR clknet_0_net600 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c726_A1 net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c63_A2 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c164_A3 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c742_A0 net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput66 net832 VGND VGND VPWR VPWR out13 sky130_fd_sc_hd__buf_2
XANTENNA_c482_RESET_B net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c461_A1 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput77 net843 VGND VGND VPWR VPWR out28 sky130_fd_sc_hd__buf_2
Xoutput99 net865 VGND VGND VPWR VPWR out51 sky130_fd_sc_hd__buf_2
Xoutput88 net854 VGND VGND VPWR VPWR out4 sky130_fd_sc_hd__buf_2
XANTENNA_c156_A_N net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input23_A in29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c636_A1 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_42_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c355_A2 net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output91_A net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c350_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c135_B net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc308 net821 net652 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__nor2_1
Xc319 net219 net232 net652 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__o21ba_1
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c712_A3 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c452_X net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c74_A1 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c737_A0 net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c88_B net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net485 net485 VGND VGND VPWR VPWR clknet_0_net485 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c472_B1 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c191_A1 net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c622_A3 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c191_B2 net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input26_X net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge768_A1 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_hold31_A net726 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout119 net835 VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__buf_4
XFILLER_0_10_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c276_A1 net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c707_A3 net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc116 net28 net42 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__and2b_1
Xc127 net54 net25 net856 net43 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__a22oi_2
Xc105 net773 net817 net32 VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__o21bai_4
XTAP_TAPCELL_ROW_96_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc138 net823 net775 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__or2_4
Xc149 net70 net812 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__nand2b_4
XANTENNA_c723_A2 net566 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_A3 net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc672 net524 net520 VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__or2_2
Xc661 net812 net305 VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__and2b_2
XANTENNA_c352_A3 net821 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc683 net538 net926 net788 net217 net411 net680 VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__mux4_1
Xc694 net334 net540 net420 net446 net542 VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__o32a_1
XANTENNA_merge779_A0 net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c420_B1_N net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c150_X net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c718_A2 net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net682 clknet_0_net682 VGND VGND VPWR VPWR clknet_1_0__leaf_net682
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c437_A3 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c734_A1 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c285_A2_N net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c750_A0 net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_100_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c628_A2 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c660_B1 net411 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc491 net824 clknet_1_0__leaf_net396 net852 net906 net889 net834 VGND VGND VPWR VPWR
+ net397 sky130_fd_sc_hd__mux4_2
Xc480 net787 net356 net364 net881 net879 net648 VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__mux4_2
XFILLER_0_87_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c273_A2 net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c570_B1 net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c198_X net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc65 net785 net789 net774 net782 net798 VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__a32o_4
Xc76 net6 net776 VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__or2_4
XANTENNA_c365_X net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc98 net829 net28 VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__or2b_2
Xc87 net4 net11 net856 net866 net15 VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__a32o_2
XFILLER_0_97_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c729_A1 net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c448_A2 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_34_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c745_A0 net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c82_B2 net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c70_B net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c464_A1 net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c464_B2 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c183_A2 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c480_A0 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input53_A in56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c630_A3 net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c358_A2 net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c165_B net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c158_A net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout126_X net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c284_A1 net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c284_B2 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s818_Q net690 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c333_SET_B net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_A2 net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold22 net241 VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 net760 VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c459_A1 net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c178_A2 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c73_Y net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c194_A1 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c625_A3 net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c66_X net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input56_X net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c504_S0 net647 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c551_A2 net411 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c726_A2 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c63_A3 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput67 net833 VGND VGND VPWR VPWR out14 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput89 net855 VGND VGND VPWR VPWR out41 sky130_fd_sc_hd__buf_2
Xoutput78 net844 VGND VGND VPWR VPWR out29 sky130_fd_sc_hd__buf_2
XFILLER_0_98_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input16_A in22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_587 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge773_A2 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c636_A2 net893 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_42_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c281_B_N net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c355_A3 net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c546_A2 net423 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc309 net768 net219 net221 net779 net776 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__a32o_2
XFILLER_0_25_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c562_B2 net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c664_B net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input8_A in15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge766_SCD net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c278_X net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c456_A2 net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c90_A1 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c753_A0 net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c472_A1 net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c472_B2 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c191_A2 net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge768_A2 net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input19_X net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold24_A net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_85_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc106 net35 net29 net811 net32 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__o2bb2a_2
Xc117 net12 net22 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_96_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc128 net14 net3 net43 net46 net863 VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__a32o_1
Xc139 net63 net780 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__or2b_4
XANTENNA_c723_A3 net531 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c85_B2 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c467_A1 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge770_A3 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_560 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc673 net414 net528 VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__and2_1
Xc662 net201 net902 VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__and2b_1
Xc684 net434 net888 net834 VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__a21bo_1
Xc695 net899 net531 net655 VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__mux2_1
XANTENNA_merge779_A1 net411 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s859_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net683 clknet_0_net683 VGND VGND VPWR VPWR clknet_1_0__leaf_net683
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c734_A2 net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c750_A1 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c478_B1 net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c332_S0 net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c628_A3 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c197_A1 net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c660_A1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc481 net368 net382 net326 net384 net381 net686 VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__mux4_1
Xc470 net69 net367 net318 net199 net852 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__a32o_1
Xc492 net354 net390 net846 net391 net150 net895 VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__mux4_1
XANTENNA_c367_SCE net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c208_B net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c273_A3 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c256_CLK_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c570_B2 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc66 net787 net810 VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__and2_2
XFILLER_0_97_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc99 net635 net12 VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__nor2_1
Xc88 net778 net895 VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__and2_1
Xc77 net801 net0 net905 net10 VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_97_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c358_X net277 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A2 net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net480 clknet_0_net480 VGND VGND VPWR VPWR clknet_1_0__leaf_net480
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_34_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c745_A1 net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c82_A2 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c761_A0 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c480_A1 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input46_A in5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c358_A3 net24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c661_A_N net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c404_A_N net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c284_A2 net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout119_X net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_A3 net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold23 net447 VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c147_S0 net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c369_RESET_B net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold34 net248 VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c459_A2 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c756_A0 net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c610_S0 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c194_A2 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c491_A0 net824 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input49_X net815 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net478 clknet_0_net478 VGND VGND VPWR VPWR clknet_1_1__leaf_net478
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_9_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c268_A net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_69_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c726_A3 net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c742_A2 net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c461_A3 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput68 net834 VGND VGND VPWR VPWR out17 sky130_fd_sc_hd__buf_2
Xoutput79 net845 VGND VGND VPWR VPWR out3 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_98_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c605_S0 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c189_A2 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c636_A3 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output77_A net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c546_A3 net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c562_A2 net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c463_A2_N net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge766_SCE net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c151_B1_N net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c753_A1 net61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c472_A2 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge768_A3 net823 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c663_A1 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_85_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c557_A2 net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c133_A net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc118 net47 net780 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__nand2b_1
XFILLER_0_5_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc107 net30 net34 VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_96_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc129 clknet_4_0_0_clk net53 net43 net866 net841 net863 VGND VGND VPWR VPWR net870
+ net58 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_95_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c555_X net435 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c85_A2 net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c748_A1 net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c467_A2 net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c764_A0 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc630 net444 net451 net195 net144 net75 net24 VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__mux4_1
XFILLER_0_32_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc663 net790 net201 net428 VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__a21boi_1
Xc674 net665 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__clkbuf_1
Xc685 net627 VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__inv_2
Xc696 net420 net331 net536 net433 net526 net332 VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__mux4_1
XANTENNA_input31_X net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c143_Y net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c734_A3 net680 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c672_X net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c759_A0 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_14_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c478_B2 net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c332_S1 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c197_A2 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c494_A0 net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge781_A3 net328 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_23_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c660_A2 net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc482 clknet_4_3_0_clk net383 net199 net370 net384 net690 VGND VGND VPWR VPWR net387
+ net386 sky130_fd_sc_hd__sdfbbp_1
Xc471 net306 net781 net69 net879 net371 VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__o32a_1
Xc460 net72 net350 net90 net239 net357 clknet_1_0__leaf_net682 VGND VGND VPWR VPWR
+ net360 sky130_fd_sc_hd__mux4_1
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc493 net795 net830 net828 net889 net687 VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__o32a_1
XANTENNA_c669_B1 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_32_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_82_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_41_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c570_A2 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c298_A net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc67 net807 net2 VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__nor2b_2
XPHY_EDGE_ROW_50_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc89 net772 net9 VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__nor2_1
Xc78 net804 net12 VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_26_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A3 net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c82_A3 net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c464_A3 net891 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c761_A1 net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c480_A2 net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c608_S0 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input39_A in43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_A0 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc290 net780 net203 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__nor2_2
XFILLER_0_41_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_5_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c284_A3 net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c147_S1 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c108_B1_N net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold35 net180 VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 net733 VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c459_A3 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c756_A1 net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c610_S1 net635 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c338_S0 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c398_A_N net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c248_S0 net863 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c268_B net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c500_SET_B net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c711_S0 net536 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput69 net835 VGND VGND VPWR VPWR out18 sky130_fd_sc_hd__buf_2
XFILLER_0_98_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c189_A3 net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c621_S0 net893 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input61_X net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_6_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c573_B1_N net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s813_GCLK net682 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c737_A3 net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c753_A2 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c469_SET_B net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c472_A3 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c616_S0 net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input21_A in27 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_13_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c663_A2 net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_97_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c319_B1_N net652 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout139_A net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc108 net37 net35 net783 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__a21boi_1
XFILLER_0_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc119 net43 net791 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__nor2_1
XANTENNA_c290_Y net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c283_X net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c748_A2 net795 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c467_A3 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c764_A1 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc620 net425 net75 net793 net289 net768 net830 VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__mux4_1
XFILLER_0_32_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc631 net277 net71 net24 net880 net770 net707 VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__mux4_4
Xc664 net812 net81 VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__and2b_1
Xc686 net445 net517 net800 VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__o21a_1
Xc675 net647 VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__clkbuf_2
Xc697 net781 net216 net521 net926 net540 net553 VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__mux4_1
XANTENNA_input24_X net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_80_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c584_A1 net196 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c361_RESET_B net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c759_A1 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c197_A3 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_71_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc472 net118 net813 net886 net357 net879 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__o32ai_1
Xc450 net317 net883 net867 VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__o21ai_2
Xc461 net347 net350 net306 net357 clknet_1_0__leaf_net682 net684 VGND VGND VPWR VPWR
+ net361 sky130_fd_sc_hd__mux4_4
XFILLER_0_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc494 net199 net392 net384 net833 net24 net881 VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__mux4_1
Xc483 net245 net383 net375 net384 clknet_1_1__leaf_net681 net688 VGND VGND VPWR VPWR
+ net388 sky130_fd_sc_hd__mux4_2
XANTENNA_c669_B2 net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_4_1_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c579_A1 net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc68 net904 net801 VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__or2b_2
Xc79 net13 net6 net12 net905 VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__a22o_1
XFILLER_0_97_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s853_Q net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net493 clknet_0_net493 VGND VGND VPWR VPWR clknet_1_0__leaf_net493
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c745_A3 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c761_A2 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c480_A3 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c489_A1 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c624_S0 net444 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c671_A2 net517 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc280 net196 net837 net184 net197 net188 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__o32a_4
Xc291 net185 net197 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__or2b_4
XFILLER_0_34_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c399_A1 net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net682_X clknet_1_0__leaf_net682 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s883_GATE_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge790 clknet_4_10_0_clk net622 net623 VGND VGND VPWR VPWR merge790/Q merge790/Q_N
+ sky130_fd_sc_hd__dfsbp_1
XANTENNA_fanout121_A net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c581_A2 net196 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold25 net288 VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 net660 VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c62_S0 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c363_X net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_39_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c756_A2 net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c491_A2 net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c619_S0 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input51_A in54 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c202_B1_N net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net469 clknet_0_net469 VGND VGND VPWR VPWR clknet_1_1__leaf_net469
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_84_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c248_S1 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s840_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c203_B1 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c77_A1_N net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c711_S1 net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout124_X net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c592_A1 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c439_S0 net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c621_S1 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c64_X net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input54_X net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c417_Q_N net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c706_S1 net726 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c538_A net823 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c722_S0 net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net478 net478 VGND VGND VPWR VPWR clknet_0_net478 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c753_A3 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c616_S1 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input14_A in20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c632_S0 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c540_B1_N net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc109 clknet_4_1_0_clk net38 net39 net26 VGND VGND VPWR VPWR net41 net40 sky130_fd_sc_hd__dfbbn_1
XTAP_TAPCELL_ROW_96_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input6_A in13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c662_B net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_A0 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c450_Y net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c748_A3 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c610_X net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_52_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc621 net393 net9 clknet_1_1__leaf_net396 net895 net893 net878 VGND VGND VPWR VPWR
+ net499 sky130_fd_sc_hd__mux4_1
Xc610 net909 net486 net16 net422 net889 net635 VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__mux4_4
Xc632 net88 net771 net144 net880 net11 net703 VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__mux4_1
Xc676 net765 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__clkinv_2
Xc687 net526 net777 net433 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__mux2_1
Xc698 net554 net422 net327 net901 net721 net723 VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__mux4_1
Xc665 net516 net422 net424 VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__a21boi_1
XANTENNA_c627_S0 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input17_X net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c301_B1 net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c393_A3 net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c690_B2 net544 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_hold22_A net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c453_SET_B net855 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c410_B net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c584_A2 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c105_A1 net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c560_X net440 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input9_X net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c478_A3 net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc440 net650 VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__clkbuf_2
Xc451 net310 net314 net68 net652 VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__a22oi_1
Xc473 net19 net256 net364 net875 net356 net879 VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__mux4_4
Xc462 net875 net886 net820 net635 net685 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__o32a_1
Xc495 net397 net856 net867 net277 net893 net696 VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__mux4_4
Xc484 net292 net72 net282 net271 net830 net769 VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__mux4_1
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c669_A2 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c664_A_N net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c714_S1 net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc69 net775 net811 VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__nand2b_4
XTAP_TAPCELL_ROW_26_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c141_X net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c595_A1 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c730_S0 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_rebuffer4_A net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c406_X net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c443_A2_N net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_A2 net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc270 net81 net904 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__or2_4
Xc281 net192 net191 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__or2b_2
XFILLER_0_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc292 net206 net97 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__and2_2
XFILLER_0_46_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_363 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge780 net331 net337 net334 net214 net216 net217 VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__mux4_1
Xmerge791 clknet_4_15_0_clk net539 net552 VGND VGND VPWR VPWR net655 net654 sky130_fd_sc_hd__dfsbp_1
XFILLER_0_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_31_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold26 net694 VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 net668 VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c725_S0 clknet_1_0__leaf_net736 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c62_S1 net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c189_X net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c460_S0 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c491_A3 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input44_A in48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c635_S0 net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c415_SCD net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_29_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c203_A1 net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c592_A2 net452 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c439_S1 clknet_1_1__leaf_net681 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge774_SET_B net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s809_Q net679 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c113_A1 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c349_S1 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c304_B1 net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input47_X net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c161_A2_N net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_72_336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c129_SET_B net863 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c214_B1 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c538_B net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c587_A2 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c326_Y net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c319_X net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c68_B_N net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_244 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c688_X net544 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c497_A2 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge789_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c209_A0 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c119_B net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_96_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c276_Y net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c603_X net482 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c205_S net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc622 net419 net11 net498 net88 net18 net873 VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__mux4_1
Xc611 net364 clknet_1_1__leaf_net485 net451 net886 clknet_1_1__leaf_net702 net706
+ VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__mux4_1
Xc600 net458 net891 net191 net451 net820 clknet_1_0__leaf_net702 VGND VGND VPWR VPWR
+ net479 sky130_fd_sc_hd__mux4_4
Xc633 net425 net244 net880 net693 net714 net718 VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__mux4_4
Xc666 net428 net771 VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__and2b_1
Xc677 net532 net427 net529 VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__a21boi_2
Xc688 net543 net186 net433 VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__o21ba_2
XANTENNA_c627_S1 net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc699 net418 net427 net901 net327 net723 net725 VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__mux4_2
XANTENNA_merge780_S0 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c301_A1 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s831_D net482 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c396_B_N net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c148_B_N net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c699_A0 net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c320_B_N net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c229_A net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c139_B_N net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c553_X net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c91_B net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c494_A3 net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc430 net64 net88 net796 net309 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__o22a_2
XFILLER_0_20_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc463 net337 net350 net362 net881 VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__o2bb2a_1
Xc441 net91 net241 net813 net770 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__a22o_1
Xc452 net229 net234 net873 net881 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_20_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc496 net373 net207 net847 net294 net244 net691 VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__mux4_1
Xc485 net160 net232 net386 net827 net843 net72 VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__mux4_4
Xc474 net228 net368 net365 net16 net684 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__a32o_1
XFILLER_0_19_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_93_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_10_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c206_B2 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c186_B net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c179_A net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c104_A_N net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_26_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net462 clknet_0_net462 VGND VGND VPWR VPWR clknet_1_0__leaf_net462
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c595_A2 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c134_X net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c307_B1 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc271 net67 net184 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__or2b_2
Xc260 clknet_4_1_0_clk net44 net122 net178 net635 net179 VGND VGND VPWR VPWR net842
+ c260/Q_N sky130_fd_sc_hd__sdfbbp_1
Xc282 net857 net197 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__nand2_1
Xc293 net805 net199 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__or2_2
XFILLER_0_46_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c696_A1 net331 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge781 net121 net236 net76 net328 net435 net823 VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__mux4_1
Xmerge770 net146 net40 net147 net782 net122 net32 VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__mux4_1
Xmerge792 clknet_4_8_0_clk net494 net497 VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__dfstp_1
XTAP_TAPCELL_ROW_31_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold38 net747 VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 net834 VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c741_S0 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c460_S1 clknet_1_0__leaf_net682 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c449_B1_N net795 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c127_B1 net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input37_A in41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_77_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c203_A2 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c149_B net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c736_S0 net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c342_SCD net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge783_S0 net332 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c304_A1 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c304_B2 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c453_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c333_SCD net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net469 net469 VGND VGND VPWR VPWR clknet_0_net469 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_2_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c497_A3 net635 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_57_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output68_A net834 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c688_A2 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_66_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_75_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_96_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_84_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c598_A2 net426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c171_Y net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc601 net883 net244 net903 net882 net930 clknet_1_0__leaf_net702 VGND VGND VPWR VPWR
+ net480 sky130_fd_sc_hd__mux4_2
Xc612 net318 net470 net426 net350 net422 net364 VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__mux4_1
Xc623 net878 net195 net880 net419 net11 net656 VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__mux4_1
Xc634 net502 net472 net635 net289 net799 net700 VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__mux4_1
Xc667 net633 VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__buf_6
Xc678 net529 net532 net530 VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__mux2_1
Xc689 clknet_4_12_0_clk net523 net540 net904 net892 net899 VGND VGND VPWR VPWR net546
+ net545 sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c196_S0 net795 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge780_S1 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c301_A2 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c211_A2 net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net600 clknet_0_net600 VGND VGND VPWR VPWR clknet_1_0__leaf_net600
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c281_X net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c546_X net426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc420 net309 net97 net88 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__a21boi_2
XFILLER_0_20_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc431 net327 net64 net903 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__o21bai_4
XFILLER_0_20_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc464 net322 net269 net891 net80 net908 VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__a32o_4
Xc453 clknet_4_12_0_clk net348 net901 net347 net238 net855 VGND VGND VPWR VPWR net352
+ net351 sky130_fd_sc_hd__sdfbbp_1
Xc442 net221 net956 net646 VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__a21o_1
XFILLER_0_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc486 clknet_4_3_0_clk net156 net856 net80 net289 net384 VGND VGND VPWR VPWR net392
+ net391 sky130_fd_sc_hd__sdfbbn_1
Xc497 net134 net395 net232 net635 net288 net851 VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__mux4_1
Xc475 clknet_4_6_0_clk net954 net235 net813 net6 net879 VGND VGND VPWR VPWR net379
+ net378 sky130_fd_sc_hd__sdfbbn_1
XANTENNA_input22_X net788 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c206_A2 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c503_B1 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c343_RESET_B net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net485 clknet_0_net485 VGND VGND VPWR VPWR clknet_1_0__leaf_net485
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c595_A3 net321 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c301_Y net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c739_S0 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s861_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc272 net74 net187 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__and2_4
Xc261 net761 VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__inv_2
Xc250 net780 net811 net871 net872 net850 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__a32o_1
Xc283 net198 net196 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__or2b_4
Xc294 net775 net205 net93 net91 net207 net204 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c696_A2 net536 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c287_B_N net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge782 net530 net528 net525 net311 net532 net666 VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__mux4_4
Xmerge771 net795 net320 net322 net194 net70 VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__a32o_1
XFILLER_0_7_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge793 clknet_4_3_0_clk net401 net402 VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__dfstp_1
XFILLER_0_43_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c130_SCE net863 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s843_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold28 net314 VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c294_S0 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold39 net664 VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s851_Q net726 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c368_Q net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output98_A net864 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_90_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c693_B1_N net331 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c351_SCE net115 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c736_S1 net788 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c299_Y net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c342_SCE net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge783_S1 net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c304_A2 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s807_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c601_A0 net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c333_SCE net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c214_A2 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c321_A net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout122_X net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c405_A1 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c140_A1 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge778_S1 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c343_SET_B net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input52_X net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c392_S0 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_96_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c598_A3 net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c164_Y net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c536_A net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c693_X net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c416_B1 net196 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc602 net356 net479 net452 clknet_1_1__leaf_net480 net470 clknet_1_1__leaf_net702
+ VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__mux4_2
Xc613 net413 net769 net886 clknet_1_0__leaf_net485 net667 clknet_1_1__leaf_net702
+ VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__mux4_1
XANTENNA_c477_S0 net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc635 net507 net106 net498 net2 net793 net714 VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__mux4_2
Xc624 net894 net468 net885 net836 net444 net711 VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__mux4_4
Xc668 net633 VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__clkbuf_1
Xc679 net528 net419 net532 net534 net70 net519 VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__mux4_4
XANTENNA_c196_S1 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input12_A in19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_80_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output80_A net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c699_A2 net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c335_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c236_B1 net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input4_A in11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c539_X net419 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c441_X net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc410 net307 net308 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__nand2b_4
Xc421 net319 net853 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__and2b_2
XFILLER_0_20_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c454_SCD net196 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc454 clknet_4_7_0_clk net349 net890 net196 net881 net343 VGND VGND VPWR VPWR net354
+ net353 sky130_fd_sc_hd__sdfbbn_1
Xc432 net331 net194 net80 net305 net323 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__a32o_2
Xc443 net852 net233 net327 net673 VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc487 net191 net317 net828 net276 net813 net292 VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__mux4_1
Xc476 net375 net367 net879 net1 clknet_1_0__leaf_net682 VGND VGND VPWR VPWR net380
+ sky130_fd_sc_hd__o32a_2
Xc465 clknet_4_6_0_clk net344 net96 net20 net261 net263 VGND VGND VPWR VPWR net366
+ net365 sky130_fd_sc_hd__sdfbbn_1
Xc498 net387 net271 net794 net160 net890 net847 VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__mux4_1
XFILLER_0_35_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input15_X net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_82_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_93_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c503_A1 net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input7_X net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc251 net942 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__clkbuf_1
Xc262 net871 net3 net658 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__o21bai_1
Xc240 net164 net151 net114 net885 net878 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__o32a_1
XANTENNA_c604_A0 net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc273 net190 net189 net78 net63 net76 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__o32a_4
Xc284 net201 net857 net772 net189 net954 VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__o32ai_4
Xc295 net210 net96 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__and2_2
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c696_A3 net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge772 net767 VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__buf_1
XFILLER_0_83_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_252 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge783 net519 net522 net770 net432 net332 net438 VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__mux4_1
XFILLER_0_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge794 clknet_4_1_0_clk net177 net181 VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__dfstp_1
XTAP_TAPCELL_ROW_31_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold29 net312 VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c294_S1 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c568_D net435 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer2_A net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c408_A1 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c404_X net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c485_S0 net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c334_B1 net864 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c395_S0 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout112_A net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c752_S1 net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c120_B_N net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_252 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c334_A1_N net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c304_A3 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input42_A in46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c601_A1 net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c154_B net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout115_X net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c260_SCE net635 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge804_GATE clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input45_X net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap125_A net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c392_S1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c331_A1 net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c567_S1 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c465_SET_B net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c134_A_N net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c264_A net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c324_Y net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc603 net270 net374 clknet_1_0__leaf_net478 net878 net770 net775 VGND VGND VPWR VPWR
+ net482 sky130_fd_sc_hd__mux4_4
XANTENNA_c477_S1 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc625 net149 net263 net195 net793 net206 net838 VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__mux4_1
XFILLER_0_32_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc636 net509 net903 net893 net350 net679 net711 VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__mux4_1
Xc614 net775 net484 net413 net792 net790 clknet_1_0__leaf_net702 VGND VGND VPWR VPWR
+ net492 sky130_fd_sc_hd__mux4_4
Xc669 net516 net79 net73 net888 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__a22o_1
XANTENNA_c432_B1 net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c151_A1 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c343_Q net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c607_A0 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output73_A net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c699_A3 net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c690_A2_N net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c236_B2 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s854_SLEEP_B clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c434_X net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c488_S0 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc400 net67 net80 VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__and2_4
Xc411 net300 net308 net887 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__a21bo_1
Xc433 net661 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__buf_6
XANTENNA_c454_SCE net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc455 net345 net809 net354 net350 net348 VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__a32o_1
Xc422 net307 net316 net896 net303 net800 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__a32o_2
Xc444 net323 net200 net317 net916 net222 VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__o32a_1
XPHY_EDGE_ROW_8_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc488 net283 net776 net274 net824 net88 clknet_1_0__leaf_net681 VGND VGND VPWR VPWR
+ net394 sky130_fd_sc_hd__mux4_1
Xc466 clknet_4_6_0_clk net262 net852 net795 net886 net687 VGND VGND VPWR VPWR net368
+ net367 sky130_fd_sc_hd__sdfbbp_1
Xc477 net377 net379 net9 net799 net364 net879 VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__mux4_2
XFILLER_0_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc499 net207 net294 net326 net289 net890 net885 VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__mux4_1
XFILLER_0_35_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output111_A net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c337_B1 net855 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c503_A2 net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout142_A net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c401_B net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c124_B1_N net863 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c710_A0 net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c490_S1 net692 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c157_B1 net795 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc230 net95 net2 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__and2b_1
Xc252 clknet_4_1_0_clk net126 net780 net36 net871 net163 VGND VGND VPWR VPWR net176
+ net175 sky130_fd_sc_hd__sdfbbp_1
Xc263 net122 net170 net866 net635 net175 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__o32a_1
XFILLER_0_20_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc241 net156 net885 net161 net676 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__a22oi_2
XFILLER_0_32_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c604_A1 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc285 net73 net201 net79 net200 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__o2bb2a_1
Xc296 net80 net927 net204 net198 net908 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__o32ai_4
Xc274 net184 net896 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__and2_1
XANTENNA_c620_A0 net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge773 net45 net172 net811 net57 net904 net49 VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__mux4_1
XFILLER_0_7_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge784 clknet_4_13_0_clk net639 net315 VGND VGND VPWR VPWR net647 net646 sky130_fd_sc_hd__dfrbp_2
Xmerge795 net165 clknet_4_1_0_clk net631 VGND VGND VPWR VPWR net660 net659 sky130_fd_sc_hd__dlrbn_1
XTAP_TAPCELL_ROW_31_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c237_Y net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c132_X net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s837_Q net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c408_A2 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c705_A0 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c485_S1 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_98_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c92_Y net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c85_X net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c318_A2 net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_90_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c334_B2 net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c336_SCD net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c228_A2 net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c187_Y net115 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c496_S0 net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input35_A in4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c601_A2 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c329_A1 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c345_B1 net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c297_X net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c464_X net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_17_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_26_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input38_X net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c331_A2 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap118_A net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c241_A2 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c424_A net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c317_Y net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_62_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc604 net297 net1 net206 net878 net886 clknet_1_0__leaf_net478 VGND VGND VPWR VPWR
+ net483 sky130_fd_sc_hd__mux4_1
Xc637 net278 net409 net830 net834 net716 net720 VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__mux4_2
Xc626 net289 net794 net500 net836 net878 net885 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__mux4_1
Xc615 net488 net771 net16 net837 clknet_1_1__leaf_net702 net710 VGND VGND VPWR VPWR
+ net493 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_73_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c713_A0 net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c432_A1 net331 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_80_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c623_A0 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output66_A net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c180_B1_N net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c236_A2 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c533_B1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_S0 net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c162_X net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c427_X net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c708_A0 net531 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c427_A1 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc412 net301 net310 net188 net887 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__a22oi_4
Xc401 net197 net833 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__or2_1
XFILLER_0_32_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc423 net662 VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__buf_1
Xc434 net187 net323 net796 net307 net901 net890 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__mux4_2
Xc445 net222 net917 net882 VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__o21a_1
XANTENNA_c443_B1 net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc456 net200 net69 net241 VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__o21a_2
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc478 net20 net372 net199 net195 net902 VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__a32o_1
Xc467 net366 net896 net118 net889 net679 net685 VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__mux4_1
Xc489 net80 net211 net34 net393 net810 net680 VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__mux4_1
XANTENNA_c162_A1 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c299_B_N net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output104_A net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c679_S0 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c337_A1 net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s822_D net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c353_B1 net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c503_A3 net288 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c417_SET_B net646 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout135_A net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c247_A1 net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c263_B1 net635 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c419_B1_N net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c438_A0 net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c499_S0 net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c157_B2 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c157_A1 net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c75_A net815 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc220 net3 net119 net675 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__mux2_1
XFILLER_0_32_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc242 net111 net32 net44 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__a21oi_1
Xc253 net168 net813 net866 net811 net830 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__o32ai_2
Xc231 net151 net136 net799 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__o21ba_1
XANTENNA_c604_A2 net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c173_B1 net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc275 net185 net192 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__or2b_4
Xc297 net193 net205 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__and2_2
Xc264 net777 net63 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__or2b_4
XFILLER_0_20_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc286 net896 net908 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__nor2_2
XFILLER_0_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A1 net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input20_X net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge774 clknet_4_13_0_clk net313 merge774/RESET_B net779 net311 net201 VGND VGND
+ VPWR VPWR net636 net413 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_83_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge796 net339 clknet_4_7_0_clk net632 VGND VGND VPWR VPWR net662 net661 sky130_fd_sc_hd__dlrbn_1
XTAP_TAPCELL_ROW_31_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge785 clknet_4_6_0_clk net363 net380 VGND VGND VPWR VPWR net649 net648 sky130_fd_sc_hd__dfrbp_1
XFILLER_0_55_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xs880 net620 clknet_4_10_0_clk VGND VGND VPWR VPWR net757 s880/Q_N sky130_fd_sc_hd__dlxbn_1
XFILLER_0_43_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s828_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput1 in0 VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__buf_4
XFILLER_0_39_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout138_X net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c705_A1 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c721_A0 net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c661_X net517 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c615_A1 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_90_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c631_A0 net277 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c692_S0 net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c244_A2 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c287_A net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c419_A2 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c716_A0 net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c435_A1 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c451_B1 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c170_B2 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c366_Q net285 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input28_A in33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c601_A3 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_87_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c329_A2 net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c626_A0 net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c597_S0 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c255_A1 net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c457_X net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c64_A0 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c612_A2 net426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c475_SCD net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_96_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_hold36_A net660 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c369_D net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net592 clknet_0_net592 VGND VGND VPWR VPWR clknet_1_1__leaf_net592
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c424_B net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout120_X net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c466_SCD net795 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc627 net218 net155 net893 net88 net878 net9 VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__mux4_2
Xc616 net24 net770 net400 net902 net779 net878 VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__mux4_1
Xc605 net891 net362 net794 net364 net895 clknet_1_0__leaf_net702 VGND VGND VPWR VPWR
+ net484 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_73_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c713_A1 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c176_S net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c176_A0 net823 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c607_A2 net795 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c623_A1 net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input50_X net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c568_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c533_A1 net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_S1 net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c541_B net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c534_A net635 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c322_X net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c708_A1 net332 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c427_A2 net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc402 net297 net298 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__or2b_2
XFILLER_0_32_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c724_A0 net544 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc413 net647 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__buf_1
Xc435 net329 net218 net332 net61 net787 net328 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__mux4_1
Xc424 net828 net787 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__or2_2
Xc446 net233 net186 net188 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__o21bai_1
Xc457 net346 net105 net890 net650 VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__a2bb2o_4
Xc468 net72 net364 net88 net879 net649 VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__o32a_1
Xc479 net96 net250 net950 net378 net646 VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__a32o_1
XANTENNA_c162_A2 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input10_A in17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c618_A1 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c337_A2 net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c353_A1 net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net478 clknet_0_net478 VGND VGND VPWR VPWR clknet_1_0__leaf_net478
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_62_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout128_A net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input2_A in1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c272_X net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c710_A2 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c719_A0 net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c499_S1 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c157_A2 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c75_B net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c68_A net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_79_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc221 net99 net82 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__and2_0
XFILLER_0_32_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc210 net128 net789 net867 net62 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__a2bb2o_2
XFILLER_0_60_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc254 net131 net50 net885 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__a21o_1
Xc243 net159 net841 net832 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__mux2_1
XANTENNA_input58_A in60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc232 net153 net0 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__nor2_1
XANTENNA_c173_A1 net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c604_A3 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc287 net796 net198 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__or2b_4
Xc276 net189 net194 net896 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__o21ai_4
Xc265 net65 net832 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__nand2_2
Xc298 net211 net83 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_5_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A2 net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input13_X net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c629_A0 net276 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge775 net525 net524 net528 net527 net523 VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__o32ai_1
Xmerge786 clknet_4_5_0_clk net355 net629 VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__dfrtn_1
Xmerge797 net279 clknet_4_0_0_clk net275 VGND VGND VPWR VPWR net664 net663 sky130_fd_sc_hd__dlrbp_1
XTAP_TAPCELL_ROW_31_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs870 net601 clknet_4_11_0_clk VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__lpflow_inputisolatch_1
XFILLER_0_83_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs881 net621 clknet_4_10_0_clk VGND VGND VPWR VPWR net758 s881/Q_N sky130_fd_sc_hd__dlxbp_1
XANTENNA_c368_Q_N net288 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c364_B1 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput2 in1 VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_67_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input5_X net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_2_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c109_CLK_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c168_B2 net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c168_A1 net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c184_B1 net821 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c692_S1 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c631_A1 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c409_B1_N net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c244_A3 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c716_A1 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c368_RESET_B net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c435_A2 net332 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c732_A0 net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c451_B2 net652 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c170_A2 net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c329_A3 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c626_A1 net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output89_A net855 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_8_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c231_B1_N net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c255_A2 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput60 in7 VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__buf_2
XANTENNA_c552_B1 net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c702_A3 net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c185_X net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer3_X net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c727_A0 net517 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c64_A1 net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c446_A1 net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c462_B1 net635 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input40_A in44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c612_A3 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c74_S net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c475_SCE net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c145_A net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c266_A1 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c466_SCE net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout113_X net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc628 net496 net880 net61 net770 net893 net357 VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__mux4_1
Xc617 net350 net407 net889 net263 net904 net903 VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__mux4_4
Xc606 net815 net836 net775 net880 net904 clknet_1_0__leaf_net682 VGND VGND VPWR VPWR
+ net485 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_73_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c713_A2 net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c432_A3 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c567_X net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c457_B1 net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c176_A1 net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c607_A3 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input43_X net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c533_A2 net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c534_B net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c708_A2 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc403 net300 net299 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__or2_1
Xc436 net823 net328 net903 net334 net929 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__a32o_1
Xc414 net887 net306 net928 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__o21bai_2
Xc425 net800 net903 net768 net62 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__o22ai_4
Xc447 net650 VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__inv_4
Xc458 net797 net343 net350 net357 net353 net650 VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__mux4_4
XANTENNA_c684_X net540 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc469 clknet_4_6_0_clk net370 net6 net894 net357 net879 VGND VGND VPWR VPWR net372
+ net371 sky130_fd_sc_hd__sdfbbn_1
XTAP_TAPCELL_ROW_28_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c187_B1 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c618_A2 net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c337_A3 net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge771_A1 net795 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge771_B2 net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c353_A2 net897 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output71_A net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c247_A3 net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_610 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c710_A3 net517 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c432_X net332 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c719_A1 net419 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_81_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c438_A2 net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c157_A3 net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c735_A0 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc211 net132 net773 net133 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__o21a_1
Xc200 net789 net8 net19 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_68_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc222 net659 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__dlygate4sd3_1
Xc244 net148 net783 net885 net131 net32 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__a32o_1
Xc233 net785 net31 net152 net158 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_32_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c173_A2 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc277 net186 net915 net190 net194 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__o22ai_4
Xc255 net791 net870 net148 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__o21bai_1
Xc288 net203 net185 net908 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__o21ai_4
Xc266 net769 net71 net185 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__a21o_4
Xc299 net213 net211 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__nor2b_2
XANTENNA_c470_B1 net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A3 net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c629_A1 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c348_A2 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge787 clknet_4_13_0_clk net448 net449 VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__dfrtp_1
Xmerge765 net93 net429 net300 net437 net805 net951 VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__mux4_1
Xs860 clknet_4_14_0_clk net579 VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__dlclkp_1
Xmerge776 net46 net53 net139 net113 net143 VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__o32ai_1
Xs882 net624 clknet_4_13_0_clk VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__dlxtn_1
Xmerge798 net535 clknet_4_15_0_clk net637 VGND VGND VPWR VPWR net666 net665 sky130_fd_sc_hd__dlrbp_1
XFILLER_0_24_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xs871 clknet_4_11_0_clk net602 VGND VGND VPWR VPWR net748 s871/Q_N sky130_fd_sc_hd__dfxbp_1
XANTENNA_c364_A1 net897 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput3 in10 VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_39_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout140_A net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c705_A3 net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c721_A2 net533 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c168_A2 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c689_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c615_A3 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c631_A2 net24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_4_4_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout143_X net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c285_B1 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c435_A3 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c732_A1 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c451_A2 net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c170_A3 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c83_X net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c195_B1 net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge774_SCD net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c271_B_N net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput61 in8 VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__buf_4
XANTENNA_merge799_GATE_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput50 in53 VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__buf_4
XFILLER_0_3_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c292_A net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c178_X net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c345_X net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c727_A1 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c64_A2 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c446_A2 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c462_A1 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input33_A in38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c356_A2 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net594 clknet_0_net594 VGND VGND VPWR VPWR clknet_1_1__leaf_net594
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c145_B net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c138_A net823 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c312_B net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c266_A2 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s876_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc618 net293 net895 net779 net880 net881 net669 VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__mux4_4
Xc607 net71 clknet_1_0__leaf_net462 net795 net827 net667 clknet_1_1__leaf_net702 VGND
+ VGND VPWR VPWR net486 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_73_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc629 net276 net769 net893 net71 net798 net885 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__mux4_1
XANTENNA_c713_A3 net544 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c295_X net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_40_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c738_A0 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c369_SET_B net288 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c473_A0 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_12_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c623_A3 net419 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input36_X net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge769_A1 net891 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap116_A net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c502_S0 net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s858_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c277_A1 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c708_A3 net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c315_Y net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c210_X net137 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c724_A2 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc415 clknet_4_7_0_clk net313 net938 net308 net307 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__sdfrtp_4
Xc437 net332 net918 net336 net334 net324 net680 VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__mux4_2
Xc404 net828 net67 VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__and2b_2
XFILLER_0_4_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc426 net208 net222 net901 net903 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__o22ai_4
Xc448 net837 net68 net662 VGND VGND VPWR VPWR net873 sky130_fd_sc_hd__o21ai_4
Xc459 net343 net191 net357 net881 net908 clknet_1_0__leaf_net682 VGND VGND VPWR VPWR
+ net359 sky130_fd_sc_hd__mux4_2
XFILLER_0_99_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c86_A0 net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c267_A_N net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c468_B1 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c187_A1 net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c359_RESET_B net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net592 net592 VGND VGND VPWR VPWR clknet_0_net592 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c634_A2 net635 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output64_A net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c366_SCE net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net469 clknet_0_net469 VGND VGND VPWR VPWR clknet_1_0__leaf_net469
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c263_A3 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c288_B1 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_81_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c719_A2 net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c735_A1 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c233_A1_N net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc212 net86 net138 net135 net137 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__a22oi_2
Xc201 net791 net8 net104 net111 net905 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__o32ai_4
Xc245 net50 net779 net798 VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__mux2_2
Xc234 net41 net801 net24 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__o21ai_4
Xc223 net774 net27 net9 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__o21bai_1
XANTENNA_c751_A0 net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc278 net193 net857 VGND VGND VPWR VPWR net837 sky130_fd_sc_hd__or2_4
Xc267 net63 net76 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__nand2b_1
Xc256 clknet_4_1_0_clk net179 net171 net45 net783 net168 VGND VGND VPWR VPWR net848
+ net180 sky130_fd_sc_hd__sdfbbn_1
Xc289 net202 net803 net184 VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__o21ai_2
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c470_B2 net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c470_A1 net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c629_A2 net893 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge782_A1 net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge777 net311 net828 net888 net527 net529 net520 VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__mux4_1
Xs850 net556 clknet_4_15_0_clk VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__dlxtn_1
Xmerge766 clknet_4_4_0_clk net257 net246 net772 net773 net945 VGND VGND VPWR VPWR
+ net626 net625 sky130_fd_sc_hd__sdfbbn_1
Xmerge788 clknet_4_5_0_clk merge788/D net123 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dfrtp_1
Xs861 clknet_4_14_0_clk net580 VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__dlclkp_2
XFILLER_0_70_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs883 net634 clknet_4_1_0_clk VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__dlxtn_1
Xs872 clknet_4_11_0_clk net603 VGND VGND VPWR VPWR net749 s872/Q_N sky130_fd_sc_hd__dfxbp_1
Xmerge799 net475 clknet_4_12_0_clk net476 VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__dlrtn_1
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c364_A2 net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput4 in11 VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_67_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout133_A net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_4_0_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_5_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c721_A3 net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c449_A2 net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c168_A3 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c746_A0 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c600_S0 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c80_B net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c184_A2 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge777_A1 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_87_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c566_B1 net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout136_X net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c716_A3 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_558 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c123_X net863 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c492_X net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c732_A2 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c94_B1 net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c476_B1 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c626_A3 net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c195_B2 net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput40 in44 VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_44_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput62 in9 VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__buf_4
Xinput51 in54 VGND VGND VPWR VPWR net817 sky130_fd_sc_hd__buf_2
XFILLER_0_12_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c552_A2 net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c296_B1 net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c338_X net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c727_A2 net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c64_A3 net815 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c469_SCD net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c462_A2 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input26_A in31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c325_S0 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c637_A2 net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c356_A3 net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_output94_A net860 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c219_S1 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c417_D net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c138_B net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c563_B2 net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc619 net423 net466 net404 net231 net106 net935 VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__mux4_1
Xc608 net426 clknet_1_0__leaf_net480 clknet_1_0__leaf_net485 net100 net873 clknet_1_1__leaf_net702
+ VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__mux4_2
XFILLER_0_69_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge794_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c754_A0 net546 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c192_A2 net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input29_X net795 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c150_A net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c724_A3 net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc416 net309 net310 net937 net196 net313 VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__o32ai_2
Xc405 net303 net296 net887 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__a21boi_2
Xc427 net903 net794 net908 VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__o21ba_2
XFILLER_0_13_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc438 net330 net307 net901 net329 net90 net316 VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__mux4_1
Xc449 net342 net233 net795 VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__o21bai_2
XANTENNA_c677_Y net533 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c572_X net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c740_A2 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c468_A1 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c603_S0 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge771_A3 net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c634_A3 net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c368_SET_B net893 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c160_Y net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c153_X net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c258_Y net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s858_Q net734 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c719_A3 net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c425_Y net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c69_A_N net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc202 net17 net911 net894 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__o21bai_1
XFILLER_0_32_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc235 net133 net36 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__nand2_1
Xc224 net119 net818 net134 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__a21o_1
Xc213 net8 net113 net112 net79 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_92_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc279 net195 net193 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__and2_4
Xc268 net72 net773 VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__and2_2
XFILLER_0_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc246 net42 net870 net32 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__a21oi_1
Xc257 net143 net848 net178 net163 net780 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__o32ai_2
XFILLER_0_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c198_A1 net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c629_A3 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge767 clknet_4_15_0_clk net521 net517 net419 net926 net777 VGND VGND VPWR VPWR
+ net628 net627 sky130_fd_sc_hd__sdfbbp_1
Xs851 net559 clknet_4_15_0_clk VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__dlxtn_2
Xmerge778 net280 net286 net865 net163 net37 net844 VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__mux4_1
Xs840 clknet_4_8_0_clk net501 VGND VGND VPWR VPWR net713 s840/Q_N sky130_fd_sc_hd__dfxbp_1
Xs884 net640 clknet_4_2_0_clk VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_24_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs873 clknet_4_11_0_clk net604 VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__dfxtp_1
Xmerge789 clknet_4_14_0_clk net589 net590 VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__dfrtp_1
Xs862 clknet_4_14_0_clk net581 VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c364_A3 net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap131_X net897 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput5 in12 VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__buf_4
XFILLER_0_36_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c252_RESET_B net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout126_A net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c571_A1 net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c270_X net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c542_Y net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c746_A1 net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c454_RESET_B net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c66_A net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input56_A in59 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c328_S0 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input11_X net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge777_A2 net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c149_A_N net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c701_S0 net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c566_A1 net440 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout129_X net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c732_A3 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input3_X net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c757_A0 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c476_B2 clknet_1_0__leaf_net682 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c195_A2 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c492_A0 net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input59_X net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_merge801_Q net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput30 in35 VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__buf_2
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput52 in55 VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__buf_2
Xinput41 in45 VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c577_B1 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c296_A1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c296_B2 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c400_X net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c469_SCE net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c462_A3 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c606_S0 net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input19_A in25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c325_S1 net652 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c487_A0 net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c637_A3 net834 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output87_A net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net574 clknet_0_net574 VGND VGND VPWR VPWR clknet_1_1__leaf_net574
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c547_A3 net423 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c563_A2 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc609 net321 clknet_1_1__leaf_net478 net795 net451 net191 clknet_1_0__leaf_net702
+ VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__mux4_4
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c288_Y net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c318_B1_N net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer1_X net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone22 net790 net770 VGND VGND VPWR VPWR net952 sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_23_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c754_A1 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c473_A2 net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_rebuffer11_A net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c192_A3 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_hold27_A net834 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c369_SCD net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c150_B net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c143_A net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c452_A2_N net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc417 clknet_4_13_0_clk net314 net313 net312 net887 net646 VGND VGND VPWR VPWR net317
+ net316 sky130_fd_sc_hd__sdfbbn_2
Xc428 net901 net319 net221 VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__mux2_2
Xc406 net304 net71 net888 VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__a21o_2
Xc439 net332 net328 net329 net337 net901 clknet_1_1__leaf_net681 VGND VGND VPWR VPWR
+ net339 sky130_fd_sc_hd__mux4_2
XFILLER_0_13_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c749_A1 net285 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c468_A2 net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c603_S1 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c96_A net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c484_A1 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net594 net594 VGND VGND VPWR VPWR clknet_0_net594 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c689_Q net546 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge766_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input41_X net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c394_A1 net863 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c163_B1_N net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_19_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c704_S0 net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c146_X net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c585_B1 net452 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer9_A net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_61_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_28_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c735_A3 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc203 net786 net775 net3 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_79_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c703_RESET_B net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc225 net659 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__inv_4
XFILLER_0_20_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc236 net152 net832 net772 net867 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__o22ai_4
Xc214 net133 net125 net111 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_92_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc269 net187 net73 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__and2_4
Xc258 net176 net36 net37 VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__o21ai_2
Xc247 net818 net169 net135 net45 net871 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__a32o_1
XANTENNA_c751_A2 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c475_SET_B net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c614_S0 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c479_B2 net646 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge768 net320 net204 net235 net823 net652 net673 VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__mux4_1
Xs852 net560 clknet_4_15_0_clk VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__dlxtn_1
Xmerge779 net90 net411 net442 net454 net350 net651 VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__mux4_1
Xs841 clknet_4_8_0_clk net504 VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__dfxtp_1
Xs830 clknet_4_8_0_clk net481 VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__dlclkp_4
Xs885 net641 clknet_4_12_0_clk VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__dlxtp_1
XFILLER_0_24_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xs874 clknet_4_10_0_clk net606 VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__dfxtp_1
Xs863 net582 clknet_4_11_0_clk VGND VGND VPWR VPWR net739 s863/Q_N sky130_fd_sc_hd__dlxbn_1
XFILLER_0_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput6 in13 VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__buf_6
XFILLER_0_36_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout119_A net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c434_S0 net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c535_Y net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c430_X net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c746_A2 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c66_B net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c762_A1 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c481_A2 net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c609_S0 net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c328_S1 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input49_A in52 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c283_B_N net196 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c566_A2 net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c230_B net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s830_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c94_A2 net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c757_A1 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c69_Y net864 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net701 clknet_0_net701 VGND VGND VPWR VPWR clknet_1_1__leaf_net701
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_49_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s888_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput31 in36 VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput20 in26 VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_12_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput42 in46 VGND VGND VPWR VPWR net808 sky130_fd_sc_hd__buf_2
Xinput53 in56 VGND VGND VPWR VPWR net819 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c278_B net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c712_S0 net652 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c296_A2 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout141_X net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c593_B1 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c743_A3 net517 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c606_S1 clknet_1_0__leaf_net682 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c622_S0 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c487_A1 net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c397_A1 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_73_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c290_A net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c707_S0 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c183_Y net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c176_X net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c588_B1 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c448_Y net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_84_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_75_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclone23 net769 net827 VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__and2b_1
XFILLER_0_62_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c754_A2 net788 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c473_A3 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c579_S net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c617_S0 net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input31_A in36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c352_S0 net824 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c369_SCE net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c201_B1 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c574_A2 net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc407 net305 net297 net197 net195 net887 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__a32o_1
XFILLER_0_13_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc418 net773 net91 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__nor2b_2
Xc429 net214 net322 net62 net892 net69 VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__a32o_1
XFILLER_0_13_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c590_A1 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c565_Y net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c558_X net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c86_A3 net815 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c749_A2 net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c468_A3 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c336_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c89_A net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c484_A2 net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input34_X net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c704_S1 net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c585_A1 net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c139_X net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c585_B2 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_61_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc226 net828 net866 net895 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__a21o_1
Xc204 net909 net808 net905 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__mux2_1
Xc215 net141 net804 net113 net140 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__o22ai_4
XFILLER_0_60_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc248 net32 net37 net126 net864 net863 net885 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__mux4_1
Xc259 clknet_4_1_0_clk net174 net173 net871 net844 net944 VGND VGND VPWR VPWR net868
+ c259/Q_N sky130_fd_sc_hd__sdfbbn_1
Xc237 net154 net158 net159 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__o21ai_2
XANTENNA_c675_X net531 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c106_B1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c495_A1 net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xs842 clknet_4_8_0_clk net505 VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__dfxtp_1
Xs820 net389 clknet_4_3_0_clk VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__dlxtn_1
XANTENNA_c630_S0 net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs831 net482 clknet_4_11_0_clk VGND VGND VPWR VPWR net876 s831/Q_N sky130_fd_sc_hd__dlxbn_1
XFILLER_0_55_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge769 net442 net891 net341 net89 net330 net652 VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__mux4_1
Xs886 net642 clknet_4_7_0_clk VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__lpflow_inputisolatch_1
XFILLER_0_70_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xs853 net565 clknet_4_14_0_clk VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__dlxtp_1
Xs864 net584 clknet_4_10_0_clk VGND VGND VPWR VPWR net740 s864/Q_N sky130_fd_sc_hd__dlxbn_1
Xs875 clknet_4_10_0_clk net611 VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc760 net513 net239 clknet_1_1__leaf_net469 net610 clknet_1_1__leaf_net719 net749
+ VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__mux4_2
XANTENNA_max_cap117_X net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput7 in14 VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_36_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c686_B1 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c715_S0 net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c434_S1 net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c746_A3 net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c762_A2 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c625_S0 net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output100_A net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc590 net898 net460 net922 net352 clknet_1_1__leaf_net462 VGND VGND VPWR VPWR net469
+ sky130_fd_sc_hd__o32ai_1
XFILLER_0_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_63_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_65_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c63_S0 net824 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_74_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c476_A3 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c492_A2 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input61_A in8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net702 clknet_0_net702 VGND VGND VPWR VPWR clknet_1_1__leaf_net702
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_92_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput21 in27 VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__buf_2
XANTENNA_c683_A1 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput10 in17 VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_71_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput43 in47 VGND VGND VPWR VPWR net809 sky130_fd_sc_hd__buf_2
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput32 in37 VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__buf_4
Xinput54 in57 VGND VGND VPWR VPWR net820 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_52_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c204_A0 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c577_A2 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c296_A3 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout134_X net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c67_B_N net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c593_B2 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c343_Q_N net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_46_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c622_S1 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c487_A2 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c174_B_N net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge788_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c694_B1 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c283_A net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c588_B2 net700 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c723_S0 net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclone24 net769 net827 VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__and2b_1
XFILLER_0_7_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_531 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c617_S1 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input24_A in3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c352_S1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c201_A1 net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c201_B2 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c136_B net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc408 net776 net303 net887 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__a21boi_2
Xc419 net192 net837 net887 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__a21bo_1
XFILLER_0_13_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c437_S1 net680 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c599_A0 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c749_A3 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c89_B net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net574 net574 VGND VGND VPWR VPWR clknet_0_net574 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge765_S0 net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c628_S0 net893 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input27_X net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_66_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c212_B1 net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c569_A3 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c585_A2 net823 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c720_S1 net734 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c413_A net647 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_61_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc227 net774 net115 net791 net41 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__a22o_1
Xc205 net117 net13 net895 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__mux2_1
Xc216 net13 net10 net118 net133 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__o22a_1
XFILLER_0_60_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc249 net942 VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__clkbuf_1
Xc238 net27 net160 net32 net895 net24 VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__o32a_2
XFILLER_0_99_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c479_A3 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs810 clknet_4_0_0_clk net295 VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__dfxtp_1
Xs843 clknet_4_8_0_clk net506 VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__dfxtp_1
XANTENNA_c495_A2 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs821 net394 clknet_4_3_0_clk VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__dlxtp_1
XANTENNA_c630_S1 net24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs832 net483 clknet_4_11_0_clk VGND VGND VPWR VPWR net705 net704 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs876 clknet_4_8_0_clk net612 VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__dlclkp_1
Xs865 net585 clknet_4_11_0_clk VGND VGND VPWR VPWR net742 net741 sky130_fd_sc_hd__dlxbp_1
Xs854 net567 clknet_4_14_0_clk VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xs887 clknet_4_15_0_clk net644 VGND VGND VPWR VPWR net765 net764 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_36_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc761 net357 net231 net832 net513 net715 net740 VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__mux4_1
Xc750 net558 net768 net913 net656 net692 net750 VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__mux4_1
Xinput8 in15 VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_78_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c686_A1 net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c715_S1 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c596_A1 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c731_S0 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c762_A3 net515 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c625_S1 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_14_0_clk_X clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c554_A_N net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc580 net809 net309 net451 net956 net425 VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__o32ai_4
XFILLER_0_47_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc591 net319 net799 net881 VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__o21bai_2
XFILLER_0_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c697_A0 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c350_SCD net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout124_A net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c111_A net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c63_S1 net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c726_S0 net546 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c461_S0 clknet_1_0__leaf_net682 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c700_X net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge773_S0 net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input54_A in57 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c636_S0 net679 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net736 clknet_0_net736 VGND VGND VPWR VPWR clknet_1_1__leaf_net736
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c310_B1 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput11 in18 VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c683_A2 net788 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput22 in28 VGND VGND VPWR VPWR net788 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_40_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput55 in58 VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_24_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput33 in38 VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__clkbuf_8
Xinput44 in48 VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__buf_2
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c691_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c204_A1 net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c220_A0 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c159_A net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout127_X net893 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input1_X net635 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c487_A3 net276 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge768_S0 net652 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input57_X net823 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c305_B1 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c694_A1 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c215_B1 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c588_A2 net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c723_S1 net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net701 net701 VGND VGND VPWR VPWR clknet_0_net701 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone25 net957 VGND VGND VPWR VPWR net955 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_23_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input17_A in23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c498_A2 net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output85_A net851 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net396 clknet_0_net396 VGND VGND VPWR VPWR clknet_1_1__leaf_net396
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc409 net298 net307 net887 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__o21ba_2
XFILLER_0_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c590_A3 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c718_S1 net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input9_A in16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c181_X net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c599_A1 net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c331_B1_N net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge765_S1 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c628_S1 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge781_S0 net435 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold25_A net288 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c212_B2 net137 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c212_A1 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c141_A net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c354_B1_N net855 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c729_S0 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc217 net671 VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__clkinv_8
XFILLER_0_32_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc206 net98 net125 net128 net905 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_92_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc228 net127 net785 net151 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__a21o_1
Xc239 net138 net127 net147 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__a21o_1
XFILLER_0_40_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s860_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs811 clknet_4_7_0_clk net335 VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__dfxtp_4
XANTENNA_c495_A3 net277 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs822 net398 clknet_4_9_0_clk VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__lpflow_inputisolatch_1
XFILLER_0_36_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs833 net487 clknet_4_9_0_clk VGND VGND VPWR VPWR net707 net706 sky130_fd_sc_hd__dlxbp_1
Xs844 clknet_4_8_0_clk net508 VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__dlclkp_1
Xs877 clknet_4_10_0_clk net614 VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__dlclkp_2
Xs855 clknet_4_11_0_clk net568 VGND VGND VPWR VPWR net731 net730 sky130_fd_sc_hd__dfxbp_1
Xs866 net587 clknet_4_11_0_clk VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__dlxtn_1
Xs888 clknet_4_13_0_clk net645 VGND VGND VPWR VPWR net767 net766 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc740 net455 net562 net142 net923 net726 net743 VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__mux4_4
Xc762 net586 net79 net889 net515 net734 net757 VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__mux4_4
Xc751 net890 net593 net776 net607 net653 net705 VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__mux4_1
Xinput9 in16 VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c686_A2 net517 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_30_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c549_S0 net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s842_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c475_D net954 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c151_Y net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c144_X net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c409_X net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_rebuffer7_A net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c311_X net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c459_S0 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c680_X net536 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc570 net932 net303 net442 net433 net898 VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__o32a_1
Xc581 net89 net196 net453 VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__o21a_1
XFILLER_0_47_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc592 net453 net837 net452 clknet_1_0__leaf_net469 net351 net470 VGND VGND VPWR VPWR
+ net471 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c697_A1 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c111_B net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput110 net876 VGND VGND VPWR VPWR out7 sky130_fd_sc_hd__buf_2
XFILLER_0_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c726_S1 net517 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c742_S0 net419 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c189_S0 net893 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input47_A in50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net737 clknet_0_net737 VGND VGND VPWR VPWR clknet_1_1__leaf_net737
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c310_A1 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c310_B2 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c683_A3 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput12 in19 VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_12_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput34 in39 VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__clkbuf_4
Xinput45 in49 VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__clkbuf_4
Xinput23 in29 VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput56 in59 VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c221_A net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c737_S0 net690 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c245_S net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c67_Y net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c305_B2 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c694_A2 net540 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_73_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c588_A3 net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net702 net702 VGND VGND VPWR VPWR clknet_0_net702 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone26 net957 VGND VGND VPWR VPWR net956 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_23_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c224_X net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_187 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c406_B1 net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c467_S0 net679 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge779_S0 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c316_B1 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_89_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output78_A net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c201_A3 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c226_B1 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap131 net92 VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c734_S1 net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c553_A net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c750_S0 net692 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c197_S0 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c453_SCD net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge781_S1 net823 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_81_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c141_B net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc207 net108 net128 net6 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__a21boi_1
Xc218 net140 net94 net141 net138 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__a2bb2o_2
XANTENNA_c729_S1 net700 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_92_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc229 net778 net143 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__nor2_1
XFILLER_0_40_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c291_X net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c745_S0 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c480_S0 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs812 clknet_4_7_0_clk net338 VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__dlclkp_1
Xs823 clknet_4_2_0_clk net399 VGND VGND VPWR VPWR net696 net695 sky130_fd_sc_hd__dfxbp_1
Xs834 net489 clknet_4_9_0_clk VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__dlxtn_1
XTAP_TAPCELL_ROW_101_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs856 clknet_4_14_0_clk net570 VGND VGND VPWR VPWR net732 s856/Q_N sky130_fd_sc_hd__dfxbp_1
Xs845 clknet_4_8_0_clk net510 VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__dlclkp_2
XFILLER_0_36_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs867 net588 clknet_4_9_0_clk VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_91_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs878 clknet_4_8_0_clk net615 VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_36_499 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc730 net904 net381 net956 net102 net781 net722 VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__mux4_1
Xc752 net788 net566 net799 net699 clknet_1_0__leaf_net719 net728 VGND VGND VPWR VPWR
+ net611 sky130_fd_sc_hd__mux4_4
Xc763 net799 net618 net680 net751 net756 net758 VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__mux4_2
Xc741 net598 net81 net790 clknet_1_1__leaf_net469 net881 net743 VGND VGND VPWR VPWR
+ net600 sky130_fd_sc_hd__mux4_2
XANTENNA_input32_X net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c223_A1 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c596_A3 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c137_X net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c459_S1 clknet_1_0__leaf_net682 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c80_A_N net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_244 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc560 net763 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__buf_6
Xc571 net429 net337 net447 net336 net919 net898 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__mux4_4
Xc582 net762 VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__inv_1
XFILLER_0_47_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc593 net461 net465 net468 net776 net898 VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__a32o_1
XPHY_EDGE_ROW_16_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput100 net866 VGND VGND VPWR VPWR out52 sky130_fd_sc_hd__buf_2
Xoutput111 net877 VGND VGND VPWR VPWR out9 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c234_B1 net24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c299_A net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_34_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c742_S1 net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_43_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c421_X net321 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net592 clknet_0_net592 VGND VGND VPWR VPWR clknet_1_0__leaf_net592
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c128_B2 net863 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c189_S1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_52_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c310_A2 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c110_B_N net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput13 in2 VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__buf_4
XFILLER_0_71_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput46 in5 VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput35 in4 VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__clkbuf_4
Xinput24 in3 VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__buf_4
XANTENNA_c475_RESET_B net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput57 in6 VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_24_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c221_B net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c500_D net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c737_S1 net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_97_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c140_S net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c602_A0 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge803_GATE clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c215_A2 net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c269_B net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout132_X net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net736 net736 VGND VGND VPWR VPWR clknet_0_net736 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_51_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c405_B1_N net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c333_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c422_B1 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c483_S0 clknet_1_1__leaf_net681 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input62_X net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c332_A0 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c226_A1 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c174_Y net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c453_SCE net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input22_A in28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output109_A net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c327_B1 net815 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output90_A net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c252_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_53_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c134_B net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc208 net10 net892 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_92_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc219 net127 net3 net129 net136 net139 net79 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_5_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_101_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs813 clknet_4_7_0_clk net358 VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__dlclkp_2
XFILLER_0_76_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs824 clknet_4_2_0_clk net405 VGND VGND VPWR VPWR net697 s824/Q_N sky130_fd_sc_hd__dfxbp_1
XFILLER_0_36_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs857 clknet_4_14_0_clk net573 VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__dfxtp_4
Xs846 clknet_4_10_0_clk net512 VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__dlclkp_4
Xs868 net596 clknet_4_9_0_clk VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__dlxtn_1
Xs835 net490 clknet_4_11_0_clk VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_91_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xs879 net617 clknet_4_10_0_clk VGND VGND VPWR VPWR net756 s879/Q_N sky130_fd_sc_hd__dlxbn_1
XFILLER_0_63_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c147_A0 net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net396 net396 VGND VGND VPWR VPWR clknet_0_net396 sky130_fd_sc_hd__clkbuf_16
Xc720 net217 net825 net330 net899 net732 net734 VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__mux4_4
Xc731 net820 net456 net81 net381 net826 net933 VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__mux4_1
XANTENNA_c687_S net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc753 net282 net61 net2 net832 net712 clknet_1_0__leaf_net736 VGND VGND VPWR VPWR
+ net612 sky130_fd_sc_hd__mux4_4
Xc764 net71 net882 net619 net670 net713 net754 VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__mux4_1
Xc742 net225 net569 net314 clknet_1_1__leaf_net493 net419 net239 VGND VGND VPWR VPWR
+ net601 sky130_fd_sc_hd__mux4_2
XFILLER_0_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input25_X net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c610_A0 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c417_SCE net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c504_A1 net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c414_A1 net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c430_B1 net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c491_S0 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c605_A0 net891 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc550 net759 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__clkbuf_2
Xc561 net672 VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__clkbuf_1
Xc572 net669 VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__buf_6
Xc594 net467 clknet_1_0__leaf_net462 net422 net891 net364 net836 VGND VGND VPWR VPWR
+ net473 sky130_fd_sc_hd__mux4_2
Xc583 net230 net195 net833 net805 clknet_1_0__leaf_net683 VGND VGND VPWR VPWR net462
+ sky130_fd_sc_hd__o32ai_4
XFILLER_0_47_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c697_A3 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c335_SCD net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput101 net867 VGND VGND VPWR VPWR out53 sky130_fd_sc_hd__buf_2
XFILLER_0_88_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c128_A2 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c425_B1 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c285_A1_N net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput36 in40 VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__buf_2
Xinput14 in20 VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__buf_4
Xinput25 in30 VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__buf_2
XFILLER_0_24_223 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput47 in50 VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__buf_2
Xinput58 in60 VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_52_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c501_A2 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout122_A net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c576_A net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c753_S1 clknet_1_0__leaf_net736 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c411_A2 net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input52_A in55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_502 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c207_B1_N net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_7_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c324_A net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net737 net737 VGND VGND VPWR VPWR clknet_0_net737 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c217_Y net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c406_A2 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c422_B2 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c65_X net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input55_X net821 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c613_A0 net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c332_A1 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_223 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c226_A2 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c242_A1 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c274_A net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c539_A net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c327_X net855 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c494_S0 net24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input15_A in21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c608_A0 net426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c327_A1 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc209 net2 net133 net132 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__mux2_2
XANTENNA_c466_RESET_B net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c253_B1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s845_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input7_A in14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c284_Y net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c700_B2 net544 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs814 clknet_4_13_0_clk net359 VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__dlclkp_4
XANTENNA_c371_SCE net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs825 clknet_4_2_0_clk net406 VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_101_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c428_A0 net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs858 clknet_4_14_0_clk net575 VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs847 net514 clknet_4_8_0_clk VGND VGND VPWR VPWR net720 s847/Q_N sky130_fd_sc_hd__dlxbn_1
XFILLER_0_36_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs836 net491 clknet_4_9_0_clk VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_91_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs869 net597 clknet_4_9_0_clk VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__dlxtp_1
XANTENNA_c489_S0 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c147_A1 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc721 net305 net577 net533 net902 net733 clknet_1_1__leaf_net736 VGND VGND VPWR VPWR
+ net580 sky130_fd_sc_hd__mux4_4
Xc710 net238 net424 net186 net517 net781 clknet_1_1__leaf_net683 VGND VGND VPWR VPWR
+ net569 sky130_fd_sc_hd__mux4_4
Xc754 net546 net771 net788 net500 net752 net753 VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__mux4_4
Xc743 net591 clknet_1_0__leaf_net600 net921 net517 net381 net690 VGND VGND VPWR VPWR
+ net602 sky130_fd_sc_hd__mux4_2
Xc732 net418 net186 net882 net781 clknet_1_1__leaf_net682 net729 VGND VGND VPWR VPWR
+ net591 sky130_fd_sc_hd__mux4_2
XANTENNA_clkbuf_4_15_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input18_X net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge795_Q net660 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_30_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s827_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_78_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c711_A0 net411 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c491_S1 net834 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc540 net66 net303 net189 VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__o21ba_1
XFILLER_0_32_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc562 net415 net205 net434 net901 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__a22oi_2
Xc551 net430 net411 net61 VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__a21bo_1
Xc573 net97 net412 net896 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__o21ba_2
XANTENNA_s809_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc595 net443 net837 net896 net321 net18 net879 VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__mux4_4
Xc584 net196 net204 net898 VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__o21ba_1
XFILLER_0_86_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c335_SCE net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput102 net868 VGND VGND VPWR VPWR out54 sky130_fd_sc_hd__buf_2
XFILLER_0_2_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c234_A2 net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c250_A1 net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c142_X net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net594 clknet_0_net594 VGND VGND VPWR VPWR clknet_1_0__leaf_net594
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c113_B1_N net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c425_A1 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c425_B2 net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c441_B1 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c319_A2 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput37 in41 VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_12_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c616_A0 net24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput15 in21 VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__buf_4
Xinput26 in31 VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__clkbuf_2
Xinput59 in61 VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__buf_2
XFILLER_0_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput48 in51 VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_75_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc370 net273 net824 net287 net290 net160 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__o32ai_4
Xc392 net819 net60 net178 net135 net832 net811 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__mux4_4
XANTENNA_c501_A3 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_3_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c245_A1 net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout115_A net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c357_X net276 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c531_Y net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c436_B1 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c497_S0 net288 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input45_A in49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c602_A2 net452 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c171_B1 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c346_B1 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_84_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c324_B net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c422_A2 net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c243_S net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c166_B1 net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c613_A1 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c332_A2 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_58_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c274_B net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c759_S1 net700 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c714_A0 net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c494_S1 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c193_S net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_4_11_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c624_A0 net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_81_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c595_S0 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c253_B2 net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c463_A1_N net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c277_Y net196 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c172_X net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c437_X net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c709_A0 net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs815 net360 clknet_4_6_0_clk VGND VGND VPWR VPWR net685 net684 sky130_fd_sc_hd__dlxbn_1
XTAP_TAPCELL_ROW_101_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs848 net537 clknet_4_15_0_clk VGND VGND VPWR VPWR net722 net721 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_63_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xs826 clknet_4_10_0_clk net408 VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__dfxtp_1
Xs837 net492 clknet_4_3_0_clk VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__dlxtp_1
Xs859 clknet_4_14_0_clk net576 VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c489_S1 net680 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c147_A2 net823 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c62_A0 net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc700 net553 net548 net543 net899 net544 VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__o32a_2
Xc711 net411 net327 net557 net531 net536 net888 VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__mux4_1
Xc722 net237 net571 net892 net670 net733 clknet_1_1__leaf_net737 VGND VGND VPWR VPWR
+ net581 sky130_fd_sc_hd__mux4_4
Xc755 net18 net274 clknet_1_0__leaf_net493 net771 net914 net739 VGND VGND VPWR VPWR
+ net614 sky130_fd_sc_hd__mux4_4
Xc733 net900 net890 net808 clknet_1_1__leaf_net682 clknet_1_0__leaf_net737 net744
+ VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__mux4_2
Xc744 net550 net881 clknet_1_1__leaf_net600 net239 net654 net748 VGND VGND VPWR VPWR
+ net603 sky130_fd_sc_hd__mux4_4
XANTENNA_c163_A1 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_98_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c619_A0 net423 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c338_A1 net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c504_A3 net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c132_A net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_531 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c711_A1 net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c430_A2 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c439_A0 net332 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc530 net296 net777 VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__or2b_1
XANTENNA_c605_A2 net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc552 net427 net413 net425 VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__o21ai_1
Xc541 net415 net902 VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__and2_1
Xc563 net431 net777 net93 net319 net418 VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__o32a_1
Xc596 net16 net816 net467 net71 net896 net690 VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__mux4_1
Xc574 net318 net825 net651 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__o21ai_1
Xc585 net116 net823 net452 net898 VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__a22o_1
XANTENNA_input30_X net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c621_A1 net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c340_A2 net860 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c535_B1_N net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput103 net869 VGND VGND VPWR VPWR out55 sky130_fd_sc_hd__buf_2
XFILLER_0_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c250_A2 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c466_D net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_12_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c706_A1 net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c425_A2 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c408_B1_N net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c722_A0 net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_21_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net719 clknet_0_net719 VGND VGND VPWR VPWR clknet_1_1__leaf_net719
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c441_B2 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput27 in32 VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_37_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput16 in22 VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__clkbuf_4
Xinput49 in52 VGND VGND VPWR VPWR net815 sky130_fd_sc_hd__buf_2
XFILLER_0_24_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c616_A1 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput38 in42 VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__buf_2
XFILLER_0_52_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_75_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc371 clknet_4_0_0_clk net283 net934 net948 net668 VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__sdfrtp_1
Xc360 net272 net9 net798 net38 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c632_A0 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc393 net167 net49 net829 net289 net58 net663 VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_48_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c136_A_N net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge784_Q_N net646 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c436_B2 net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c436_A1 net823 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c497_S1 net851 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c452_B1 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input38_A in42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c171_A1 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c171_B2 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_306 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c627_A0 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c346_A1 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c346_B2 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c362_B1 net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc190 net115 net814 net114 net803 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__o22a_1
XFILLER_0_85_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c103_B1_N net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c465_SCE net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c422_A3 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone1 net67 net775 net778 VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__mux2_1
XFILLER_0_66_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c65_B1 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c166_B2 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c166_A1 net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_50_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c613_A2 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c332_A3 net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge795_GATE_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c528_B_N net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_1_1__f_net681_X clknet_1_1__leaf_net681 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout130_X net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c730_A0 net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_4_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c177_A0 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c70_X net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c327_A3 net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c361_SET_B net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input60_X net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output69_A net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c595_S1 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_92_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c253_A2 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c591_B1_N net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_77_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c709_A1 net546 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs816 net361 clknet_4_6_0_clk VGND VGND VPWR VPWR net687 net686 sky130_fd_sc_hd__dlxbn_1
XTAP_TAPCELL_ROW_101_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs827 clknet_4_13_0_clk net450 VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__dfxtp_2
Xs849 net555 clknet_4_15_0_clk VGND VGND VPWR VPWR net724 net723 sky130_fd_sc_hd__dlxbp_1
Xs838 net495 clknet_4_3_0_clk VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__lpflow_inputisolatch_1
XFILLER_0_48_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c147_A3 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c62_A1 net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c725_A0 net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_86_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc701 net542 net414 net557 net543 net433 net554 VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__mux4_4
Xc712 net465 net204 net822 net771 net652 net722 VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__mux4_1
Xc756 net340 net902 net206 net511 net613 net717 VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__mux4_2
Xc734 net452 net784 net807 net680 clknet_1_1__leaf_net682 net733 VGND VGND VPWR VPWR
+ net593 sky130_fd_sc_hd__mux4_4
Xc745 net459 net808 clknet_1_0__leaf_net574 net768 net769 net741 VGND VGND VPWR VPWR
+ net604 sky130_fd_sc_hd__mux4_4
XANTENNA_c163_A2 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc723 net822 net578 net566 net531 net325 net733 VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__mux4_1
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c460_A0 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input20_A in26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_95_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c610_A3 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output107_A net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c338_A2 net137 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c314_B1_N net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c132_B net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout138_A net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c439_A1 net328 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c455_B1 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c78_A net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc531 c531/A VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__inv_2
XFILLER_0_20_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c605_A3 net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc542 net299 net297 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__nand2_4
Xc553 net928 net417 VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__or2_4
Xc564 net417 net430 net431 VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__o21bai_2
Xc575 net412 net797 net2 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__a21oi_1
Xc597 net205 net374 net816 net891 net909 clknet_1_0__leaf_net701 VGND VGND VPWR VPWR
+ net476 sky130_fd_sc_hd__mux4_2
Xc586 net464 net424 net438 net461 net831 VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__o32a_1
XANTENNA_c190_B1 net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c568_SCD net331 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c349_A1 net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_15_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput104 net870 VGND VGND VPWR VPWR out56 sky130_fd_sc_hd__buf_2
XFILLER_0_2_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net574 clknet_0_net574 VGND VGND VPWR VPWR clknet_1_0__leaf_net574
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_53_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c302_Y net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c706_A2 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c441_A2 net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c453_RESET_B net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput17 in23 VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__buf_2
Xinput28 in33 VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__buf_2
XANTENNA_c185_B1 net893 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput39 in43 VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_75_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc372 net162 net291 net293 net840 net284 net288 VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__mux4_1
Xc361 clknet_4_0_0_clk net157 net816 net156 net273 net894 VGND VGND VPWR VPWR net281
+ net280 sky130_fd_sc_hd__sdfbbp_1
XANTENNA_c632_A1 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc350 clknet_4_4_0_clk net260 net265 net184 net245 net946 VGND VGND VPWR VPWR net268
+ c350/Q_N sky130_fd_sc_hd__sdfbbn_1
Xc394 net56 net863 net58 net664 net674 net858 VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_48_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s853_GATE clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c297_B net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c182_B1_N net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c717_A1 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c436_A2 net328 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c733_A0 net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c452_B2 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge780_A0 net331 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c362_A1 net137 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc180 net73 net95 net104 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__o21bai_1
Xc191 net116 net825 net819 net103 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__a22oi_4
XFILLER_0_85_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c548_B1_N net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout120_A net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone2 net812 net772 VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__or2_1
XFILLER_0_66_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c627_X net505 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c728_A0 net533 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c65_A1 net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c65_B2 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c166_A2 net897 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_50_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input50_A in53 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s857_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap125 net112 VGND VGND VPWR VPWR net891 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c155_A net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_416 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c215_Y net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout123_X net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c208_X net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c714_A2 net419 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge774_CLK_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c730_A1 net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c458_A0 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c608_A3 net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s839_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c63_X net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c193_A0 net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c624_A2 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input53_X net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c253_A3 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c272_A net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c544_B net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c537_A net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c709_A2 net566 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs839 clknet_4_8_0_clk net499 VGND VGND VPWR VPWR net712 s839/Q_N sky130_fd_sc_hd__dfxbp_1
Xs817 net376 clknet_4_6_0_clk VGND VGND VPWR VPWR net689 net688 sky130_fd_sc_hd__dlxbp_1
XFILLER_0_48_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xs828 clknet_4_12_0_clk net473 VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__dlclkp_1
XFILLER_0_16_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c62_A2 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc702 net525 net434 net523 net558 net834 net726 VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__mux4_1
Xc713 net796 net215 net314 net544 net920 net728 VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__mux4_2
XFILLER_0_31_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc746 net227 net239 net79 net558 net709 net730 VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__mux4_4
Xc735 net886 net781 clknet_1_1__leaf_net592 net768 net653 net680 VGND VGND VPWR VPWR
+ net594 sky130_fd_sc_hd__mux4_4
Xc724 net544 clknet_1_1__leaf_net574 net61 net558 net724 net738 VGND VGND VPWR VPWR
+ net583 sky130_fd_sc_hd__mux4_4
XFILLER_0_31_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc757 net771 net903 net503 net744 net746 net755 VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__mux4_1
XANTENNA_c460_A1 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input13_A in2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c351_Q net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c188_B1 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c696_S1 net332 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c635_A1 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output81_A net847 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c500_RESET_B net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net701 clknet_0_net701 VGND VGND VPWR VPWR clknet_1_0__leaf_net701
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_26_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c248_A3 net864 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input5_A in12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c711_A3 net531 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c661_B net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c280_A1 net196 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c707_X net566 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c736_A0 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c455_B2 net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc532 net636 VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__buf_1
Xc543 net301 net304 net416 VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__a21oi_2
Xc554 net794 net334 VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_9_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc565 net766 VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__inv_4
Xc576 net669 VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__inv_2
XANTENNA_c471_B1 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc598 net827 net474 net426 net337 clknet_1_0__leaf_net683 clknet_1_1__leaf_net701
+ VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__mux4_4
Xc587 net460 net781 net204 VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__a21boi_1
XANTENNA_c190_A1 net115 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c190_B2 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c621_A3 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c568_SCE net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input16_X net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c349_A2 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c431_B1_N net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput105 net871 VGND VGND VPWR VPWR out57 sky130_fd_sc_hd__buf_2
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c556_B1 net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c402_A net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c706_A3 net531 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c722_A2 net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input8_X net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput18 in24 VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__buf_2
XANTENNA_c185_B2 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput29 in34 VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__buf_4
XFILLER_0_91_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c616_A3 net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c486_SCD net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c252_SET_B net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc373 net761 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__inv_2
Xc362 net137 net855 net852 net278 VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__a22oi_4
XANTENNA_c632_A2 net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc351 clknet_4_4_0_clk net265 net268 net259 net115 VGND VGND VPWR VPWR net270 net269
+ sky130_fd_sc_hd__sdfrbp_1
Xc340 net83 net860 net207 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__o21ba_1
Xc395 net135 net182 net874 net819 net867 net658 VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c140_X net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c238_X net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c717_A2 net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c436_A3 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c733_A1 net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c443_A1_N net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout140 net802 VGND VGND VPWR VPWR net906 sky130_fd_sc_hd__buf_2
XFILLER_0_69_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c196_A0 net893 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c627_A2 net893 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge780_A1 net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c362_A2 net855 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc181 net75 net804 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__or2_2
Xc170 net95 net902 net86 net85 net72 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__a32o_2
Xc192 net117 net108 net118 net112 net61 net867 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__mux4_2
XFILLER_0_18_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_18_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net719 net719 VGND VGND VPWR VPWR clknet_0_net719 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c728_A1 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c689_SCD net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c334_A2_N net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c463_B2 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_18_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c182_A2 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input43_A in47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge784_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c148_A net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c714_A3 net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c103_X net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c730_A2 net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c73_B1_N net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c193_A1 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c624_A3 net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input46_X net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c161_A1_N net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c688_B1_N net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c559_B1 net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c537_B net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c158_Y net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs807 clknet_4_1_0_clk net145 VGND VGND VPWR VPWR net676 net675 sky130_fd_sc_hd__dfxbp_1
XTAP_TAPCELL_ROW_101_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs818 net385 clknet_4_3_0_clk VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__dlxtn_2
Xs829 clknet_4_12_0_clk net477 VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__dlclkp_2
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c294_A0 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c62_A3 net824 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c444_A3 net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc703 clknet_4_14_0_clk net549 net445 net558 net557 net940 VGND VGND VPWR VPWR net562
+ net561 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc714 net805 net899 net419 net433 net561 net459 VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__mux4_1
Xc736 net422 net536 clknet_1_0__leaf_net592 net558 net902 net788 VGND VGND VPWR VPWR
+ net595 sky130_fd_sc_hd__mux4_4
Xc747 net62 net225 net18 net726 net742 net947 VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__mux4_1
Xc725 net825 net583 net547 net225 clknet_1_0__leaf_net736 clknet_1_0__leaf_net737
+ VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__mux4_2
Xc758 net609 net34 net605 net599 net704 net731 VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__mux4_4
XANTENNA_c741_A1 net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c460_A2 net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c87_B1 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c619_A3 net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_556 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c370_A2 net824 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net702 clknet_0_net702 VGND VGND VPWR VPWR clknet_1_0__leaf_net702
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_clk_X clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c118_B net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c280_A2 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c268_X net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c289_B1 net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c439_A3 net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c73_A2 net864 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c736_A1 net536 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c455_A2 net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c204_S net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc500 clknet_4_3_0_clk net326 net784 net783 net384 net906 VGND VGND VPWR VPWR net404
+ c500/Q_N sky130_fd_sc_hd__sdfbbn_1
XANTENNA_c752_A0 net788 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc555 net336 net430 net416 VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__o21a_1
Xc544 net770 net831 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__and2b_2
Xc533 net904 net201 net777 VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_9_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc566 net440 net438 net445 VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__o21a_1
Xc588 net436 net833 net205 net446 net700 VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__a32o_1
Xc577 net352 net909 net70 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__o21ai_1
Xc599 net896 net892 net318 net16 net689 clknet_1_0__leaf_net702 VGND VGND VPWR VPWR
+ net478 sky130_fd_sc_hd__mux4_1
XFILLER_0_63_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c482_SET_B net690 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_71_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput106 net872 VGND VGND VPWR VPWR out59 sky130_fd_sc_hd__buf_2
XANTENNA_c256_SCE net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout143_A net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c747_A0 net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c84_B2 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c84_A1 net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c601_S0 net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c185_A2 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput19 in25 VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__buf_2
XANTENNA_c486_SCE net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc330 net184 net867 net104 net20 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__a22oi_4
XFILLER_0_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc352 net166 net768 net82 net821 net824 net905 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__mux4_2
Xc363 net136 net7 net244 net80 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__a22o_1
Xc341 net251 net257 net130 net211 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__a22oi_2
Xc396 net190 net81 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__or2b_1
XFILLER_0_20_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c392_A0 net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c133_X net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c717_A3 net452 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c300_X net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c733_A2 net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout130 net188 VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__buf_8
Xfanout141 net802 VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__buf_4
XANTENNA_c79_B2 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c627_A3 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c86_X net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge780_A2 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc160 net83 net777 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__nor2b_4
XFILLER_0_20_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc171 net88 net85 net73 net907 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__a22oi_4
XFILLER_0_85_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc193 net118 net867 net790 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__mux2_2
Xc182 net101 net822 net109 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__a21bo_2
XFILLER_0_18_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c188_Y net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c355_Y net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c728_A2 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c689_SCE net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c65_A3 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c744_A1 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input36_A in40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c129_SCD net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmax_cap116 net234 VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__buf_4
XFILLER_0_96_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c368_SCD net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c548_A2 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c315_B net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c308_A net821 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c580_B1 net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c730_A3 net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c739_A1 net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c458_A2 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c755_A0 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c490_A0 net821 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input39_X net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_0_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c559_A1 net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c265_B net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c559_B2 net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_5_0_clk_X clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs819 net388 clknet_4_3_0_clk VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__dlxtn_1
XPHY_EDGE_ROW_46_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs808 clknet_4_5_0_clk net240 VGND VGND VPWR VPWR net678 net677 sky130_fd_sc_hd__dfxbp_1
XANTENNA_c575_B1 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c318_Y net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c294_A1 net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_60_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s820_Q net692 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c725_A3 net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc704 net308 net330 net81 net204 net528 net890 VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__mux4_1
XFILLER_0_16_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc737 net551 net572 clknet_1_1__leaf_net469 net892 net690 net728 VGND VGND VPWR VPWR
+ net596 sky130_fd_sc_hd__mux4_2
Xc726 net540 net381 net790 net255 net546 net517 VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__mux4_1
Xc715 net303 net798 net770 clknet_1_0__leaf_net469 net894 net186 VGND VGND VPWR VPWR
+ net574 sky130_fd_sc_hd__mux4_2
Xc759 net784 net810 clknet_1_0__leaf_net574 net608 net616 net700 VGND VGND VPWR VPWR
+ net618 sky130_fd_sc_hd__mux4_4
XANTENNA_c741_A2 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc748 net457 net438 net795 net769 clknet_1_1__leaf_net683 clknet_1_1__leaf_net702
+ VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_55_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c460_A3 net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c162_B1_N net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c87_A1 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c604_S0 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_80_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_64_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c188_A2 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c635_A3 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_73_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c343_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output67_A net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net736 clknet_0_net736 VGND VGND VPWR VPWR clknet_1_0__leaf_net736
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c395_A0 net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c280_A3 net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer20 net321 VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_83_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c428_X net328 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c455_A3 net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc501 net31 net283 net889 net261 net691 net949 VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__mux4_1
XANTENNA_c752_A1 net566 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc545 net420 net424 net416 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__o21a_2
Xc534 net635 net413 VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_9_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc567 net439 net422 net898 net440 net212 net797 VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__mux4_2
Xc556 net300 net308 net901 VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__a21o_1
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c471_A2 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc578 net762 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__inv_2
Xc589 net463 net2 net651 VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__a21oi_1
XANTENNA_c454_Q net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge783_A2 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput107 net873 VGND VGND VPWR VPWR out6 sky130_fd_sc_hd__buf_2
XFILLER_0_10_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c689_RESET_B net540 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c556_A2 net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout136_A net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge767_SCD net419 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c280_X net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c545_X net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c747_A1 net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c84_A2 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c264_B_N net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c76_A net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c763_A0 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc320 net209 net772 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__or2b_1
XFILLER_0_58_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_75_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc353 net114 net897 net31 net82 net136 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__a32o_1
Xc331 net198 net207 net19 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__a21boi_2
Xc342 clknet_4_4_0_clk net256 net939 net118 net886 net936 VGND VGND VPWR VPWR net260
+ net259 sky130_fd_sc_hd__sdfbbp_1
Xc397 net827 net192 net187 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__a21o_2
Xc364 net897 net859 net75 net261 net840 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__o32ai_4
XFILLER_0_74_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input21_X net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_13_0_clk_X clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c223_B1_N net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c702_S0 net834 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c567_A1 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net396 clknet_0_net396 VGND VGND VPWR VPWR clknet_1_0__leaf_net396
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout139_X net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s878_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c583_B1 net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout120 net142 VGND VGND VPWR VPWR net886 sky130_fd_sc_hd__buf_4
Xfanout142 net802 VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c79_A2 net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c612_S0 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c196_A2 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c417_Q net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c493_B1 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc172 net97 net788 net64 net82 net798 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__a32o_1
XFILLER_0_20_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc150 net790 net62 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__and2_4
Xc161 net86 net805 net87 net907 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_85_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc183 net78 net803 net780 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__o21ai_4
Xc194 net104 net120 net118 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__o21ba_1
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c728_A3 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c760_A1 net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input29_A in34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge800_GATE_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge775_A3 net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap117 net212 VGND VGND VPWR VPWR net883 sky130_fd_sc_hd__clkbuf_2
XANTENNA_output97_A net863 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c411_B1_N net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c308_B net652 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c691_D net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c580_B2 net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c580_A1 net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_1_0_clk_X clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c572_A net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c193_X net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c359_SCE net660 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c739_A2 net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c458_A3 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c755_A1 net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c490_A1 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c662_A_N net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c584_B1_N net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_hold37_A net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net681 clknet_0_net681 VGND VGND VPWR VPWR clknet_1_1__leaf_net681
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c153_A net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs809 clknet_4_4_0_clk net267 VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_101_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c418_A net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c710_S0 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout121_X net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc716 net433 net73 net572 net798 net545 net733 VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__mux4_1
Xc727 net517 net769 net894 net709 net724 net742 VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__mux4_1
Xc738 net204 clknet_1_0__leaf_net592 clknet_1_0__leaf_net594 net572 net456 net726
+ VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__mux4_2
Xc705 net800 net822 net899 net62 net888 net330 VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__mux4_1
XFILLER_0_97_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc749 net595 net285 net890 net357 net694 net745 VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_4_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c177_S net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c87_A2 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_S0 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c485_A1 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_max_cap131_A net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net737 clknet_0_net737 VGND VGND VPWR VPWR clknet_1_0__leaf_net737
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c270_A net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c705_S0 net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer10 net918 VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer21 net321 VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c542_B net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c289_A2 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_65_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c330_Y net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c323_X net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c736_A3 net558 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc502 net150 net373 net294 net903 net884 net674 VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__mux4_1
XANTENNA_c752_A2 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc535 net298 net413 net189 VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__o21bai_4
Xc546 net424 net421 net423 net66 net416 net410 VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_9_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc568 clknet_4_13_0_clk net435 net336 net331 net898 VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__sdfrtp_1
Xc557 net416 net894 net436 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__o21bai_1
Xc579 net410 net839 net773 VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__mux2_1
XANTENNA_c471_A3 net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input11_A in18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput108 net874 VGND VGND VPWR VPWR out60 sky130_fd_sc_hd__buf_2
XFILLER_0_10_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput90 net856 VGND VGND VPWR VPWR out42 sky130_fd_sc_hd__buf_2
XFILLER_0_77_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c152_B1_N net635 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout129_A net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net682_A net682 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge767_SCE net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input3_A in10 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c435_S0 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c440_X net851 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c747_A2 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c76_B net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc310 net797 net204 net78 net207 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__a22oi_2
XFILLER_0_20_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc321 net232 net84 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_75_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c329_S1 net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input59_A in61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc332 net120 net78 net234 net241 net857 net806 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__mux4_2
Xc354 net7 net38 net855 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__o21bai_4
Xc343 clknet_4_4_0_clk net260 net255 net878 net883 net118 VGND VGND VPWR VPWR net875
+ net261 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_20_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc365 net625 VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__buf_6
Xc398 net790 net189 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__and2b_1
XANTENNA_merge778_A3 net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input14_X net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer1 net76 VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c702_S1 net726 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c567_A2 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout121 net889 VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__buf_4
Xfanout132 net446 VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__clkbuf_4
XANTENNA_input6_X net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout143 net792 VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__buf_4
XFILLER_0_69_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c758_A1 net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_45_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c612_S1 net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c477_A2 net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c493_A1 net795 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc151 net79 net65 net66 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__a21boi_4
Xc140 net67 net775 net778 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__mux2_4
Xc162 net778 net909 net82 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__a21bo_2
XFILLER_0_20_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc195 net119 net120 net99 net114 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__o22ai_4
Xc173 net892 net92 net786 net84 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__a22o_1
Xc184 net107 net822 net821 net77 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__o22ai_4
XANTENNA_merge804_Q net834 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge787_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c340_B1_N net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c744_A3 net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge786_CLK_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_58_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c488_A1 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c623_S0 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_442 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap118 net853 VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_33_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c146_B_N net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c679_A0 net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c708_S0 net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c186_X net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_rebuffer14_A net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c490_A2 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c618_S0 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input41_A in45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c499_A0 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c665_A2 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net682 clknet_0_net682 VGND VGND VPWR VPWR clknet_1_1__leaf_net682
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c153_B net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c146_A net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c575_A2 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c313_A net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_60_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc706 net557 net325 net771 net531 net545 net726 VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__mux4_4
Xc717 net571 net797 net239 net452 net547 net899 VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__mux4_1
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc728 net533 net784 net776 net799 net708 net741 VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__mux4_1
XANTENNA_c438_S0 net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc739 net547 net892 net773 clknet_1_1__leaf_net594 net781 clknet_1_1__leaf_net682
+ VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__mux4_4
XFILLER_0_97_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c530_B_N net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c112_B1 net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c87_A3 net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c99_A net635 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c620_S1 net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input44_X net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c551_B1_N net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c692_A0 net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c259_SCE net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c270_B net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer11 net900 VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c705_S1 net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c528_A net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c721_S0 net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c586_B2 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c316_X net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc503 net833 net910 net288 net906 net657 VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__o32ai_4
Xc536 net877 net410 VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_9_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc558 net759 VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__buf_6
Xc569 net441 net447 net437 net334 net779 net898 VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__mux4_1
Xc547 net304 net296 net424 net423 net831 net417 VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__mux4_2
XFILLER_0_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c496_A1 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c631_S0 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput109 net875 VGND VGND VPWR VPWR out61 sky130_fd_sc_hd__buf_2
XFILLER_0_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output72_A net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput91 net857 VGND VGND VPWR VPWR out44 sky130_fd_sc_hd__buf_2
XFILLER_0_37_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput80 net846 VGND VGND VPWR VPWR out30 sky130_fd_sc_hd__buf_2
XFILLER_0_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c130_D net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_14_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c544_A_N net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c435_S1 net328 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c266_X net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c597_A0 net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c538_Y net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c747_A3 net726 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c763_A2 net680 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c69_B net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc300 net85 net215 net211 net209 net907 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__a32o_2
XFILLER_0_20_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc311 net210 net118 net77 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__o21ba_2
XTAP_TAPCELL_ROW_75_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc344 net69 net249 net254 net678 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__o22a_2
Xc333 clknet_4_4_0_clk net130 net246 net907 net9 net886 VGND VGND VPWR VPWR net248
+ net247 sky130_fd_sc_hd__sdfbbn_1
Xc322 net237 net203 net652 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__o21a_2
Xc366 clknet_4_0_0_clk net113 net23 net7 net894 net283 VGND VGND VPWR VPWR net285
+ net284 sky130_fd_sc_hd__sdfbbn_1
Xc355 net115 net910 net859 net884 net162 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__o32ai_4
Xc399 net66 net190 net297 VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__o21bai_2
XANTENNA_c626_S0 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge784_Q net647 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer2 net910 VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c392_A3 net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c417_CLK_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c210_B1 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_610 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c567_A3 net440 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout141_A net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_88_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c400_B net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c583_A2 net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout122 net889 VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__buf_2
XANTENNA_c64_S0 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout133 net446 VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c477_A3 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c81_A net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c493_A2 net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc141 net812 net772 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__or2_4
Xc130 clknet_4_0_0_clk net776 net57 net56 net863 net50 VGND VGND VPWR VPWR net874
+ net59 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_20_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc163 net799 net74 net907 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__o21bai_4
Xc152 net65 net77 net635 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__o21ba_4
XFILLER_0_20_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc174 net98 net827 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__nor2b_2
Xc185 net814 net73 net893 net909 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__o22a_4
Xc196 net893 net77 net104 net121 net795 net79 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c713_S1 net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c488_A2 net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c91_Y net24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c84_X net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c679_A1 net419 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge767_RESET_B net517 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c580_A3 net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c708_S1 net544 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c398_B net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c293_A net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c755_A3 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c490_A3 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c618_S1 net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input34_A in39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c634_S0 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc90 net4 net12 net21 VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__a21boi_2
XFILLER_0_97_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c681_A2 net533 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net683 clknet_0_net683 VGND VGND VPWR VPWR clknet_1_1__leaf_net683
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_226 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c139_A net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_60_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc718 net777 net894 net807 net516 net727 net733 VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__mux4_1
Xc707 net105 net516 net186 net418 net790 net550 VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__mux4_2
XFILLER_0_12_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc729 net70 net255 net418 net438 net781 net700 VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__mux4_4
XANTENNA_c719_S0 net734 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c591_A2 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c438_S1 net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c675_A net647 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_68_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c112_A1 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c485_A3 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c629_S0 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input37_X net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_42_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c303_B1 net860 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c395_A3 net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_51_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c692_A1 net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_60_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s841_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c213_B1 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer12 net900 VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_65_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net480 clknet_0_net480 VGND VGND VPWR VPWR clknet_1_1__leaf_net480
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c149_Y net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c309_X net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc537 net191 net413 VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_9_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc504 net384 net830 net271 net884 net647 net693 VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__mux4_1
Xc559 net438 net324 net430 net892 net887 VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__o32ai_1
Xc548 net421 net832 net201 VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__a21bo_1
XFILLER_0_79_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c496_A2 net847 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net681 net681 VGND VGND VPWR VPWR clknet_0_net681 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput70 net836 VGND VGND VPWR VPWR out19 sky130_fd_sc_hd__buf_2
XANTENNA_output65_A net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge805_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput92 net858 VGND VGND VPWR VPWR out45 sky130_fd_sc_hd__buf_2
Xoutput81 net847 VGND VGND VPWR VPWR out31 sky130_fd_sc_hd__buf_2
XFILLER_0_37_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c399_B1_N net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c360_A2_N net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c687_A1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c469_RESET_B net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s814_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c716_S1 net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc301 net215 net213 net205 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__o21ai_4
Xc312 net77 net799 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_75_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc323 net672 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__buf_6
Xc334 net244 net213 net864 net198 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__o2bb2a_1
Xc345 net253 net87 net135 net245 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc367 clknet_4_0_0_clk net158 net281 net283 net801 net166 VGND VGND VPWR VPWR net287
+ net286 sky130_fd_sc_hd__sdfbbn_1
Xc356 net129 net906 net231 net273 net31 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__a32o_1
XANTENNA_c626_S1 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c300_B2 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge800 net264 clknet_4_4_0_clk net266 VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__dlrtn_1
XFILLER_0_67_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer3 net76 VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c210_B2 net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c414_B1_N net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c583_A3 net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout112 net144 VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__buf_4
XANTENNA_c64_S1 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout123 net302 VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__buf_4
Xfanout134 net333 VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__buf_12
XFILLER_0_64_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c493_A3 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc120 net29 net843 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__or2b_2
XFILLER_0_33_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc153 net81 net70 VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__and2_4
Xc131 net52 net863 net59 net841 net671 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__o32ai_1
XFILLER_0_20_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc142 net827 net774 net773 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__o21a_4
Xc186 net108 net111 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__and2_4
Xc175 net99 net101 net98 net894 net798 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__o32a_2
Xc164 net77 net828 net909 net771 net782 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__o32ai_4
Xc197 net121 net809 net109 net112 net120 c197/S1 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__mux4_1
XFILLER_0_87_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c684_A2 net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c587_B1_N net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c547_S0 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_A2 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout137_X net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c351_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c493_X net847 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c192_S0 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c488_A3 net824 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge769_S0 net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c415_Q net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c342_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c306_B1 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c695_A1 net531 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c216_B1 net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_6_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c293_B net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c286_A net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c589_A2 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c740_S0 net726 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c126_B1 net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input27_A in32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c499_A2 net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c634_S1 net700 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc91 net798 net772 VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__nand2b_4
Xc80 net1 net4 VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__nand2b_2
XFILLER_0_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c681_A3 net531 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c691_SCD net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc719 net807 net419 net551 net733 net734 net735 VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__mux4_1
Xc708 net531 net332 net820 net231 net892 net544 VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__mux4_1
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c456_X net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c629_S1 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c303_B2 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c213_B2 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c368_D net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer13 net333 VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_65_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c586_A3 net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s811_Q net680 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc505 net407 net316 net836 net288 net697 net698 VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__mux4_4
Xc549 net427 net420 net424 net428 net418 net421 VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__mux4_1
Xc538 net823 net776 VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__nor2_4
XANTENNA_c580_Y net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c573_X net452 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_14_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net682 net682 VGND VGND VPWR VPWR clknet_0_net682 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_50_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput71 net837 VGND VGND VPWR VPWR out2 sky130_fd_sc_hd__clkbuf_4
Xoutput82 net848 VGND VGND VPWR VPWR out32 sky130_fd_sc_hd__buf_2
Xoutput93 net859 VGND VGND VPWR VPWR out46 sky130_fd_sc_hd__buf_2
XFILLER_0_37_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c199_A net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c597_A2 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c154_X net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c426_Y net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc302 net763 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__inv_6
XFILLER_0_32_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_75_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc324 net882 net807 VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__nand2_4
XFILLER_0_32_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc335 clknet_4_4_0_clk net246 net931 net799 net886 VGND VGND VPWR VPWR net251 net250
+ sky130_fd_sc_hd__sdfrbp_1
Xc313 net780 net84 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__or2b_2
Xc368 clknet_4_2_0_clk net801 net113 net191 net283 net893 VGND VGND VPWR VPWR net289
+ net288 sky130_fd_sc_hd__sdfbbp_1
Xc357 net626 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__buf_1
Xc346 net213 net248 net878 net234 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_86_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c300_A2 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge801 net471 clknet_4_12_0_clk net630 VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__dlrtn_2
XFILLER_0_28_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c309_B1 net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer4 net912 VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_11_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c698_A1 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout127_A net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout113 net369 VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__clkbuf_4
Xfanout135 net325 VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__buf_4
Xfanout124 net103 VGND VGND VPWR VPWR net890 sky130_fd_sc_hd__buf_4
XANTENNA_input1_A in0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c743_S0 net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c543_Y net423 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_53_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c67_A net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc110 net22 net791 VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__or2b_1
XFILLER_0_33_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc132 net790 net770 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__and2_4
Xc143 net71 net64 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__nand2_4
Xc154 net65 net69 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__and2_4
Xc121 net48 net50 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__and2b_1
XANTENNA_s847_GATE_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input57_A in6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c158_B_N net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc187 net114 net101 net112 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__o21ai_4
Xc176 net823 net99 net907 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__mux2_4
Xc165 net89 net92 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__nand2b_1
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc198 net94 net786 net9 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__mux2_2
XANTENNA_input12_X net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c372_S1 net288 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c502_A0 net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_2_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c594_A3 net891 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_72_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge802_GATE clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input4_X net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c473_S0 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c192_S1 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge769_S1 net652 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c322_B1 net652 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c181_A net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c286_B net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c279_A net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c86_S0 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c407_B1 net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c427_B1_N net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c126_B2 net863 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c142_B1 net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c499_A3 net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc92 net21 net817 net816 VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__a21boi_4
Xc81 net11 net13 VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__and2_1
Xc70 net5 net787 VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__and2_2
XFILLER_0_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c260_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c691_SCE net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge767_SET_B net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c227_B1 net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc709 net528 net546 net566 net899 clknet_1_1__leaf_net682 net727 VGND VGND VPWR VPWR
+ net568 sky130_fd_sc_hd__mux4_4
XANTENNA_c289_Y net860 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c735_S1 net680 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c191_Y net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_rebuffer12_A net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c303_A2 net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_10_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net719 clknet_0_net719 VGND VGND VPWR VPWR clknet_1_0__leaf_net719
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_100_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_5_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c692_A3 net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_hold28_A net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c213_A2 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_65_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer14 net922 VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__dlygate4sd1_1
Xclkbuf_1_1__f_net493 clknet_0_net493 VGND VGND VPWR VPWR clknet_1_1__leaf_net493
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c144_A net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout112_X net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc528 net62 net81 VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__nor2b_1
XTAP_TAPCELL_ROW_9_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc539 net413 net416 VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__or2_4
XFILLER_0_12_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c566_X net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c307_A2_N net860 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c481_S0 net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c457_A2_N net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c343_SCD net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net683 net683 VGND VGND VPWR VPWR clknet_0_net683 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput83 net849 VGND VGND VPWR VPWR out33 sky130_fd_sc_hd__buf_2
Xoutput72 net838 VGND VGND VPWR VPWR out20 sky130_fd_sc_hd__buf_2
XANTENNA_input42_X net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput94 net860 VGND VGND VPWR VPWR out47 sky130_fd_sc_hd__buf_2
XANTENNA_c314_A1 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c330_B1 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c240_B1 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c597_A3 net891 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c321_Y net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc303 net209 net205 net860 net218 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__a22o_1
XFILLER_0_4_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc336 clknet_4_4_0_clk net943 net130 net120 net246 net816 VGND VGND VPWR VPWR net253
+ net252 sky130_fd_sc_hd__sdfbbn_1
Xc314 net806 net91 net825 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__o21bai_4
Xc325 net238 net78 net226 net225 net954 net652 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__mux4_1
Xc369 clknet_4_2_0_clk net82 net262 net859 net784 net288 VGND VGND VPWR VPWR net291
+ net290 sky130_fd_sc_hd__sdfbbn_1
Xc358 net161 net244 net24 net125 net199 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__a32o_1
Xc347 net78 net104 net135 net257 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__o22a_1
XFILLER_0_99_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c300_A3 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge802 net563 clknet_4_14_0_clk net564 VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__dlrtp_1
XFILLER_0_23_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c309_B2 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c309_A1 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_11_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net480 net480 VGND VGND VPWR VPWR clknet_0_net480 sky130_fd_sc_hd__clkbuf_16
Xrebuffer5 net913 VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c325_A0 net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output70_A net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap125_X net891 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c698_A2 net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_19_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c219_A1 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout114 net369 VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__clkbuf_2
Xfanout136 net68 VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__buf_6
XANTENNA_c743_S1 net690 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c264_X net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c529_X net411 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c200_S net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc111 net5 net904 VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__nand2_1
Xc100 net817 net829 VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__nand2b_1
XFILLER_0_60_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc144 net61 net67 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__or2b_4
Xc133 net781 net812 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__or2b_4
Xc122 net36 net43 net47 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__mux2_1
Xc155 net82 net64 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__and2_2
Xc166 net66 net897 net902 net905 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__a22o_1
Xc177 net104 net98 net909 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__mux2_2
Xc199 net803 net117 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__nor2_1
Xc188 net0 net111 net86 net110 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__a22oi_4
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c311_A2 net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_50_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c738_S1 net726 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_72_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c412_B2 net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c473_S1 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c131_A2 net863 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c603_A0 net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c322_A1 net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c181_B net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout142_X net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c407_B2 net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c407_A1 net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c86_S1 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c126_A2 net635 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c484_S0 net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c198_S net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s862_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c142_A1 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc93 net23 net15 VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__nand2_1
Xc71 net5 net768 net816 VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__mux2_2
Xc82 net12 net909 net836 net810 net804 VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__o32a_2
XFILLER_0_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c82_X net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c569_S0 net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c227_A1 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s844_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c184_Y net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c177_X net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c449_Y net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c344_X net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input32_A in37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_11_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c600_A1 net891 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_20_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer15 net189 VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c571_S1 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c238_B1 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc529 net312 net299 VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__and2b_2
XTAP_TAPCELL_ROW_9_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c762_S0 net734 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c97_B net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c343_SCE net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s808_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput73 net839 VGND VGND VPWR VPWR out21 sky130_fd_sc_hd__clkbuf_4
Xoutput84 net850 VGND VGND VPWR VPWR out35 sky130_fd_sc_hd__buf_2
Xoutput95 net861 VGND VGND VPWR VPWR out48 sky130_fd_sc_hd__buf_2
XANTENNA_input35_X net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c611_A0 net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c330_A1 net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c505_A1 net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c224_A2 net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c240_B2 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc304 net217 net204 net215 net198 net207 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__o32a_1
XFILLER_0_20_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc315 net107 net227 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__nand2b_4
Xc326 net226 net229 net677 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__a21oi_4
Xc359 clknet_4_2_0_clk net125 net793 net271 net660 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__sdfrtn_1
Xc348 net258 net782 net941 net265 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__a22o_1
Xc337 net241 net852 net82 net855 net247 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__a32o_1
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c492_S0 net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge803 net55 clknet_4_1_0_clk net638 VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__dlrtp_2
XFILLER_0_95_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer6 net65 VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c606_A0 net815 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c325_A1 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c698_A3 net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap118_X net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c107_B net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout137 net324 VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__buf_4
Xfanout126 net100 VGND VGND VPWR VPWR net892 sky130_fd_sc_hd__buf_4
Xfanout115 net340 VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__buf_4
XFILLER_0_77_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c431_Y net331 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c426_B1 net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc101 net23 net30 net29 VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__a21bo_2
XANTENNA_c487_S0 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc112 net776 net12 net779 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__o21ai_1
Xc123 net52 net43 VGND VGND VPWR VPWR net863 sky130_fd_sc_hd__or2_4
Xc145 net902 net774 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__and2_4
Xc134 net769 net827 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__and2b_4
Xc167 net94 net897 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__nand2_1
Xc178 net774 net778 net104 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__a21o_2
Xc156 net801 net83 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__and2b_1
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc189 net814 net110 net810 net808 net893 net905 VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__mux4_2
XFILLER_0_87_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output101_A net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc690 net518 net79 net899 net544 VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_75_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_3_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout132_A net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c129_Q net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c72_A net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input62_A in9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_76_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c453_D net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout135_X net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s827_Q net700 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c407_A2 net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c704_A0 net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c484_S1 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c142_A2 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc94 net22 net801 net830 VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__a21oi_2
Xc83 net17 net14 VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__or2_4
Xc72 net806 net6 VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__nor2_1
XFILLER_0_85_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c75_X net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c317_A2 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c614_A0 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c569_S1 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c227_A2 net115 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c91_A_N net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c495_S0 net893 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold40 net695 VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input25_A in30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c600_A2 net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c609_A0 net321 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c328_A1 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_244 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output93_A net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer27 net333 VGND VGND VPWR VPWR net957 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer16 net74 VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net462 clknet_0_net462 VGND VGND VPWR VPWR clknet_1_1__leaf_net462
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge801_GATE_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c137_B net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c238_B2 net24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c254_B1 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c673_B net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c287_X net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c336_SET_B net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c429_B1 net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c164_B1 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput85 net851 VGND VGND VPWR VPWR out36 sky130_fd_sc_hd__clkbuf_4
Xoutput63 net829 VGND VGND VPWR VPWR out1 sky130_fd_sc_hd__buf_2
Xoutput74 net840 VGND VGND VPWR VPWR out23 sky130_fd_sc_hd__buf_2
Xoutput96 net862 VGND VGND VPWR VPWR out49 sky130_fd_sc_hd__buf_2
XANTENNA_input28_X net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c330_A2 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c505_A2 net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c179_B_N net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
.ends
