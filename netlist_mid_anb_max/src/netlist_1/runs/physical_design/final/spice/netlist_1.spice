* NGSPICE file created from netlist_1.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_16 abstract view
.subckt sky130_fd_sc_hd__buf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_1 abstract view
.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_2 abstract view
.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtn_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtn_1 CLK_N D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_1 abstract view
.subckt sky130_fd_sc_hd__dlrtp_1 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_4 abstract view
.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_4 abstract view
.subckt sky130_fd_sc_hd__o2111a_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_2 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_2 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtn_1 abstract view
.subckt sky130_fd_sc_hd__dfrtn_1 CLK_N D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_2 abstract view
.subckt sky130_fd_sc_hd__or4bb_2 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_4 abstract view
.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_0 abstract view
.subckt sky130_fd_sc_hd__and2_0 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_4 abstract view
.subckt sky130_fd_sc_hd__mux4_4 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_2 abstract view
.subckt sky130_fd_sc_hd__o2111a_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_4 abstract view
.subckt sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_1 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_4 abstract view
.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfrbp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_2 abstract view
.subckt sky130_fd_sc_hd__dlrtp_2 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_8 abstract view
.subckt sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbp_1 CLK D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q
+ Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_4 abstract view
.subckt sky130_fd_sc_hd__a2111oi_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxbp_1 abstract view
.subckt sky130_fd_sc_hd__edfxbp_1 CLK D DE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_2 abstract view
.subckt sky130_fd_sc_hd__a2111o_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxbp_1 abstract view
.subckt sky130_fd_sc_hd__sedfxbp_1 CLK D DE SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_4 abstract view
.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfsbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfsbp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_1 abstract view
.subckt sky130_fd_sc_hd__dfsbp_1 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_2 abstract view
.subckt sky130_fd_sc_hd__o2111ai_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_1 abstract view
.subckt sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_4 abstract view
.subckt sky130_fd_sc_hd__and2b_4 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_2 abstract view
.subckt sky130_fd_sc_hd__dfstp_2 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_8 abstract view
.subckt sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfbbn_1 abstract view
.subckt sky130_fd_sc_hd__dfbbn_1 CLK_N D RESET_B SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__lpflow_inputisolatch_1 abstract view
.subckt sky130_fd_sc_hd__lpflow_inputisolatch_1 D SLEEP_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_2 abstract view
.subckt sky130_fd_sc_hd__dlrbn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_1 abstract view
.subckt sky130_fd_sc_hd__dlclkp_1 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_1 abstract view
.subckt sky130_fd_sc_hd__dfxbp_1 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_2 abstract view
.subckt sky130_fd_sc_hd__a2111oi_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxbp_2 abstract view
.subckt sky130_fd_sc_hd__sedfxbp_2 CLK D DE SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_1 abstract view
.subckt sky130_fd_sc_hd__dlxtn_1 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_1 abstract view
.subckt sky130_fd_sc_hd__dlrbn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_2 abstract view
.subckt sky130_fd_sc_hd__dlclkp_2 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_4 abstract view
.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbp_1 abstract view
.subckt sky130_fd_sc_hd__dlrbp_1 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_4 abstract view
.subckt sky130_fd_sc_hd__dlclkp_4 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_1 abstract view
.subckt sky130_fd_sc_hd__dlxbn_1 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtp_1 abstract view
.subckt sky130_fd_sc_hd__dlxtp_1 D GATE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbp_1 abstract view
.subckt sky130_fd_sc_hd__dlxbp_1 D GATE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfstp_2 abstract view
.subckt sky130_fd_sc_hd__sdfstp_2 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfstp_1 abstract view
.subckt sky130_fd_sc_hd__sdfstp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_4 abstract view
.subckt sky130_fd_sc_hd__and3b_4 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_2 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_2 abstract view
.subckt sky130_fd_sc_hd__dfxbp_2 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_4 abstract view
.subckt sky130_fd_sc_hd__a2111o_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_1 abstract view
.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxtp_1 abstract view
.subckt sky130_fd_sc_hd__edfxtp_1 CLK D DE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_1 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_1 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_1 abstract view
.subckt sky130_fd_sc_hd__dlrtn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_2 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_2 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_2 abstract view
.subckt sky130_fd_sc_hd__dlrtn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_4 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_4 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_2 abstract view
.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_2 abstract view
.subckt sky130_fd_sc_hd__dfrbp_2 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

.subckt netlist_1 VGND VPWR clk in0 in1 in10 in11 in12 in13 in14 in15 in16 in17 in18
+ in19 in2 in20 in21 in22 in23 in24 in25 in26 in27 in28 in29 in3 in30 in31 in32 in33
+ in34 in35 in36 in37 in38 in39 in4 in40 in41 in42 in43 in44 in45 in46 in47 in48 in49
+ in5 in50 in51 in52 in53 in54 in55 in56 in57 in58 in59 in6 in60 in61 in7 in8 in9
+ out0 out1 out10 out11 out12 out13 out14 out15 out16 out17 out18 out19 out2 out20
+ out21 out22 out23 out24 out25 out26 out27 out28 out29 out3 out30 out31 out32 out33
+ out34 out35 out36 out37 out38 out39 out4 out40 out41 out42 out43 out44 out45 out46
+ out47 out48 out49 out5 out50 out51 out52 out53 out54 out55 out56 out57 out58 out59
+ out6 out60 out61 out7 out8 out9 rst
XFILLER_0_94_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net281 clknet_0_net281 VGND VGND VPWR VPWR clknet_1_1__leaf_net281
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_27_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c247_A net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout162_A net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c421_B net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c202_X net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc305 net645 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__buf_16
XFILLER_0_13_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc327 clknet_1_1__leaf_net238 clknet_1_0__leaf_net243 net123 net113 net241 VGND VGND
+ VPWR VPWR net246 sky130_fd_sc_hd__o2111ai_1
Xc316 net118 net218 net126 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__and3b_1
XFILLER_0_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge805_GATE clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc338 net133 net872 net91 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__nand3b_2
Xc349 clknet_4_1_0_clk clknet_1_1__leaf_net243 net245 net264 net258 VGND VGND VPWR
+ VPWR net268 sky130_fd_sc_hd__sdfrtn_1
XANTENNA_c712_B1 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c153_A_N net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge815 clknet_4_5_0_clk net395 net294 VGND VGND VPWR VPWR net689 net856 sky130_fd_sc_hd__dfrbp_1
XFILLER_0_83_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge804 net450 clknet_4_10_0_clk net643 VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__dlrtp_1
XFILLER_0_95_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer7 net77 VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c175_C1 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge771_D_N net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c683_S0 net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c341_A1 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_74_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c235_A2 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout149 net300 VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__buf_8
XANTENNA_c135_A_N net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c152_X net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c707_A0 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc102 net37 net774 net934 VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__nand3_2
XANTENNA_c487_S1 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc113 net46 net38 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__nor2_1
Xc124 net31 net46 net785 net57 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__or4bb_1
Xc135 net768 net811 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__nand2b_2
Xc157 net87 net777 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__or2_2
Xc168 net797 net85 net97 net88 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__or4bb_4
Xc146 net73 net929 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__or2b_4
Xc179 net90 net821 net807 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__or3_4
XFILLER_0_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c352_B1 net258 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc691 net551 net543 net800 net994 net737 VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__o2111ai_1
Xc680 net424 net735 VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__nor2_1
XANTENNA_c502_A3 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_6_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c586_B net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c216_SCE net795 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c579_A net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c498_S0 net658 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c72_B net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c65_A net788 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input55_A in58 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c172_A0 net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input10_X net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_29_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c167_B net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge767_C_N net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c612_SET_B net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c704_A1 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input2_X net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c720_A0 net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc84 net4 net20 net16 net940 net816 VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__o2111a_4
Xc62 net806 net782 net788 net939 net823 net769 VGND VGND VPWR VPWR net0 sky130_fd_sc_hd__mux4_1
Xc73 net795 net4 net9 VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__nor3_1
Xc95 net799 net20 VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__and2b_2
XTAP_TAPCELL_ROW_26_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c373_SCD net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire133 net899 VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__clkbuf_1
Xwire144 net62 VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c75_Y net13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c464_D1 net681 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c630_A0 net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s864_SLEEP_B clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net699 clknet_0_net699 VGND VGND VPWR VPWR clknet_1_1__leaf_net699
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c715_A0 net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c495_S1 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold63 net375 VGND VGND VPWR VPWR net1010 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold52 net358 VGND VGND VPWR VPWR net999 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input18_A in24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c600_A3 net304 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c609_A1 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_5 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output86_A net851 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c344_A1 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c585_SCD net851 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer17 net65 VGND VGND VPWR VPWR net964 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_65_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer28 net974 VGND VGND VPWR VPWR net975 sky130_fd_sc_hd__buf_2
Xrebuffer39 net982 VGND VGND VPWR VPWR net986 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_88_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c429_A1 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c63_A0 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net697 net697 VGND VGND VPWR VPWR clknet_0_net697 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net686 net686 VGND VGND VPWR VPWR clknet_0_net686 sky130_fd_sc_hd__clkbuf_16
XANTENNA_rebuffer10_A net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput64 net829 VGND VGND VPWR VPWR out1 sky130_fd_sc_hd__clkbuf_4
Xoutput75 net840 VGND VGND VPWR VPWR out2 sky130_fd_sc_hd__buf_2
Xoutput86 net851 VGND VGND VPWR VPWR out3 sky130_fd_sc_hd__clkbuf_4
Xoutput97 net862 VGND VGND VPWR VPWR out4 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_86_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c240_A3 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c247_B net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c142_A net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_8_0_clk_X clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c407_A net302 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc306 net800 net951 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__nor2_1
Xc317 net108 net900 net785 net96 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__or4bb_1
XFILLER_0_13_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc328 clknet_4_2_0_clk net220 net989 net946 net241 clknet_1_0__leaf_net243 VGND VGND
+ VPWR VPWR net248 net247 sky130_fd_sc_hd__sdfbbn_2
Xc339 net256 net251 net922 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__and3_2
XFILLER_0_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge816 clknet_4_4_0_clk net646 net630 VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__dfrtn_1
Xmerge805 net249 clknet_4_2_0_clk net638 VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__dlrtp_1
XFILLER_0_36_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_11_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer8 net838 VGND VGND VPWR VPWR net955 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c175_B1 net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_97_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c325_A3 net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c622_A1 net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c683_S1 net408 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s842_GATE_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net338 clknet_0_net338 VGND VGND VPWR VPWR clknet_1_0__leaf_net338
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c235_A3 net44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c210_C_N net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c357_A net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c531_B net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net850 clknet_0_net850 VGND VGND VPWR VPWR clknet_1_0__leaf_net850
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout158_X net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c707_A1 net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc114 net25 net46 net12 net47 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__or4bb_2
Xc125 net8 net57 net15 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__or3b_1
Xc103 net26 net33 net16 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__nand3_1
XFILLER_0_20_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc136 net66 net773 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__nor2_2
XFILLER_0_13_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc169 net96 net98 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__nand2b_2
Xc147 net928 net778 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__and2_4
Xc158 net88 net853 net86 net784 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__or4bb_4
XFILLER_0_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c633_A0 net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s883_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c352_A1 net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc681 net413 net529 net421 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__and3_1
Xc670 net527 net303 net529 net525 net521 net528 VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__mux4_1
Xc692 net433 net550 net770 net536 net529 net669 VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__mux4_1
XFILLER_0_75_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s875_GATE clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c535_CLK_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c112_B net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c262_A1 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c579_B net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c437_A1 net336 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c65_B net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c172_A1 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input48_A in51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c628_A0 net298 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s856_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c167_C net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c404_C_N net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c108_X net44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c689_A net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c704_A2 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc63 net939 net807 net805 net825 net769 net938 VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__mux4_2
Xc85 net8 net21 net930 net868 net15 VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__o2111ai_4
Xc74 net815 net11 net8 VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__or3_2
XFILLER_0_97_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc96 net787 net820 VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__and2_0
XTAP_TAPCELL_ROW_26_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c265_A_N net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_rebuffer40_A net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire134 net855 VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c68_Y net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c464_C1 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c614_A2 net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_72_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c451_C net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_9_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge783_D net439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net857 net857 VGND VGND VPWR VPWR clknet_0_net857 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c731_A0 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold53 net145 VGND VGND VPWR VPWR net1000 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 net740 VGND VGND VPWR VPWR net1011 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c80_X net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c475_D1 net658 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c673_SET_B net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c344_A2 clknet_1_1__leaf_net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer18 net194 VGND VGND VPWR VPWR net965 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_88_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer29 net367 VGND VGND VPWR VPWR net976 sky130_fd_sc_hd__buf_6
XFILLER_0_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c596_S1 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c561_B net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c342_X net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c429_A2 net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c63_A1 net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c726_A0 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net687 net687 VGND VGND VPWR VPWR clknet_0_net687 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net698 net698 VGND VGND VPWR VPWR clknet_0_net698 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_7_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput65 net830 VGND VGND VPWR VPWR out10 sky130_fd_sc_hd__buf_2
Xoutput76 net841 VGND VGND VPWR VPWR out20 sky130_fd_sc_hd__buf_2
Xoutput98 net863 VGND VGND VPWR VPWR out40 sky130_fd_sc_hd__clkbuf_4
Xoutput87 net852 VGND VGND VPWR VPWR out30 sky130_fd_sc_hd__buf_2
XANTENNA_input30_A in35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output117_A net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c142_B net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_99_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc307 net225 net811 net211 net872 net212 net207 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__mux4_4
Xc318 net826 net795 net788 clknet_1_0__leaf_net231 net97 VGND VGND VPWR VPWR net238
+ sky130_fd_sc_hd__a2111o_1
XFILLER_0_13_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc329 net246 clknet_1_0__leaf_net873 net248 net924 net989 VGND VGND VPWR VPWR net249
+ sky130_fd_sc_hd__o2111a_2
XANTENNA_c397_Y net296 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c671_A net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge806 net104 net103 VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__or2_1
XANTENNA_c95_B net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net473 net473 VGND VGND VPWR VPWR clknet_0_net473 sky130_fd_sc_hd__clkbuf_16
Xrebuffer9 net955 VGND VGND VPWR VPWR net956 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_31_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input33_X net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c341_A3 net258 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout129 net144 VGND VGND VPWR VPWR net894 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net873 clknet_0_net873 VGND VGND VPWR VPWR clknet_1_0__leaf_net873
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c707_A2 net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c305_X net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc115 net47 net868 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__nand2b_1
Xc126 net57 net1 net55 VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__nand3_1
Xc104 net33 net38 VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__and2b_1
XFILLER_0_60_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge797_GATE_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc137 net778 net770 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__nor2b_4
Xc159 net80 net781 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__and2b_2
Xc148 net78 net932 net928 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__and3_4
XTAP_TAPCELL_ROW_44_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c98_Y net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c85_C1 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_A2 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net281 net281 VGND VGND VPWR VPWR clknet_0_net281 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c458_SCD net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_12_0_clk_X clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c352_A2 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc671 net779 net420 net521 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__or3_1
Xc660 net189 net926 VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__or2_4
Xc682 net428 net521 net681 net688 net737 VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__o2111a_1
Xc693 clknet_4_11_0_clk net554 net545 net534 net548 clknet_1_1__leaf_net338 VGND VGND
+ VPWR VPWR net557 net556 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_78_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c569_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c262_A2 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c467_A net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout170_X net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge792_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_36_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c453_A1 net864 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c172_A2 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c186_C_N net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c612_SCD net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_45_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge783_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge765_A1 net35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c628_A1 net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge781_A0 net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc490 clknet_1_1__leaf_net370 net44 net862 net270 net45 net940 VGND VGND VPWR VPWR
+ net392 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_63_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c160_B_N net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_72_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c222_B net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c94_A_N net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c689_B net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c168_C_N net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c704_A3 clknet_1_0__leaf_net338 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_81_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c720_A2 net456 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc75 net819 net12 VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__nor2_2
Xc64 net779 net767 net812 net824 net814 net806 VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__mux4_2
Xc97 net940 net16 VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__and2b_1
Xc86 net14 net868 net21 net22 net7 net18 VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_26_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A0 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_90_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c464_B1 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input60_A in7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c630_A2 net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_4_0_0_clk_X clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c67_A_N net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c284_A0 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge808_GATE clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c581_D1 net692 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c731_A1 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c450_A2 net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold54 net380 VGND VGND VPWR VPWR net1001 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 net371 VGND VGND VPWR VPWR net1012 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c609_A3 net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c625_A2 net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer19 net968 VGND VGND VPWR VPWR net966 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_s825_GATE_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c554_B net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c168_X net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c429_A3 net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net699 net699 VGND VGND VPWR VPWR clknet_0_net699 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_31_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput66 net831 VGND VGND VPWR VPWR out11 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c482_RESET_B net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c461_A1 net851 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput77 net842 VGND VGND VPWR VPWR out21 sky130_fd_sc_hd__buf_2
Xoutput99 net864 VGND VGND VPWR VPWR out41 sky130_fd_sc_hd__buf_2
Xoutput88 net853 VGND VGND VPWR VPWR out31 sky130_fd_sc_hd__buf_2
XANTENNA_input23_A in29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c189_A0 net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c636_A1 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c135_B net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c302_B net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc308 net210 net931 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__nand2_1
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc319 net770 net115 clknet_1_0__leaf_net238 net936 VGND VGND VPWR VPWR net873 sky130_fd_sc_hd__or4bb_4
XFILLER_0_13_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c292_Y net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c138_A_N net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c285_X net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c452_X net851 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge807 net271 net278 VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__and2_1
XFILLER_0_67_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c737_A0 net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c88_B net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c175_A2 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c472_B1 net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c622_A3 net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input26_X net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge784_A0 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_85_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout160_A net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c430_RESET_B net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c138_Y net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c707_A3 net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc127 net42 net49 net56 net867 net866 VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__o2111a_1
Xc116 net48 net8 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__nand2_1
Xc105 net934 net29 net812 net38 net28 net26 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__mux4_1
XFILLER_0_13_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c219_SCE net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc149 net70 net932 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__nor2b_4
Xc138 net65 net769 net767 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__nand3b_4
XTAP_TAPCELL_ROW_44_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_A3 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c458_SCE net658 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c633_A2 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc672 net662 VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__inv_1
Xc661 net771 net191 VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__and2b_1
Xc683 net330 net307 net428 net81 net528 net408 VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__mux4_1
Xc694 net295 net525 net191 net800 net530 net901 VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__mux4_1
XFILLER_0_91_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c150_X net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c437_A3 net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c734_A1 net535 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c172_A3 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c750_A0 net407 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_100_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c197_A0 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c628_A2 net497 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge781_A1 net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc491 net269 net132 net160 net204 net916 net31 VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_71_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc480 clknet_4_6_0_clk net381 net955 net216 net809 net1012 VGND VGND VPWR VPWR net383
+ c480/Q_N sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_19_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c222_C net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c720_A3 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc65 net788 net786 VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__and2_2
Xc76 net0 net823 net797 VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__nand3b_4
Xc98 net29 net815 VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__nor2_2
Xc87 net17 net19 net824 net18 net4 net9 VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__mux4_1
XFILLER_0_97_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A1 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c70_B net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xwire125 net438 VGND VGND VPWR VPWR net890 sky130_fd_sc_hd__buf_1
XANTENNA_c464_A1 net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input53_A in56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c630_A3 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c477_RESET_B net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_97_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c588_SCD net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c158_A net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s818_Q net694 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c581_C1 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c587_Y net466 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_A2 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c450_A3 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold55 net495 VGND VGND VPWR VPWR net1002 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input56_X net821 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_65_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c504_S0 net712 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c682_D1 net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c554_C net412 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c230_X net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c726_A2 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c63_A3 net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput67 net832 VGND VGND VPWR VPWR out12 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput89 net854 VGND VGND VPWR VPWR out32 sky130_fd_sc_hd__clkbuf_4
Xoutput78 clknet_1_0__leaf_net843 VGND VGND VPWR VPWR out22 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_98_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input16_A in22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c636_A2 net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_443 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c411_D_N net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net285 clknet_0_net285 VGND VGND VPWR VPWR clknet_1_1__leaf_net285
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_43_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc309 clknet_4_0_0_clk net115 net78 net774 net227 VGND VGND VPWR VPWR net229 net228
+ sky130_fd_sc_hd__sdfrbp_1
XFILLER_0_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c671_C net521 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input8_A in15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c664_B net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge808 net339 clknet_4_2_0_clk net335 VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__dlrtp_2
XFILLER_0_82_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c737_A1 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c753_A0 net21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c472_A1 net22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c471_Q net372 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge768_A2 net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input19_X net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge784_A1 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c443_C_N net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire161_X net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c140_A net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c200_Y net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc117 net825 net820 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__or2_2
Xc106 net824 net32 net36 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_96_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc128 net56 net866 net858 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__or3_2
XFILLER_0_13_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc139 net64 net811 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__nand2_8
XANTENNA_c723_A3 net408 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c667_Y net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c748_A0 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c602_S0 net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s868_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc673 clknet_4_10_0_clk net533 net317 net525 net189 net800 VGND VGND VPWR VPWR net535
+ net534 sky130_fd_sc_hd__sdfbbp_1
Xc662 net79 net72 VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__or2b_1
XFILLER_0_75_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc684 net530 net330 net994 net677 VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__or4bb_1
Xc695 net552 net895 net901 net550 net688 net735 VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__mux4_1
XFILLER_0_91_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c355_A net44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c143_X net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c734_A2 net483 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c750_A1 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c628_A3 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c197_A1 net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge781_A2 net406 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_71_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc481 net69 net85 net950 net22 net379 net695 VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__mux4_1
Xc470 net208 net247 net368 net976 clknet_1_0__leaf_net699 VGND VGND VPWR VPWR net370
+ sky130_fd_sc_hd__a2111oi_4
Xc492 net355 net774 net787 clknet_1_0__leaf_net857 net771 VGND VGND VPWR VPWR net394
+ sky130_fd_sc_hd__o2111ai_4
XFILLER_0_29_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c417_S0 net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc66 net0 net815 VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__nand2_2
XFILLER_0_97_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc99 net25 net31 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__and2_1
Xc77 net816 net5 VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__and2_2
Xc88 net823 net940 VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__nand2_1
XFILLER_0_97_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c152_S0 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c595_D1 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_rebuffer9_X net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c745_A1 net691 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xwire137 net903 VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c422_A_N net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c464_A2 net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_rebuffer19_A net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c761_A0 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input46_A in5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c349_SCE net258 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c661_A_N net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c413_A_N net304 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c588_SCE net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c158_B net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c220_A net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_31_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c581_B1 net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_A3 net535 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold56 net269 VGND VGND VPWR VPWR net1003 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c756_A0 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c682_C1 net688 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_9_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c430_SCD net893 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c275_B net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c268_A net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_69_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c442_B net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge767_B net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c726_A3 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c742_A2 net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput68 net833 VGND VGND VPWR VPWR out13 sky130_fd_sc_hd__clkbuf_4
Xoutput79 net844 VGND VGND VPWR VPWR out23 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_98_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c605_S0 net442 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c189_A2 net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c486_A0 net28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c636_A3 net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net231 clknet_0_net231 VGND VGND VPWR VPWR clknet_1_1__leaf_net231
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net286 clknet_0_net286 VGND VGND VPWR VPWR clknet_1_1__leaf_net286
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c180_Y net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge809 clknet_4_14_0_clk net586 net612 VGND VGND VPWR VPWR net683 net682 sky130_fd_sc_hd__edfxbp_1
XANTENNA_c340_X net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c737_A2 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c753_A1 net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_1_0__f_net338_X clknet_1_0__leaf_net338 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c245_S0 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xnet899_2 clknet_1_1__leaf_net685 VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_85_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net843 clknet_0_net843 VGND VGND VPWR VPWR clknet_1_0__leaf_net843
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c140_B net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c238_B net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout146_A net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c468_RESET_B net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c133_A net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c405_B net296 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc118 net820 net46 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__and2_1
Xc107 net36 net39 net40 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__or3_1
XFILLER_0_5_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc129 net55 net1 net38 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__and3_2
XANTENNA_c290_X net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge795_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c748_A1 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c85_A2 net21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c93_B net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c602_S1 net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_rebuffer49_A net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clone21_A net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c483_A1 net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc630 net465 net877 net937 net934 net204 net1004 VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__mux4_1
Xc663 net308 net303 VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__nand2b_1
Xc685 net198 net528 net313 net525 VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__or4bb_1
Xc696 net443 net528 net203 net81 net307 net940 VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__mux4_4
Xc674 net523 net527 net522 net421 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__or4bb_1
XANTENNA_merge779_A2 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input31_X net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c361_C_N net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c722_RESET_B net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c301_D1 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c362_C net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c355_B net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c97_A_N net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c310_Y net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c408_Y net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c734_A3 net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c424_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_14_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c494_A0 net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge781_A3 net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc482 clknet_4_6_0_clk net382 net305 net372 net1010 net865 VGND VGND VPWR VPWR net385
+ c482/Q_N sky130_fd_sc_hd__sdfbbp_1
Xc460 net70 net350 net296 clknet_1_0__leaf_net356 net357 net344 VGND VGND VPWR VPWR
+ net361 sky130_fd_sc_hd__mux4_4
Xc471 clknet_4_6_0_clk net94 net13 net262 net121 net972 VGND VGND VPWR VPWR net372
+ net371 sky130_fd_sc_hd__sdfbbn_2
Xc493 net282 net816 net272 net277 net937 net940 VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_32_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_41_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_93_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c417_S1 net696 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_50_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c465_A net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc67 net775 net796 VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__and2b_2
XFILLER_0_97_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc89 net811 net8 net12 VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__nor3_1
Xc78 net10 net5 VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__nor2b_2
XFILLER_0_78_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s860_Q net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c729_A3 net466 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c420_X net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c595_C1 net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire138 net487 VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_306 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c761_A1 net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s877_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c535_Q_N net412 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input39_A in43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_A0 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc290 net781 net91 net929 net932 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__or4bb_4
XFILLER_0_46_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_5_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c284_A3 net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c581_A1 net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold57 net488 VGND VGND VPWR VPWR net1004 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c756_A1 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c475_A2 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c491_A1 net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge777_D_N net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c682_B1 net681 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s860_GATE_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c430_SCE net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c268_B net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout176_A net789 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_36_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge774_D net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c742_A3 net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput69 net834 VGND VGND VPWR VPWR out14 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_98_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c605_S1 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c189_A3 net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c486_A1 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c71_X net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input61_X net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c296_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net243 clknet_0_net243 VGND VGND VPWR VPWR clknet_1_1__leaf_net243
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net287 clknet_0_net287 VGND VGND VPWR VPWR clknet_1_1__leaf_net287
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c677_A0 net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c250_S1 net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_334 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c479_SCE net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c717_RESET_B net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c706_S0 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c552_B net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c166_X net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c441_S0 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c753_A2 net456 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input21_A in27 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_13_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output108_A clknet_1_0__leaf_net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_97_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xnet899_3 clknet_1_1__leaf_net685 VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__inv_6
XANTENNA_c245_S1 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c238_C net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c133_B net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c321_SCD net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc108 net43 net42 net31 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__and3_2
XFILLER_0_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc119 net12 net46 VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__or2_2
XFILLER_0_41_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c662_A net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge802_GATE_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c748_A2 net372 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_44_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_52_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c764_A1 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net285 net285 VGND VGND VPWR VPWR clknet_0_net285 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c79_A net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc631 net484 net204 net304 net829 net894 net728 VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__mux4_1
Xc620 net416 net291 net499 net230 net833 net706 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__mux4_1
Xc664 net203 net779 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__nand2b_2
Xc675 net663 VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__clkbuf_1
Xc697 net759 VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__inv_4
Xc686 net901 net434 net207 net521 net543 VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__a2111oi_4
XANTENNA_c346_S0 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input24_X net789 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c301_C1 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c393_A2 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c188_C net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c355_C net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net685 clknet_0_net685 VGND VGND VPWR VPWR clknet_1_0__leaf_net685
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c136_Y net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c410_A net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c750_A3 net483 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c105_A0 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c759_A1 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c197_A3 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_71_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc472 net22 net1003 net883 net838 net977 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__a2111o_1
Xc450 net328 net122 net345 net347 net204 net971 VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__mux4_1
Xc461 net122 net851 net349 net236 net347 clknet_1_0__leaf_net699 VGND VGND VPWR VPWR
+ net362 sky130_fd_sc_hd__mux4_1
Xc494 net168 clknet_1_0__leaf_net394 clknet_1_0__leaf_net289 net132 net934 net688
+ VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__mux4_4
Xc483 net383 net825 net980 clknet_1_0__leaf_net377 clknet_1_0__leaf_net370 net658
+ VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__mux4_4
XFILLER_0_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge814_Q net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_82_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c298_B net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_1_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c465_B net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc68 net805 net4 VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__nand2_2
XANTENNA_c714_S0 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc79 net9 net14 net938 VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__or3_4
XFILLER_0_97_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c595_B1 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c261_C_N net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c761_A2 net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_A1 net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c471_Q_N net371 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc280 net853 net188 net194 net771 net75 net932 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__mux4_2
Xc291 net201 net195 net204 net98 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__or4bb_2
XFILLER_0_46_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c220_C net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge790 clknet_4_9_0_clk net460 net462 VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__dfrtp_2
XTAP_TAPCELL_ROW_31_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c213_B net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c575_A net795 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold58 net345 VGND VGND VPWR VPWR net1005 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c756_A2 net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c293_B_N net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c459_RESET_B net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c491_A2 net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c619_S0 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input51_A in54 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net458 clknet_0_net458 VGND VGND VPWR VPWR clknet_1_1__leaf_net458
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c444_Q_N net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s840_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_64_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c163_B net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout169_A net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c428_B net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c439_S0 net688 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge769_SCD net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge813_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c174_S0 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c621_S1 net712 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c486_A2 net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c64_X net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input54_X net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s822_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net288 clknet_0_net288 VGND VGND VPWR VPWR clknet_1_1__leaf_net288
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c706_S1 net692 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c552_C net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c685_C_N net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c440_A net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_140 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c616_S1 net712 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c497_A1 net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input14_A in20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c632_S0 net712 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xnet899_4 clknet_1_1__leaf_net685 VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__inv_6
XFILLER_0_77_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c133_C net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c126_B net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc109 net812 net6 net38 net43 net934 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__a2111o_2
XFILLER_0_41_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c225_D1 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input6_A in13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c748_A3 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c443_X net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net231 net231 VGND VGND VPWR VPWR clknet_0_net231 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c764_A2 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net286 net286 VGND VGND VPWR VPWR clknet_0_net286 sky130_fd_sc_hd__clkbuf_16
Xc621 net250 net98 clknet_1_0__leaf_net285 net839 net290 net712 VGND VGND VPWR VPWR
+ net505 sky130_fd_sc_hd__mux4_4
XFILLER_0_32_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc610 net475 net95 net324 net345 net481 net684 VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__mux4_4
Xc632 net13 net125 net372 net160 net712 net728 VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__mux4_1
Xc665 net663 VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__buf_1
Xc676 net81 net408 net526 net529 VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__or4bb_1
Xc687 net963 net548 net771 clknet_1_0__leaf_net697 net737 VGND VGND VPWR VPWR net549
+ sky130_fd_sc_hd__a2111o_2
Xc698 net548 net208 net738 VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__nand3_1
XANTENNA_c346_S1 net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input17_X net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c393_A3 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c243_B net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout151_A net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net686 clknet_0_net686 VGND VGND VPWR VPWR clknet_1_0__leaf_net686
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net697 clknet_0_net697 VGND VGND VPWR VPWR clknet_1_0__leaf_net697
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_98_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c410_B net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c403_A net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c350_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c560_X net439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input9_X net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c759_A2 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc451 net772 net205 net344 VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__nand3b_1
Xc440 net792 net864 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__nand2_2
Xc462 net252 net803 net65 net985 net933 net694 VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__mux4_2
Xc473 net976 net775 net299 net825 net983 net681 VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__mux4_1
Xc495 net30 net269 net768 net838 net862 net813 VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__mux4_1
Xc484 net277 net816 net162 net185 net371 net675 VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__mux4_1
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c664_A_N net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c360_B net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c714_S1 net693 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc69 net791 net938 net812 VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__and3b_1
XFILLER_0_78_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c595_A1 net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c141_X net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c730_S0 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_A2 net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c94_X net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c72_C_N net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc281 net864 net83 net195 net920 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__or4bb_4
Xc270 net185 net186 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__or2_4
Xc292 net209 net952 net207 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__nand3_2
XFILLER_0_46_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge791 clknet_4_2_0_clk net226 net632 VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__dfrtp_2
Xmerge780 net783 net443 net429 net312 net193 net910 VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__mux4_1
XFILLER_0_55_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c213_C net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c709_S1 clknet_1_0__leaf_net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c196_Y net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c233_D1 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c725_S0 net688 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold59 net696 VGND VGND VPWR VPWR net1006 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c189_X net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c62_S1 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c530_Y net407 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c756_A3 net497 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_rebuffer17_A net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c491_A3 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input44_A in48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c424_SCD net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net459 clknet_0_net459 VGND VGND VPWR VPWR clknet_1_1__leaf_net459
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_84_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c318_D1 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c682_A2 net521 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c415_SCD net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_29_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c280_S0 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c156_B net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c149_A net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_38_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c439_S1 clknet_1_1__leaf_net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c685_A net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge774_SET_B net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge769_SCE net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c174_S1 net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c486_A3 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c365_S0 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net289 clknet_0_net289 VGND VGND VPWR VPWR clknet_1_1__leaf_net289
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c677_A2 net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_84_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c214_A0 net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c273_B net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c440_B net864 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge789_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xnet899_5 clknet_1_0__leaf_net685 VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__inv_6
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net857 clknet_0_net857 VGND VGND VPWR VPWR clknet_1_0__leaf_net857
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c225_C1 net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c276_Y net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c550_A net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_A1 net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c269_X net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c603_X net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net243 net243 VGND VGND VPWR VPWR clknet_0_net243 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net287 net287 VGND VGND VPWR VPWR clknet_0_net287 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c79_C net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc622 net470 net95 net291 net124 net785 net185 VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__mux4_1
Xc600 net100 net451 net452 net304 net883 net665 VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__mux4_1
Xc611 net84 net451 clknet_1_1__leaf_net459 net979 net20 net89 VGND VGND VPWR VPWR
+ net493 sky130_fd_sc_hd__mux4_1
Xc633 net160 net464 net363 net834 net726 net731 VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__mux4_2
XFILLER_0_32_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc666 net526 net426 VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__nand2_1
Xc677 net193 net538 net528 net535 net526 net525 VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__mux4_1
Xc688 clknet_4_10_0_clk net419 net529 clknet_1_0__leaf_net549 net995 VGND VGND VPWR
+ VPWR net551 net550 sky130_fd_sc_hd__sedfxbp_1
Xc699 net759 VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__inv_1
XANTENNA_merge780_S0 net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c301_A1 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c243_C net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net687 clknet_0_net687 VGND VGND VPWR VPWR clknet_1_0__leaf_net687
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net698 clknet_0_net698 VGND VGND VPWR VPWR clknet_1_0__leaf_net698
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_98_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c198_A_N net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c576_C_N net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c728_S0 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c494_A3 net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc430 clknet_4_9_0_clk net303 net926 net893 net86 net910 VGND VGND VPWR VPWR net330
+ net329 sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_32_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc463 net9 net131 net839 net785 VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__or4bb_1
XFILLER_0_20_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc441 net85 net340 net791 net229 net216 net234 VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__mux4_2
Xc452 net349 net937 net678 VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__or3b_4
Xc496 net893 net124 net282 net829 net290 net822 VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__mux4_1
Xc485 net374 net44 net204 net73 net787 net261 VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc474 clknet_4_3_0_clk net268 net208 net969 net893 VGND VGND VPWR VPWR net376 net375
+ sky130_fd_sc_hd__sdfsbp_1
XFILLER_0_19_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_10_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c193_C net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c186_B net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net473 clknet_0_net473 VGND VGND VPWR VPWR clknet_1_0__leaf_net473
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c730_S1 net688 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout147_X net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c134_X net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c406_Y net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c489_A3 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge798_GATE_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc260 net180 net79 net778 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__and3_1
Xc271 net800 net66 net925 net185 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__or4bb_4
Xc293 net209 net781 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__or2b_4
Xc282 net1017 net198 net65 net933 net920 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__a2111oi_4
XANTENNA_c604_D1 net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c696_A1 net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge781 net221 net785 net406 net528 net891 net836 VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__mux4_4
Xmerge770 net536 net545 net562 net436 net561 net739 VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__mux4_4
XFILLER_0_28_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge792 clknet_4_10_0_clk net637 net651 VGND VGND VPWR VPWR net663 net662 sky130_fd_sc_hd__dfsbp_1
XFILLER_0_15_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c101_B net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c573_A_N net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c233_C1 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c463_A net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c460_S1 net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net281 clknet_0_net281 VGND VGND VPWR VPWR clknet_1_0__leaf_net281
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c424_SCE net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input37_A in41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c601_RESET_B net439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c685_B net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c736_S0 net408 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c304_A1 net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c365_S1 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c677_A3 net535 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c528_A_N net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c214_A1 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c266_B net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout174_A net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c426_A net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c239_D1 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net458 net458 VGND VGND VPWR VPWR clknet_0_net458 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c214_X net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s821_Q net696 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_2_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge778_S0 net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output68_A net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xnet899_6 clknet_1_0__leaf_net685 VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__inv_6
XFILLER_0_89_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_66_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge773_SET_B net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_75_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_84_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c550_B net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_A2 net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c543_A net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c436_Y net336 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_93_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c291_C_N net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net288 net288 VGND VGND VPWR VPWR clknet_0_net288 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc601 clknet_4_9_0_clk net463 net439 clknet_1_0__leaf_net377 net345 net936 VGND VGND
+ VPWR VPWR net482 net481 sky130_fd_sc_hd__sdfbbn_1
Xc612 clknet_4_12_0_clk net409 net1013 net20 net969 net781 VGND VGND VPWR VPWR net495
+ net494 sky130_fd_sc_hd__sdfbbn_1
Xc634 net827 net813 net829 net109 net938 net822 VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__mux4_1
Xc623 net501 net384 net465 net813 net34 net160 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__mux4_1
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc689 net313 net207 net696 VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__nor3b_1
Xc667 net191 net405 VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__nor2b_4
Xc678 net72 net528 net737 VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__nor3b_1
XANTENNA_c301_A2 net190 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_587 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap142_X net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net699 clknet_0_net699 VGND VGND VPWR VPWR clknet_1_0__leaf_net699
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c229_B net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c124_A net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c728_S1 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c660_A net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c77_A net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc420 net777 net301 net906 net911 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__or4bb_4
XFILLER_0_20_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc431 net67 net661 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__and2_1
Xc442 net237 net216 net989 net922 VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__or4bb_1
Xc453 net350 net864 net346 net233 net344 clknet_1_0__leaf_net698 VGND VGND VPWR VPWR
+ net353 sky130_fd_sc_hd__mux4_4
Xc464 net299 net9 net247 net347 net681 VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__o2111a_2
Xc497 net272 net45 net277 clknet_1_0__leaf_net288 net160 net774 VGND VGND VPWR VPWR
+ net398 sky130_fd_sc_hd__mux4_4
Xc486 net28 net31 net20 net916 net324 net204 VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__mux4_2
Xc475 net365 net216 net978 net375 net658 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__o2111ai_2
XANTENNA_input22_X net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c328_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c179_B net821 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_net899_6_A clknet_1_0__leaf_net685 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c307_A1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc261 net181 net773 net768 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__nor3b_1
Xc250 net49 net871 net868 net848 net919 net874 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__mux4_1
Xc272 net77 net64 net928 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__nand3_4
Xc283 net198 net200 net193 net981 net920 net195 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__mux4_1
Xc294 net211 net101 net203 net925 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__or4bb_2
XFILLER_0_99_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c696_A2 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge771 net425 net419 net532 net534 VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__or4bb_1
Xmerge782 net822 net317 net426 net890 net435 net800 VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__mux4_1
Xmerge793 clknet_4_13_0_clk net500 net502 VGND VGND VPWR VPWR net664 net842 sky130_fd_sc_hd__dfsbp_1
XTAP_TAPCELL_ROW_31_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c233_B1 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c191_A net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c469_S0 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c143_A0 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s834_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c535_Q net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c318_B1 net788 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_90_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c323_D net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c316_C net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c243_A_N net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c678_B net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c194_X net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c752_S0 net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c435_D1 net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c170_D1 net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c329_C1 net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c266_C net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c161_B net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout167_A net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c239_C1 net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net459 net459 VGND VGND VPWR VPWR clknet_0_net459 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c576_X net456 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clone42_A net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge778_S1 net691 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xnet899_7 clknet_1_0__leaf_net685 VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_18_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c225_A1 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c241_A0 net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c271_A net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c369_A net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_A3 net371 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c164_Y net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c536_A net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c157_X net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net289 net289 VGND VGND VPWR VPWR clknet_0_net289 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c416_A0 net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc602 net969 net248 net405 net776 net84 net785 VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__mux4_2
Xc613 clknet_4_12_0_clk net1002 net902 net76 net888 net998 VGND VGND VPWR VPWR net497
+ net496 sky130_fd_sc_hd__sdfbbn_1
Xc635 net20 net940 net787 net839 net727 net730 VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__mux4_2
Xc624 net258 net404 net153 net134 clknet_1_1__leaf_net698 net723 VGND VGND VPWR VPWR
+ net508 sky130_fd_sc_hd__mux4_4
Xc668 net765 VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__clkbuf_4
Xc679 net537 net81 net521 net412 net301 VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__a2111oi_1
XANTENNA_c432_C1 net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input12_A in19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c592_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c117_A net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c252_C1 net854 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c660_B net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input4_A in11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c215_SCD net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c274_X net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc410 net306 net295 net935 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__nor3b_1
Xc421 net318 net798 net89 net912 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__or4bb_1
Xc432 net225 net190 net319 net320 net329 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__a2111oi_1
Xc443 net234 net772 net95 VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__or3b_2
Xc454 net634 VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__inv_2
Xc487 net385 net851 net927 net168 net816 net941 VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc465 net837 net126 net936 clknet_1_1__leaf_net697 VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__or4bb_2
Xc476 net369 net185 net125 clknet_1_0__leaf_net377 net668 net676 VGND VGND VPWR VPWR
+ net378 sky130_fd_sc_hd__mux4_2
Xc498 net809 net162 net282 net336 net658 clknet_1_1__leaf_net698 VGND VGND VPWR VPWR
+ net859 sky130_fd_sc_hd__mux4_4
XFILLER_0_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input15_X net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c670_S0 net521 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c693_SCD net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c503_A1 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c179_C net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input7_X net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c371_D_N net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c490_S0 net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c307_A2 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc262 net182 net111 net916 net918 net183 net667 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__mux4_4
Xc251 net50 net61 net175 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__or3_1
Xc240 net116 net27 net164 net900 net98 c240/S1 VGND VGND VPWR VPWR net874 sky130_fd_sc_hd__mux4_2
XFILLER_0_20_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c604_B1 net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_15_0_clk_X clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc295 net193 net211 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__or2b_1
Xc284 net76 net200 net201 net198 net920 net933 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__mux4_2
Xc273 net927 net70 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__nand2b_2
XFILLER_0_87_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c696_A3 net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge772 net227 net766 net213 net70 net91 VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__a2111oi_1
XFILLER_0_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge783 clknet_4_9_0_clk net439 net317 net207 net802 net816 VGND VGND VPWR VPWR
+ net653 net652 sky130_fd_sc_hd__sdfbbp_1
Xmerge794 clknet_4_9_0_clk net477 net478 VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__dfstp_1
XFILLER_0_15_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c233_A1 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c184_A net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c456_B net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c237_X net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c87_S1 net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c469_S1 net693 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc322_1 clknet_1_0__leaf_net685 VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__inv_6
XANTENNA_c485_S0 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c143_A1 net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c318_A1 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_90_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c334_A0 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c500_A2 net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_wire120_X net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c399_A net190 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c588_RESET_B net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input42_A in46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c317_D_N net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c170_C1 net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c219_CLK_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c329_B1 net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c588_SET_B net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c214_A3 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c161_A_N net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c154_B net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c239_B1 net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_3_0_clk_X clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c747_S1 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c358_C_N net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge804_GATE clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input45_X net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c392_S1 net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c271_B net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c369_B net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c536_B net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c431_A net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c579_C_N net412 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c416_A1 net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc603 net334 net468 net409 net830 net410 VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__a2111o_1
Xc636 net517 net185 net465 net793 net830 net732 VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__mux4_1
Xc625 net276 clknet_1_0__leaf_net285 net95 net501 net957 net707 VGND VGND VPWR VPWR
+ net509 sky130_fd_sc_hd__mux4_1
XFILLER_0_32_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc614 net494 net773 net496 net684 net719 VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__o2111ai_2
Xc669 net772 net528 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__and2b_1
XANTENNA_c493_S0 net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c432_B1 net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c326_A1 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output73_A net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_max_cap128_X net893 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c215_SCE net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c267_X net864 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c488_S0 net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc400 net186 net770 VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__and2b_4
Xc411 net309 net297 net296 net912 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__or4bb_1
Xc433 net644 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__inv_1
Xc422 net319 net299 net668 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__nand3b_4
Xc455 net652 VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__inv_8
Xc444 clknet_4_2_0_clk net235 net89 net194 net928 net912 VGND VGND VPWR VPWR net345
+ net344 sky130_fd_sc_hd__sdfbbn_2
Xc488 net162 net854 net939 net916 net780 net701 VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__mux4_1
Xc477 clknet_4_4_0_clk net140 net825 clknet_1_1__leaf_net377 net986 net694 VGND VGND
+ VPWR VPWR net380 net379 sky130_fd_sc_hd__sdfbbn_1
Xc466 net776 net140 net925 net269 net363 VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__a2111o_1
XPHY_EDGE_ROW_8_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc499 net270 net774 net30 net853 clknet_1_0__leaf_net394 net822 VGND VGND VPWR VPWR
+ net861 sky130_fd_sc_hd__mux4_4
XFILLER_0_35_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c670_S1 net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_11_0_clk_X clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_93_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c503_A2 net851 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c339_C net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c490_S1 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c296_SET_B net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c557_CLK_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c82_A net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c307_A3 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc230 net814 net106 net161 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__or3b_2
Xc263 net184 net183 net128 VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__and3b_1
Xc252 net818 net63 net871 net854 net175 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__o2111ai_1
Xc241 net45 net163 net874 net916 net147 c241/S1 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__mux4_1
XANTENNA_c604_A1 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc296 clknet_4_2_0_clk net207 net213 net97 net203 net883 VGND VGND VPWR VPWR net215
+ net214 sky130_fd_sc_hd__sdfbbp_1
Xc285 net201 net882 net197 net198 net925 net906 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__mux4_2
Xc274 net188 net78 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__or2_4
XFILLER_0_46_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c620_A0 net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge773 clknet_4_0_0_clk net102 net794 net121 net115 net124 VGND VGND VPWR VPWR
+ net640 net639 sky130_fd_sc_hd__sdfbbn_2
XANTENNA_c348_C1 net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge795 clknet_4_8_0_clk net411 net631 VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__dfstp_2
XTAP_TAPCELL_ROW_31_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge784 net230 net121 net78 net212 net780 net989 VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__mux4_1
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c296_D net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c191_C net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c474_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c184_B net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c177_A net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c485_S1 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c143_A2 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_98_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c217_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c92_Y net28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c318_A2 net795 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c334_A1 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c500_A3 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c584_SCD net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c271_D_N net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c399_B net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c294_A net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c573_C net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c435_B1 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input35_A in4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c170_B1 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net238 clknet_0_net238 VGND VGND VPWR VPWR clknet_1_1__leaf_net238
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_97_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s878_GATE_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c309_SCD net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c147_B net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c676_A net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c702_A1 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c464_X net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c294_C_N net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c219_Q net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c446_C1 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_26_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input38_X net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_362 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c241_A2 net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout172_A net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c264_B net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_53_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c431_B net661 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c465_D_N clknet_1_1__leaf_net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c547_D1 net408 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_62_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c416_A2 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc604 net65 net959 net830 net973 net262 VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__a2111oi_1
Xc637 net516 net839 net696 net711 net729 net733 VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__mux4_1
Xc626 net152 net363 net833 net501 net418 net706 VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__mux4_1
Xc615 net476 net452 net496 net939 net718 net720 VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_73_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s861_GATE_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c493_S1 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_80_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c326_A2 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s882_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output66_A net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge774_RESET_B net21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c252_A1 net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout175_X net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c162_X net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c249_C_N net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c434_Y net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc412 net301 net308 net305 net306 net910 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__a2111o_1
Xc401 net960 net199 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__nor2_8
XFILLER_0_32_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c421_C_N net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc434 net206 net198 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__nand2b_2
Xc423 net320 net69 net991 VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__or3b_1
Xc445 net126 net900 net982 VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__or3_1
Xc478 clknet_4_6_0_clk clknet_1_1__leaf_net377 net883 net955 net268 net702 VGND VGND
+ VPWR VPWR net381 c478/Q_N sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc456 net352 net779 net344 clknet_1_1__leaf_net699 VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__or4bb_4
Xc467 net130 net131 net990 net982 VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__or4bb_4
Xc489 net261 net793 net306 net185 net270 net168 VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__mux4_1
XFILLER_0_87_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c618_A0 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s855_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_54_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c273_A_N net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout135_A net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c264_A_N net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c75_A net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc220 net786 net148 net787 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__and3_1
XFILLER_0_32_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s837_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc253 net58 net169 net667 VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__nand3_1
Xc242 net52 net40 net61 VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__nor3_1
Xc231 net139 net86 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__or2_1
XANTENNA_c173_A0 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc297 net96 net207 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__nor2b_4
Xc286 net197 net93 net917 net929 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__or4bb_4
Xc264 net65 net84 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__and2b_4
Xc275 net80 net772 VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__and2_4
XFILLER_0_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input20_X net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge803_GATE_N clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c255_A_N net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c348_B1 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge785 clknet_4_5_0_clk net292 net293 VGND VGND VPWR VPWR net863 net860 sky130_fd_sc_hd__dfrbp_1
Xmerge796 clknet_4_5_0_clk net176 net178 VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__dfstp_1
XFILLER_0_83_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge774 clknet_4_0_0_clk net132 net21 net120 VGND VGND VPWR VPWR net642 net641 sky130_fd_sc_hd__dfbbn_1
Xs880 net636 clknet_4_10_0_clk VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__lpflow_inputisolatch_1
XFILLER_0_70_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput1 in0 VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__buf_4
XANTENNA_c184_C net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c177_B net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net285 clknet_0_net285 VGND VGND VPWR VPWR clknet_1_0__leaf_net285
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c337_A net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c705_A1 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s819_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c721_B1 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c85_Y net22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c615_A1 net452 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c334_A2 net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_90_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c631_A0 net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c692_S0 net529 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_64_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c359_C1 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c287_A net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c559_B net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c496_S1 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c170_A1 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input28_A in33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_87_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c329_A2 clknet_1_0__leaf_net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c557_SCE net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c239_A2 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c202_A net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c676_B net408 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c297_Y net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c64_A0 net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_rebuffer20_A net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c241_A3 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c212_Y net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c416_A3 net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc627 net454 net813 net404 net290 net724 net728 VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__mux4_4
Xc616 net291 net418 net851 net483 net707 net712 VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__mux4_1
Xc605 net807 net121 net154 net110 net442 net776 VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_73_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c282_C1 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c713_A1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c218_SCD net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c432_A2 net190 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c574_X net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c568_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c194_C_N net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c541_B net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout168_X net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge791_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c427_Y net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c708_A1 net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc402 net199 net912 net186 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__or3_4
Xc413 net304 net299 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__nand2b_2
Xc435 net217 net334 net98 net892 net912 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__o2111ai_1
XFILLER_0_32_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc424 clknet_4_2_0_clk net798 net321 net305 net207 net319 VGND VGND VPWR VPWR net837
+ net324 sky130_fd_sc_hd__sdfbbn_2
Xc446 net113 net819 net331 net208 net982 VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__o2111ai_4
Xc479 clknet_4_6_0_clk net1001 clknet_1_1__leaf_net377 net375 net299 net703 VGND VGND
+ VPWR VPWR net382 c479/Q_N sky130_fd_sc_hd__sdfbbn_1
Xc457 net354 net355 net234 net350 net913 net344 VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__mux4_2
Xc468 clknet_4_3_0_clk net124 net121 net302 net983 net676 VGND VGND VPWR VPWR net369
+ net368 sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_87_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input10_A in17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c613_Q net497 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c722_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c634_A0 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c695_S0 net688 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_62_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c589_S1 net466 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c227_C net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input2_A in1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c499_S1 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc221 net150 net931 net923 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__and3_1
Xc210 net770 net11 net923 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__or3b_2
Xc232 net690 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__inv_1
Xc254 net813 net172 net848 net54 net840 net175 VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__mux4_1
Xc243 net2 net79 net825 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__and3b_1
XANTENNA_c173_A1 net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input58_A in60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc287 net774 net780 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__nor2_1
XFILLER_0_20_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc276 net926 net965 VGND VGND VPWR VPWR net883 sky130_fd_sc_hd__nor2_4
Xc265 net822 net75 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__and2b_1
XANTENNA_c158_C_N net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc298 net200 net97 net201 net211 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__or4bb_1
XTAP_TAPCELL_ROW_5_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input13_X net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c629_A0 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge769_CLK_N clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c348_A1 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge786 clknet_4_4_0_clk net170 merge786/RESET_B VGND VGND VPWR VPWR net171 net655
+ sky130_fd_sc_hd__dfrbp_1
XFILLER_0_70_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge797 net310 clknet_4_8_0_clk net311 VGND VGND VPWR VPWR net836 net668 sky130_fd_sc_hd__dlrbn_2
Xmerge775 net427 net795 net314 net962 net214 VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__a2111o_1
XTAP_TAPCELL_ROW_31_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs870 clknet_4_14_0_clk net604 VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__dlclkp_1
XFILLER_0_83_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs881 clknet_4_11_0_clk net647 VGND VGND VPWR VPWR net761 net760 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_51_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput2 in1 VGND VGND VPWR VPWR net767 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c177_C net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net231 clknet_0_net231 VGND VGND VPWR VPWR clknet_1_0__leaf_net231
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c337_B net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net286 clknet_0_net286 VGND VGND VPWR VPWR clknet_1_0__leaf_net286
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c217_RESET_B net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input5_X net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c721_A1 net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c334_A3 net864 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c631_A1 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c359_B1 net28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c287_B net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c542_C_N net408 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c182_A net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c559_C net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c402_X net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c435_A2 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_76_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s844_GATE_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c601_CLK_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c626_A1 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output89_A net854 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c208_S0 net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_8_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c597_S1 net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput60 in7 VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_24_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c202_B net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c669_B net528 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c64_A1 net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c446_A1 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input40_A in44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net238 net238 VGND VGND VPWR VPWR clknet_0_net238 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc628 net298 net465 net497 net941 net708 net722 VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__mux4_4
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc606 net360 net482 net86 net484 net716 VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__a2111oi_1
Xc617 net349 net455 net822 net98 net766 net418 VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_73_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c282_B1 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c681_A net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c713_A2 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c218_SCE net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_84_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c623_A2 net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input43_X net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_59_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c367_B net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c155_Y net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc403 net825 net984 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__nor2b_2
XFILLER_0_20_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc414 net764 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__buf_1
XFILLER_0_32_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc436 net322 net334 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__nor2_2
Xc425 net788 net775 net319 net968 net982 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__a2111oi_2
Xc458 clknet_4_2_0_clk net321 net100 net344 net658 VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__sdfrtp_1
Xc447 net233 net340 net1005 net347 net85 VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__a2111o_1
Xc469 net331 net134 net367 net347 net19 net693 VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__mux4_2
XANTENNA_c740_A0 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c618_A2 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c634_A1 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_48 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output71_A net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c366_SCD net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c115_B net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c710_A3 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_81_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c735_A0 net405 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc211 net762 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_79_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc200 net4 net24 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__nor2b_2
XFILLER_0_60_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc244 net60 net2 net655 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__or3_1
Xc233 net97 net158 net91 net931 net934 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__o2111a_1
XPHY_EDGE_ROW_68_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c468_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc222 net129 net807 net900 VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__nand3b_4
Xc255 net111 net175 net1 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__and3b_1
Xc288 net801 net87 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__or2_1
Xc266 net954 net67 net773 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__nor3_1
Xc277 net186 net192 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__or2_4
Xc299 net661 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__buf_1
XFILLER_0_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c620_A3 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge766_A1 net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c348_A2 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge765 net137 net35 net63 net174 net128 net854 VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__mux4_1
Xmerge787 net254 net266 VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__nand2b_1
Xmerge776 clknet_4_2_0_clk net213 net892 net67 net691 VGND VGND VPWR VPWR net645 net644
+ sky130_fd_sc_hd__sedfxbp_2
Xs860 net539 clknet_4_10_0_clk VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__dlxtn_1
XANTENNA_c415_RESET_B net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge782_A0 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs882 clknet_4_5_0_clk net648 VGND VGND VPWR VPWR net763 net762 sky130_fd_sc_hd__dfxbp_1
Xmerge798 net560 clknet_4_10_0_clk net547 VGND VGND VPWR VPWR net670 net669 sky130_fd_sc_hd__dlrbn_1
Xs871 clknet_4_14_0_clk net606 VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__dlclkp_2
XANTENNA_c364_A1 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput3 in10 VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_39_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net243 clknet_0_net243 VGND VGND VPWR VPWR clknet_1_0__leaf_net243
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net287 clknet_0_net287 VGND VGND VPWR VPWR clknet_1_0__leaf_net287
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c705_A3 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c80_A net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c615_A3 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c673_Q net535 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c631_A2 net304 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c216_CLK_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c569_SCD net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c359_A1 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_16_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s831_GATE clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_hold59_A net696 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_4_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c716_A2 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c582_D1 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c732_A1 net296 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge783_SCD net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c83_X net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c626_A2 net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c492_D1 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput50 in53 VGND VGND VPWR VPWR net815 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_12_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput61 in8 VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__buf_6
XFILLER_0_31_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c202_C net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c477_SET_B net694 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c397_B net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c564_B net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c577_D1 net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c727_A1 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c446_A2 net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c743_A0 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c462_A1 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input33_A in38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c637_A1 net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_22_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c145_B net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c424_D net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc618 net86 net480 net98 net800 net454 net1007 VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__mux4_1
Xc607 clknet_4_12_0_clk net366 net406 net347 net894 net936 VGND VGND VPWR VPWR net489
+ net488 sky130_fd_sc_hd__sdfbbp_1
XTAP_TAPCELL_ROW_73_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc629 net216 net387 net831 net501 net766 net906 VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__mux4_1
XFILLER_0_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c282_A1 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_31_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c681_B net529 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c713_A3 net333 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c462_X net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_40_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c738_A0 net408 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c457_A1 net355 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclone42 net933 VGND VGND VPWR VPWR net989 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_12_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c623_A3 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_59_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout170_A net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c708_A3 net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s849_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc415 clknet_4_8_0_clk net296 net313 net305 net312 net910 VGND VGND VPWR VPWR net315
+ net314 sky130_fd_sc_hd__sdfbbn_1
Xc437 net323 net336 net329 net319 net950 net681 VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__mux4_1
Xc426 net937 net322 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__nor2_2
Xc404 net779 net190 net776 net911 VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__or4bb_4
Xc459 clknet_4_9_0_clk net207 net113 net992 net1014 net345 VGND VGND VPWR VPWR net360
+ net359 sky130_fd_sc_hd__sdfbbn_1
Xc448 net229 net93 net347 VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__and3b_1
XFILLER_0_99_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c618_A3 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c634_A2 net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output64_A net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net458 clknet_0_net458 VGND VGND VPWR VPWR clknet_1_0__leaf_net458
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c160_X net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout173_X net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge783_SET_B net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c719_A2 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c735_A1 net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc212 net923 net130 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__nand2b_4
Xc201 net69 net127 net816 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__or3_1
Xc245 net908 net868 net2 net916 net862 net936 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__mux4_4
Xc234 net165 net96 net799 net916 net158 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__o2111a_1
Xc223 net148 net931 net40 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__and3_1
Xc256 net27 net61 net137 net907 net937 VGND VGND VPWR VPWR net855 sky130_fd_sc_hd__a2111oi_1
Xc278 net882 net186 net194 net928 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__or4bb_4
Xc267 net927 net77 VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__and2_4
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc289 net801 net206 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__nor2b_4
XANTENNA_c470_A1 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge766_A2 net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c629_A2 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs850 clknet_4_7_0_clk net508 VGND VGND VPWR VPWR net727 net726 sky130_fd_sc_hd__dfxbp_1
Xmerge777 net163 net132 net264 net96 VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__or4bb_1
Xmerge766 net312 net198 net301 net305 net414 net1006 VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__mux4_1
Xs861 net555 clknet_4_10_0_clk VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__dlxtn_1
Xmerge788 clknet_4_2_0_clk net342 net348 VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__dfrtn_1
XFILLER_0_55_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge799 net388 clknet_4_7_0_clk net389 VGND VGND VPWR VPWR net828 net671 sky130_fd_sc_hd__dlrbp_1
Xs883 clknet_4_8_0_clk net649 VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xs872 clknet_4_15_0_clk net607 VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c364_A2 net35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput4 in11 VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__buf_12
XFILLER_0_78_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net288 clknet_0_net288 VGND VGND VPWR VPWR clknet_1_0__leaf_net288
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_0_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c600_S0 net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c73_A net795 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c481_A0 net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c631_A3 net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c359_A2 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_16_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c323_CLK_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_87_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c182_C net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s873_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c168_A net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c342_B net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s880_SLEEP_B clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_96_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c285_A1 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c716_A3 net472 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c732_A2 net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge783_SCE net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c458_RESET_B net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c240_S0 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput40 in44 VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__buf_1
Xinput62 in9 VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput51 in54 VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__buf_4
XFILLER_0_12_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c564_C net442 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c240_X net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c577_C1 net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c727_A2 net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c215_CLK_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c584_SET_B net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c743_A1 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c462_A2 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c156_D_N net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input26_A in31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c637_A2 net696 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c138_B net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc619 net69 net276 net98 net465 net906 clknet_1_0__leaf_net698 VGND VGND VPWR VPWR
+ net503 sky130_fd_sc_hd__mux4_2
Xc608 net453 net484 net320 net409 net665 VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__a2111oi_1
XFILLER_0_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c282_A2 net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c667_A net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c190_X net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge794_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c738_A1 net529 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclone21 net76 VGND VGND VPWR VPWR net968 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_51_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c91_A1 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c473_A1 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c360_C_N net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c171_B_N net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge785_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c502_S1 net712 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net370 clknet_0_net370 VGND VGND VPWR VPWR clknet_1_1__leaf_net370
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge776_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout163_A net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c150_A net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c422_B net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc416 net308 net299 net768 net313 net312 net836 VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__mux4_1
XFILLER_0_13_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc405 net303 net296 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__nor2_2
Xc427 net72 net298 net322 VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__nand3_4
Xc438 net981 clknet_1_0__leaf_net697 VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__and2_0
Xc449 net635 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__inv_1
XANTENNA_c572_X net452 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c342_C_N net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c749_A0 net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c86_A1 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c634_A3 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c333_C_N net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net459 clknet_0_net459 VGND VGND VPWR VPWR clknet_1_0__leaf_net459
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c108_C net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c691_D1 net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c372_B net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout166_X net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c153_X net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c69_A_N net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c735_A2 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc202 net784 net17 net120 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__or3_4
Xc235 net5 net23 net799 net44 net159 net156 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__mux4_1
Xc224 net1 net870 net814 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__or3_2
Xc213 net78 net127 net142 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_92_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc257 net690 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__inv_2
Xc246 net35 net821 net774 VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__and3_1
XFILLER_0_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc279 net188 net920 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__nand2b_2
Xc268 net75 net69 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__nor2_2
XANTENNA_c751_A1 net521 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c470_A2 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c315_C_N net821 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge766_A3 net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c444_Q net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs851 clknet_4_7_0_clk net509 VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__dfxtp_1
Xmerge767 net212 net216 net221 net197 VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__or4bb_1
Xmerge778 net524 net563 net432 net427 net84 net691 VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__mux4_1
Xs840 clknet_4_11_0_clk net469 VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__dlclkp_4
Xmerge789 clknet_4_13_0_clk net629 net616 VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__dfrtp_1
Xs873 net609 clknet_4_15_0_clk VGND VGND VPWR VPWR net751 s873/Q_N sky130_fd_sc_hd__dlxbn_1
Xs884 clknet_4_8_0_clk net650 VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs862 net558 clknet_4_10_0_clk VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap131_X net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput5 in12 VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__buf_4
XFILLER_0_36_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net289 clknet_0_net289 VGND VGND VPWR VPWR clknet_1_0__leaf_net289
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c571_A1 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c270_X net190 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c762_A0 net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c481_A1 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input56_A in59 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input11_X net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_64_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c397_A_N net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c168_B net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_35_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c335_B net13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge797_Q_N net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout129_X net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c582_B1 net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c732_A3 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input3_X net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c560_A_N net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c312_A_N net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c757_A0 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c611_S0 net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c476_A1 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c492_B1 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_88_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c505_S1 net712 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput30 in35 VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput52 in55 VGND VGND VPWR VPWR net817 sky130_fd_sc_hd__buf_1
Xinput41 in45 VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__buf_2
XFILLER_0_52_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c292_C net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c180_A net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c452_B net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c445_A net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c577_B1 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c727_A3 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge777_B net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c400_X net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c743_A2 net497 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c533_A_N net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input19_A in25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output87_A net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c138_C net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc609 net442 net802 net455 net305 net807 net767 VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__mux4_1
XFILLER_0_12_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c183_X net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c455_Y net355 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c738_A2 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c754_A1 net134 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c91_A2 net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c109_D1 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c473_A2 net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_95_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c255_C net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c422_C net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c574_A1 net333 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc428 net325 net793 VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__and2b_1
Xc417 net777 net308 net925 net203 net836 net696 VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__mux4_2
Xc406 net304 net961 VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__nand2_4
XFILLER_0_13_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc439 net323 clknet_1_0__leaf_net338 net94 net191 net688 clknet_1_1__leaf_net697 VGND
+ VGND VPWR VPWR net339 sky130_fd_sc_hd__mux4_1
XANTENNA_c740_A3 net691 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c565_X net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c749_A1 net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c86_A2 net21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c96_A net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c484_A1 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input41_X net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c286_D_N net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c691_C1 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c198_B net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_19_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c358_A net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c704_S0 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c532_B net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_81_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c320_Y net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_61_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_28_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c735_A3 net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc203 net642 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_79_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc236 net167 net164 VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__nand2b_2
Xc225 net106 net158 net23 net786 net771 VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__a2111oi_2
XFILLER_0_20_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc214 net141 net923 net140 net120 net935 net134 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_92_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc258 net690 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__buf_16
Xc247 net907 net1 net1008 VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__nor3b_2
Xc269 net83 net927 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__and2b_1
XANTENNA_c751_A2 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c495_A0 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c99_X net35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xs830 net392 clknet_4_5_0_clk VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__dlxtn_1
Xmerge779 net59 net177 net79 net136 net132 net675 VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__mux4_1
Xs852 clknet_4_7_0_clk net510 VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__dfxtp_1
Xs841 net471 clknet_4_11_0_clk VGND VGND VPWR VPWR net717 net716 sky130_fd_sc_hd__dlxbn_1
Xmerge768 net245 net966 net132 net253 net839 net907 VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__mux4_4
Xs874 net617 clknet_4_12_0_clk VGND VGND VPWR VPWR net753 net752 sky130_fd_sc_hd__dlxbn_1
Xs863 net572 clknet_4_14_0_clk VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__dlxtp_1
XFILLER_0_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput6 in13 VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_36_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c686_C1 net521 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_587 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c607_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c746_A2 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c73_C net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c762_A1 net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c481_A2 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c609_S0 net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input49_A in52 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c613_CLK_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_44_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c717_SCD clknet_1_0__leaf_net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c230_B net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c335_C net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c463_C_N net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c285_A3 net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c109_X net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c582_A1 net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c429_S0 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c673_Q_N net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c476_A2 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c611_S1 net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c206_C_N net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c492_A1 net355 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s821_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput20 in26 VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__buf_6
Xinput31 in36 VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__clkbuf_2
Xinput53 in56 VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_12_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput42 in46 VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__buf_4
XFILLER_0_101_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c278_B net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c684_C_N net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c445_B net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c577_A1 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout141_X net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c743_A3 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c595_X net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c622_S0 net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c487_A1 net851 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c341_S1 net694 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c444_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c212_A_N net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c290_A net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c707_S0 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c459_CLK_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c555_A net677 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c176_X net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c279_A_N net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c738_A3 net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c409_C_N net296 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c754_A2 clknet_1_0__leaf_net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c451_A_N net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c473_A3 net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_S0 net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input31_A in36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c498_A0 net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c322_1_A clknet_1_0__leaf_net685 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output118_A net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net361 clknet_0_net361 VGND VGND VPWR VPWR clknet_1_1__leaf_net361
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net394 clknet_0_net394 VGND VGND VPWR VPWR clknet_1_1__leaf_net394
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c136_A net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c408_B net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c574_A2 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c303_A net661 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc418 net98 net209 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__or2b_1
Xc407 net302 net303 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__or2_2
Xmax_cap150 net845 VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_13_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc429 net791 net775 net327 net319 net216 net688 VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__mux4_1
XANTENNA_c293_X net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c437_S0 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c749_A2 net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c86_A3 net22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c172_S0 net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c89_A net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c484_A2 net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c215_Q net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c296_SCD net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input34_X net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c663_A_N net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c394_A2 clknet_1_1__leaf_net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c691_B1 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c260_B net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c358_B net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c420_A net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c720_S0 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_61_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc226 net158 net786 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__nand2b_1
Xc215 clknet_4_1_0_clk net930 net143 net894 net85 net142 VGND VGND VPWR VPWR net146
+ net145 sky130_fd_sc_hd__sdfbbn_1
Xc204 net641 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__buf_2
Xc259 net763 VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_92_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc237 net159 net161 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__and2b_2
Xc248 net40 net858 net870 VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__nand3_1
XFILLER_0_13_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs831 net393 clknet_4_5_0_clk VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__dlxtp_1
XANTENNA_c630_S0 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs842 net486 clknet_4_12_0_clk VGND VGND VPWR VPWR net718 s842/Q_N sky130_fd_sc_hd__dlxbn_1
Xs820 clknet_4_1_0_clk net265 VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__dfxtp_1
Xmerge769 clknet_4_3_0_clk net236 net328 net344 net305 net661 VGND VGND VPWR VPWR
+ net635 net634 sky130_fd_sc_hd__sdfbbn_1
Xs853 clknet_4_13_0_clk net511 VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__dfxtp_1
Xs875 net618 clknet_4_15_0_clk VGND VGND VPWR VPWR net754 s875/Q_N sky130_fd_sc_hd__dlxbp_1
Xs864 net580 clknet_4_11_0_clk VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xclkbuf_0_net370 net370 VGND VGND VPWR VPWR clknet_0_net370 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc760 net778 clknet_1_1__leaf_net473 net614 net68 net664 net753 VGND VGND VPWR VPWR
+ net625 sky130_fd_sc_hd__mux4_4
XANTENNA_s862_GATE_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput7 in14 VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__buf_6
XFILLER_0_36_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c686_B1 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c715_S0 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout171_X net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c596_A0 net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c528_Y net405 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c450_S0 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c762_A2 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c481_A3 net22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c609_S1 net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output100_A net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_1_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc590 net941 net927 net660 VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__nand3_1
XFILLER_0_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_63_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c474_SET_B net893 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c223_B net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_65_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c582_A2 net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c168_D_N net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c429_S1 net688 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c63_S0 net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_74_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c540_X net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c71_A net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c492_A2 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input61_A in8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_92_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c331_D_N net688 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput21 in27 VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_12_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c683_A1 net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput10 in17 VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput32 in37 VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__buf_4
Xinput43 in47 VGND VGND VPWR VPWR net808 sky130_fd_sc_hd__clkbuf_2
Xinput54 in57 VGND VGND VPWR VPWR net819 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c570_D_N net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c438_B clknet_1_0__leaf_net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c333_A net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c612_CLK_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_89_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c124_C_N net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_46_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c622_S1 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c487_A2 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c694_A0 net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c354_C_N net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c290_B net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c343_Y net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c754_A3 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone46 net921 VGND VGND VPWR VPWR net993 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c593_C_N net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c345_C_N net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c617_S1 net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input24_A in3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c498_A1 net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c415_D net296 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c136_B net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c574_A3 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc408 net297 net83 net910 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__nand3_2
Xc419 net197 net295 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__nor2b_4
Xmax_cap140 net325 VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__dlymetal6s2s_1
XANTENNA_c575_C_N net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c437_S1 net681 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c286_X net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c599_A0 net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c453_S0 net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c749_A3 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c484_A3 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c296_SCE net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c188_A_N net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input27_X net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c394_A3 net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_10_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c260_C net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c246_A net35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c420_B net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_61_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc227 net155 net878 net940 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__or3_4
Xc216 clknet_4_1_0_clk net894 net1000 net143 net795 net5 VGND VGND VPWR VPWR net148
+ net147 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_13_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc205 net794 net2 net132 net938 net688 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__a2111o_1
XTAP_TAPCELL_ROW_92_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc249 net169 net58 net787 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__or3b_1
Xc238 net156 net168 net916 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__nand3b_1
XANTENNA_c668_X net529 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs832 net396 clknet_4_7_0_clk VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__lpflow_inputisolatch_1
XANTENNA_c495_A2 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs821 clknet_4_8_0_clk net316 VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__dfxtp_2
Xs843 net491 clknet_4_3_0_clk VGND VGND VPWR VPWR net719 s843/Q_N sky130_fd_sc_hd__dlxbp_1
Xs854 clknet_4_7_0_clk net513 VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__dlclkp_1
Xs876 net619 clknet_4_15_0_clk VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs865 clknet_4_14_0_clk net583 VGND VGND VPWR VPWR net743 net742 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_23_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc761 net771 net17 net202 net672 net745 net756 VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__mux4_1
Xc750 net407 net802 net376 net483 net594 net68 VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__mux4_4
Xinput8 in15 VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_78_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c715_S1 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c363_A net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c596_A1 net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c151_X net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout164_X net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c731_S0 net371 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c450_S1 net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c762_A3 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c554_A_N net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc580 net414 clknet_1_0__leaf_net361 net841 net359 VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__or4bb_4
Xc591 net782 net841 net889 net456 net463 net341 VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__mux4_4
XFILLER_0_47_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_0__f_net685_X clknet_1_0__leaf_net685 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c209_A net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_76_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c63_S1 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c578_A net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c726_S0 net677 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_87_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c757_A3 net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c461_S0 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_356 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input54_A in57 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c636_S0 net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput22 in28 VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_12_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput11 in18 VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__buf_8
XTAP_TAPCELL_ROW_40_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput44 in48 VGND VGND VPWR VPWR net809 sky130_fd_sc_hd__clkbuf_2
Xinput55 in58 VGND VGND VPWR VPWR net820 sky130_fd_sc_hd__buf_1
Xinput33 in38 VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__buf_1
XFILLER_0_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c340_C net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c333_B clknet_1_0__leaf_net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c323_SCD net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s819_Q net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input1_X net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c487_A3 net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge768_S0 net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input57_X net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c673_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c694_A1 net525 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_hold62_A net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c276_A net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c169_Y net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c548_B net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_2_0_clk_X clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c290_C_N net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c498_A2 net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input17_A in23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c298_D_N net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c535_SCD net405 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s845_GATE_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c535_RESET_B net408 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c332_D1 net675 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c129_B net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc409 net302 net72 net296 net911 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__or4bb_2
Xmax_cap152 net200 VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_40_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input9_A in16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c599_A1 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge765_S1 net854 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge797_Q net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c246_B net821 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c141_A net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c413_B net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c406_A net304 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc217 clknet_4_1_0_clk net24 net813 net923 net894 net675 VGND VGND VPWR VPWR net150
+ net149 sky130_fd_sc_hd__sdfbbp_1
Xc206 net14 net129 net931 net814 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__or4bb_1
XTAP_TAPCELL_ROW_92_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc239 net164 net106 net894 net160 net934 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__a2111o_1
Xc228 net23 net106 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__nand2b_1
XFILLER_0_13_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c396_X net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c563_X net442 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c295_B_N net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs833 clknet_4_13_0_clk net397 VGND VGND VPWR VPWR net708 s833/Q_N sky130_fd_sc_hd__dfxbp_1
Xs822 clknet_4_9_0_clk net337 VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__dlclkp_1
XFILLER_0_36_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs855 clknet_4_13_0_clk net515 VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__dlclkp_2
Xs877 net623 clknet_4_15_0_clk VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_36_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs866 clknet_4_14_0_clk net588 VGND VGND VPWR VPWR net744 s866/Q_N sky130_fd_sc_hd__dfxbp_1
Xs844 net492 clknet_4_12_0_clk VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_63_251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net361 net361 VGND VGND VPWR VPWR clknet_0_net361 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net394 net394 VGND VGND VPWR VPWR clknet_0_net394 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc740 net953 net593 net376 net691 net700 net747 VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__mux4_2
Xc762 net793 net804 net885 net85 net591 net625 VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__mux4_4
Xc751 net596 net521 net810 net514 net601 net17 VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__mux4_1
XANTENNA_clkbuf_4_10_0_clk_X clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput9 in16 VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_59_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net238 clknet_0_net238 VGND VGND VPWR VPWR clknet_1_0__leaf_net238
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c596_A2 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c530_B net405 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout157_X net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c409_X net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge815_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s833_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_51_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc570 net445 net449 net432 net830 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__or4bb_1
Xc581 net124 net1014 net93 net203 net692 VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__a2111oi_1
Xc592 clknet_4_9_0_clk net457 net413 net841 clknet_1_1__leaf_net458 VGND VGND VPWR
+ VPWR net472 sky130_fd_sc_hd__sdfstp_2
XFILLER_0_47_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s824_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c717_SET_B net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_15_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c209_B net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput110 net875 VGND VGND VPWR VPWR out53 sky130_fd_sc_hd__buf_2
XFILLER_0_42_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c234_C1 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c578_B net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c726_S1 net692 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c189_S0 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input47_A in50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net715 clknet_0_net715 VGND VGND VPWR VPWR clknet_1_1__leaf_net715
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net748 clknet_0_net748 VGND VGND VPWR VPWR clknet_1_1__leaf_net748
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c678_C_N net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput12 in19 VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c683_A3 net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput34 in39 VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__clkbuf_2
Xinput45 in49 VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__buf_1
Xinput23 in29 VGND VGND VPWR VPWR net788 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c349_CLK_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput56 in59 VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_20_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c501_A0 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c159_B net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c319_A net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c590_A net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c737_S0 net688 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge768_S1 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge784_S0 net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c694_A2 net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_73_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c171_A net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c443_B net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c109_A2 net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c480_SCD net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c498_A3 net336 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge779_S0 net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output78_A clknet_1_0__leaf_net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c471_SCD net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c332_C1 net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap153 net919 VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__buf_1
Xmax_cap131 net1015 VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__dlymetal6s2s_1
Xmax_cap142 net126 VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c181_Y net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c734_S1 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c553_A net677 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c446_Y net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c197_S0 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s827_GATE clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge781_S1 net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge809_Q_N net682 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output116_A net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c327_C1 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c444_SCD net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c190_C_N net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s818_Q_N net693 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_81_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c246_C net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c134_A net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc218 clknet_4_4_0_clk net128 net139 net894 net950 net142 VGND VGND VPWR VPWR net152
+ net151 sky130_fd_sc_hd__sdfbbn_1
Xc207 net11 net111 net14 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__and3b_1
XFILLER_0_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc229 net161 net30 VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__or2_2
XFILLER_0_13_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs834 clknet_4_5_0_clk net398 VGND VGND VPWR VPWR net710 net709 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_83_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c94_B net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs823 clknet_4_3_0_clk net351 VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__dlclkp_2
XTAP_TAPCELL_ROW_101_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs856 clknet_4_13_0_clk net518 VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_36_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs867 clknet_4_14_0_clk net590 VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__dfxtp_1
Xs845 net493 clknet_4_12_0_clk VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_91_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs878 net627 clknet_4_13_0_clk VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_63_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc730 net452 net466 net372 net574 net906 net688 VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__mux4_4
Xc752 net109 net499 net489 net613 net82 net725 VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__mux4_1
Xc763 net343 net298 net626 net696 net751 net757 VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__mux4_4
Xc741 net472 net598 net230 net770 net605 clknet_1_0__leaf_net748 VGND VGND VPWR VPWR
+ net606 sky130_fd_sc_hd__mux4_1
XANTENNA_input32_X net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c504_A0 net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c284_S1 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c468_D net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c356_B net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c144_Y net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc571 net437 net215 net444 net446 net195 net830 VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__mux4_1
Xc560 net191 net433 net431 VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__and3b_1
Xc582 net194 net924 net210 net410 net79 VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__a2111oi_2
XFILLER_0_47_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc593 clknet_1_1__leaf_net356 net904 net247 net472 VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__or4bb_4
XPHY_EDGE_ROW_16_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c145_C_N net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_35_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_25_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c216_D net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput100 net865 VGND VGND VPWR VPWR out43 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput111 net876 VGND VGND VPWR VPWR out54 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c234_B1 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c585_D net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c299_A net661 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c742_S1 net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_43_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c189_S1 net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c425_C1 net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net749 clknet_0_net749 VGND VGND VPWR VPWR clknet_1_1__leaf_net749
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_61_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput13 in2 VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_12_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput35 in4 VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__buf_4
Xinput46 in5 VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__buf_8
Xinput24 in3 VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__buf_1
XFILLER_0_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput57 in6 VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_70_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c501_A1 net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c221_B net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c590_B net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c328_Q_N net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c753_S0 net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net568 clknet_0_net568 VGND VGND VPWR VPWR clknet_1_1__leaf_net568
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c694_A3 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c398_B_N net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c269_B net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c164_A net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c436_B net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_51_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c256_D1 net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c480_SCE net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s874_GATE_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge779_S1 net675 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input62_X net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap142_A net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c471_SCE net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c393_S0 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap121 net887 VGND VGND VPWR VPWR net886 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_96_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap154 net878 VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__clkbuf_2
Xmax_cap165 net10 VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_0_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c543_B_N net405 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c599_A3 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c281_A net864 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c167_X net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c546_A net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c750_S1 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c417_A0 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input22_A in28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output109_A net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c134_B net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc208 net931 net3 net923 net121 net132 net24 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_92_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc219 clknet_4_1_0_clk net1009 net2 net149 net894 net923 VGND VGND VPWR VPWR net154
+ net153 sky130_fd_sc_hd__sdfbbn_1
XANTENNA_c534_D1 net405 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c284_X net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs824 clknet_4_3_0_clk net353 VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__dlclkp_4
XTAP_TAPCELL_ROW_101_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs835 clknet_4_13_0_clk net399 VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__dfxtp_1
Xs857 net519 clknet_4_13_0_clk VGND VGND VPWR VPWR net733 s857/Q_N sky130_fd_sc_hd__dlxbn_1
Xs846 net504 clknet_4_13_0_clk VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__dlxtn_1
Xs868 clknet_4_15_0_clk net599 VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs879 net633 clknet_4_0_0_clk VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__dlxtp_1
XFILLER_0_63_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc720 net307 clknet_1_0__leaf_net568 net456 net777 net940 net895 VGND VGND VPWR VPWR
+ net585 sky130_fd_sc_hd__mux4_4
Xc731 net770 net768 net822 net535 net371 net721 VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__mux4_4
Xc753 net21 net766 net456 net602 net852 net734 VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__mux4_1
Xc764 net570 net347 net230 net628 net624 net714 VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__mux4_1
Xc742 net605 net582 net319 net262 net817 net852 VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__mux4_4
XANTENNA_c610_A0 net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c356_C net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c137_Y net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c424_SET_B net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c756_S0 net682 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c711_C1 net529 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c491_S0 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c592_SCD net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c605_A0 net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc561 net436 net783 net437 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__or3b_1
Xc550 net99 net773 net910 VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__and3_1
Xc572 net215 net783 net922 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__and3_2
Xc583 clknet_1_1__leaf_net231 clknet_1_0__leaf_net458 net422 net461 clknet_1_1__leaf_net459
+ VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__a2111o_2
Xc594 net781 net841 net298 net941 net768 VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__o2111a_1
XFILLER_0_47_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c471_RESET_B net13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput101 net866 VGND VGND VPWR VPWR out44 sky130_fd_sc_hd__buf_2
XFILLER_0_70_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput112 net942 VGND VGND VPWR VPWR out55 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout162_X net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c414_X net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c486_S0 net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c425_B1 net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput36 in40 VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput14 in20 VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__buf_4
Xinput25 in30 VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__buf_1
XFILLER_0_52_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput58 in60 VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__clkbuf_2
Xinput47 in50 VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_75_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c351_C1 net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c501_A2 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c221_C net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c197_X net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c364_X net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c531_X net408 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_rebuffer25_A net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input52_A in55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c602_A1 net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c569_RESET_B net439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_587 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_7_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c164_B net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c157_A net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net715 net715 VGND VGND VPWR VPWR clknet_0_net715 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net748 net748 VGND VGND VPWR VPWR clknet_0_net748 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c256_C1 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c748_S1 net407 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s817_Q net692 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_524 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c586_Y net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c579_X net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c483_S1 net658 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c447_D1 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c65_X net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s881_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c332_A1 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net377 clknet_0_net377 VGND VGND VPWR VPWR clknet_1_1__leaf_net377
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_hold60_A net712 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap122 net566 VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__buf_1
XFILLER_0_96_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s872_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c281_B net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c274_A net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c685_D_N net525 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c539_A net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c219_Q_N net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c759_S0 clknet_1_1__leaf_net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c417_A1 net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c420_C_N net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c494_S0 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input15_A in21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c676_D_N net529 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c608_B1 net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c411_C_N net296 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc209 net923 net85 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__nor2_1
XFILLER_0_25_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c534_C1 net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_92_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input7_A in14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs825 net362 clknet_4_12_0_clk VGND VGND VPWR VPWR net701 net700 sky130_fd_sc_hd__dlxbn_1
XTAP_TAPCELL_ROW_101_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs836 clknet_4_7_0_clk net400 VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__dfxtp_2
Xs858 net520 clknet_4_13_0_clk VGND VGND VPWR VPWR net734 s858/Q_N sky130_fd_sc_hd__dlxbn_1
Xs847 net505 clknet_4_7_0_clk VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__dlxtp_1
XFILLER_0_91_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs869 clknet_4_15_0_clk net603 VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc710 net567 net569 net564 net783 net941 net343 VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__mux4_1
Xc721 net528 net584 net896 net741 net742 VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__o2111a_1
Xc754 net512 net134 clknet_1_0__leaf_net459 net110 net773 net659 VGND VGND VPWR VPWR
+ net619 sky130_fd_sc_hd__mux4_4
Xc732 net559 net296 net767 net778 net768 net743 VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__mux4_1
Xc743 net783 net792 net497 net896 net119 net750 VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__mux4_1
XANTENNA_c607_SET_B net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_15_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c568_Q net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c610_A1 net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input18_X net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge772_D1 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c244_B net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c404_A net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s818_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xwire1 net490 VGND VGND VPWR VPWR net1013 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c711_B1 net472 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c491_S1 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c592_SCE net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc540 net666 VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c605_A1 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc562 net662 VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__inv_2
Xc551 net327 net191 net950 VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__nor3_1
Xc573 net767 net205 net787 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__nand3b_1
Xc584 clknet_4_9_0_clk net889 net216 clknet_1_1__leaf_net459 net939 VGND VGND VPWR
+ VPWR net463 sky130_fd_sc_hd__sdfstp_1
Xc595 net89 net133 net922 net767 net900 VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__a2111o_1
XANTENNA_c621_A0 net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge808_Q net681 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput102 net867 VGND VGND VPWR VPWR out45 sky130_fd_sc_hd__buf_2
Xoutput113 net919 VGND VGND VPWR VPWR out58 sky130_fd_sc_hd__buf_2
XFILLER_0_2_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c234_A2 net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c194_B net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c361_B net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_1_1__f_net873_X clknet_1_1__leaf_net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c407_X net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c706_A0 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c486_S1 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c425_A1 net788 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c441_A0 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s857_GATE_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c95_X net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput15 in21 VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__buf_4
Xinput37 in41 VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_40_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput26 in31 VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput48 in51 VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__buf_2
XFILLER_0_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput59 in61 VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_75_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc370 clknet_1_0__leaf_net286 clknet_1_0__leaf_net287 clknet_1_1__leaf_net687 VGND
+ VGND VPWR VPWR net288 sky130_fd_sc_hd__and3b_4
Xc392 net259 net173 net774 net867 clknet_1_0__leaf_net281 net937 VGND VGND VPWR VPWR
+ net292 sky130_fd_sc_hd__mux4_2
XANTENNA_c351_B1 net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c501_A3 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net843_X clknet_1_0__leaf_net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c207_B net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_3_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c245_A1 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c576_B net442 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c497_S0 net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_rebuffer18_A net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input45_A in49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c602_A2 net405 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout170 net68 VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__buf_4
XFILLER_0_44_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c474_SCD net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c669_A_N net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c157_B net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net749 net749 VGND VGND VPWR VPWR clknet_0_net749 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c217_SCD net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_22_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c447_C1 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_49_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input48_X net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c332_A2 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_58_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net356 clknet_0_net356 VGND VGND VPWR VPWR clknet_1_1__leaf_net356
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_29_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap123 net1013 VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_40_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c267_A net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c539_B net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c105_S0 net28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge790_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net568 net568 VGND VGND VPWR VPWR clknet_0_net568 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c417_A2 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c714_A0 net333 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c494_S1 net688 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c152_A2 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_4_11_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_rebuffer40_X net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c624_A0 net258 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output76_A net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c92_A_N net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_92_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c551_A net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c709_A0 net525 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs837 clknet_4_5_0_clk net401 VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__dfxtp_1
Xs848 net506 clknet_4_7_0_clk VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xs826 net378 clknet_4_6_0_clk VGND VGND VPWR VPWR net703 net702 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_63_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xs859 net531 clknet_4_11_0_clk VGND VGND VPWR VPWR net736 net735 sky130_fd_sc_hd__dlxbp_1
XFILLER_0_91_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c489_S1 net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c62_A0 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc700 net563 net529 net670 VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__and3b_1
Xc722 clknet_4_11_0_clk net564 net85 net525 net1015 net674 VGND VGND VPWR VPWR net587
+ c722/Q_N sky130_fd_sc_hd__sdfbbp_1
Xc711 clknet_1_1__leaf_net338 net345 net472 net529 net736 VGND VGND VPWR VPWR net575
+ sky130_fd_sc_hd__a2111oi_4
Xc755 net19 net34 net766 net740 net754 net755 VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__mux4_1
Xc733 net767 net939 net688 clknet_1_0__leaf_net715 net720 net745 VGND VGND VPWR VPWR
+ net598 sky130_fd_sc_hd__mux4_1
Xc744 net79 net608 net822 net746 clknet_1_1__leaf_net748 clknet_1_1__leaf_net749 VGND
+ VGND VPWR VPWR net609 sky130_fd_sc_hd__mux4_4
XANTENNA_c296_Q net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c610_A2 net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c619_A0 net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge788_Q net658 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge772_C1 net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_66_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net873_X clknet_1_0__leaf_net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c132_A net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c404_B net190 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c576_D_N net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c92_B net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer48_A net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c174_A0 net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc530 net195 net405 net910 VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__nand3b_2
XANTENNA_c605_A2 net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc552 net988 net216 net668 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__nand3b_2
Xc563 net441 net99 net681 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__or3_2
Xc541 net418 net779 VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__nand2b_2
Xc585 clknet_4_6_0_clk net340 net851 net949 net997 VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__sdfstp_1
Xc596 net340 net146 net925 net877 net464 net783 VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__mux4_1
XANTENNA_c319_D_N net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc574 net422 net333 net941 net900 net452 net344 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__mux4_2
XANTENNA_c621_A1 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input30_X net795 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_63_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput114 net879 VGND VGND VPWR VPWR out59 sky130_fd_sc_hd__buf_2
XFILLER_0_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput103 net868 VGND VGND VPWR VPWR out46 sky130_fd_sc_hd__buf_2
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c163_A_N net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c187_B net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c250_A2 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c354_B net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c347_A net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c302_X net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c706_A1 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c425_A2 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c441_A1 net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_21_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c84_D1 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_30_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c466_D1 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput16 in22 VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__buf_2
XFILLER_0_37_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput27 in32 VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c616_A1 net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput49 in52 VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c677_S1 net525 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput38 in42 VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__buf_2
XFILLER_0_52_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c632_A0 net13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc371 net157 net222 clknet_1_0__leaf_net286 net160 VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__or4bb_4
Xc360 net166 net132 net811 net881 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__or4bb_1
XFILLER_0_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc393 net54 net283 net787 net811 net916 net943 VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_48_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c245_A2 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c102_B net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c297_A net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c688_DE net529 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net370 clknet_0_net370 VGND VGND VPWR VPWR clknet_1_0__leaf_net370
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c497_S1 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input38_A in42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c602_A3 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout160 net189 VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__buf_4
Xfanout171 net852 VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__buf_4
Xclkbuf_1_1__f_net549 clknet_0_net549 VGND VGND VPWR VPWR clknet_1_1__leaf_net549
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c627_A0 net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c346_A1 net66 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc190 net77 net117 net96 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__or3b_4
XFILLER_0_85_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c317_B net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c217_SCE net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone1 net822 net70 net769 net64 net800 net932 VGND VGND VPWR VPWR net1016 sky130_fd_sc_hd__mux4_1
XFILLER_0_85_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c587_A_N net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap124 net461 VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c162_A net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout175_A net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c539_C net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c434_B net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c222_Y net854 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c417_A3 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c152_A3 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c730_A0 net452 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c607_RESET_B net406 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c608_A2 net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input60_X net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c601_SCE net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_92_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_69_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c551_B net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_77_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c165_X net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c709_A1 net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs838 clknet_4_7_0_clk net402 VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__dlclkp_1
Xs849 clknet_4_12_0_clk net507 VGND VGND VPWR VPWR net725 s849/Q_N sky130_fd_sc_hd__dfxbp_1
Xs827 net386 clknet_4_15_0_clk VGND VGND VPWR VPWR net705 net704 sky130_fd_sc_hd__dlxbp_1
XANTENNA_c291_D_N net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net377 net377 VGND VGND VPWR VPWR clknet_0_net377 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c725_A0 net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c62_A1 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_86_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc701 net319 net433 net563 net554 net670 net738 VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__mux4_1
Xc712 net326 net546 net900 net434 net766 VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__o2111a_1
Xc756 net774 net73 net301 net497 net682 net752 VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__mux4_4
Xc723 net579 net578 net584 net408 net683 net741 VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__mux4_4
Xc734 net574 net535 net483 net84 net975 net885 VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__mux4_1
Xc745 net498 net691 net705 net745 clknet_1_1__leaf_net748 clknet_1_0__leaf_net749
+ VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__mux4_4
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c460_A0 net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input20_A in26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c610_A3 net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output107_A net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c635_A0 net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c696_S0 net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s825_D net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c458_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c132_B net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire3 net541 VGND VGND VPWR VPWR net1015 sky130_fd_sc_hd__buf_1
XANTENNA_c280_A0 net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c711_A2 net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c439_A1 clknet_1_0__leaf_net338 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_362 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c688_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c174_A1 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc531 net297 net937 net911 VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__or3b_4
XANTENNA_c605_A3 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc542 net415 net419 net408 VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__or3b_1
Xc564 net440 net430 net442 VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__and3_1
Xc553 net677 VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__buf_1
Xc586 net205 net939 net464 VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__nor3_2
Xc575 net795 net90 net808 net344 VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__or4bb_1
Xc597 net410 net474 net771 net468 net969 net894 VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__mux4_1
XANTENNA_c568_SCD net439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input23_X net788 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput115 net880 VGND VGND VPWR VPWR out6 sky130_fd_sc_hd__clkbuf_4
Xoutput104 net869 VGND VGND VPWR VPWR out47 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_70_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c187_C net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c459_D net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c347_B net21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c135_Y net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c706_A2 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c441_A2 net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_net899_7_A clknet_1_0__leaf_net685 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c304_S0 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c84_C1 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c722_SCD net525 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c321_Q net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput28 in33 VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__buf_2
XFILLER_0_91_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput17 in23 VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c616_A2 net851 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput39 in43 VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_52_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c632_A1 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc361 net273 net853 net941 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__nor3b_1
Xc372 net274 net204 clknet_1_0__leaf_net287 VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__nand3b_4
Xc350 clknet_4_1_0_clk net143 net258 clknet_1_1__leaf_net685 net695 VGND VGND VPWR
+ VPWR net269 sky130_fd_sc_hd__sdfrtp_2
Xc394 net107 clknet_1_1__leaf_net281 clknet_1_1__leaf_net873 net874 clknet_1_1__leaf_net850
+ net847 VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__mux4_2
XFILLER_0_20_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge773_SCD net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c214_S0 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c245_A3 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c102_C net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c192_A net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout160_X net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c278_C_N net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c733_A0 net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout172 net827 VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_44_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c627_A1 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c346_A2 net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge780_A0 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s884_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output99_A net864 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc180 net922 net90 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__nand2_4
Xc191 net120 net118 net900 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__nor3_4
XFILLER_0_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c212_B net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclone2 net822 net70 net769 net64 net800 net932 VGND VGND VPWR VPWR net1017 sky130_fd_sc_hd__mux4_1
XFILLER_0_66_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c728_A0 net190 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input50_A in53 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c350_RESET_B net258 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap136 net540 VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c162_B net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c155_A net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c427_B net298 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c283_A0 net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c714_A2 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge774_CLK_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c730_A1 net466 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s839_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c63_X net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c624_A2 net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input53_X net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_69_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c551_C net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c544_B net412 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c158_X net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_101_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs839 clknet_4_13_0_clk net403 VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__dlclkp_2
Xs828 net390 clknet_4_6_0_clk VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__dlxtn_1
Xs817 clknet_4_2_0_clk net223 VGND VGND VPWR VPWR net692 net691 sky130_fd_sc_hd__dfxbp_2
Xclkbuf_0_net356 net356 VGND VGND VPWR VPWR clknet_0_net356 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c62_A2 net788 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc702 net926 net563 net326 net533 net540 VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__a2111oi_2
Xc713 net565 net777 net803 net333 net927 net85 VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__mux4_1
Xc724 net542 net587 clknet_1_0__leaf_net473 net895 net900 net448 VGND VGND VPWR VPWR
+ net589 sky130_fd_sc_hd__mux4_4
Xc746 clknet_1_1__leaf_net549 net553 net906 net717 clknet_1_0__leaf_net748 clknet_1_0__leaf_net749
+ VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__mux4_1
Xc735 net405 net883 net922 net84 net372 net953 VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__mux4_1
Xc757 net800 net620 net615 net804 clknet_1_1__leaf_net686 clknet_1_1__leaf_net715
+ VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__mux4_2
XANTENNA_c741_A0 net472 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input13_A in2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c619_A2 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_416 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c635_A1 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c696_S1 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c667_B_N net405 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_38_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c419_B_N net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s846_GATE_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input5_A in12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c280_A1 net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c661_B net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c275_X net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer40 net882 VGND VGND VPWR VPWR net987 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c439_A2 net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc554 net88 net782 net412 VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__and3b_1
Xc543 net775 net405 VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__or2b_1
Xc532 net768 net927 VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__and2b_1
Xc587 net465 net660 VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__nand2b_2
Xc565 net653 VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__buf_6
Xc576 net341 net442 net100 net941 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__or4bb_2
Xc598 net999 net141 net475 net371 net467 net409 VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__mux4_1
XANTENNA_c621_A3 net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input16_X net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput105 net870 VGND VGND VPWR VPWR out48 sky130_fd_sc_hd__buf_2
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput116 net881 VGND VGND VPWR VPWR out60 sky130_fd_sc_hd__buf_2
XFILLER_0_56_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input8_X net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c664_Y net525 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c304_S1 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c90_A net780 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c466_B1 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput18 in24 VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_40_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c616_A3 net483 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput29 in34 VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_52_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c632_A2 net372 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc373 clknet_4_4_0_clk clknet_1_1__leaf_net286 net280 net250 clknet_1_0__leaf_net288
+ clknet_1_0__leaf_net857 VGND VGND VPWR VPWR net291 net290 sky130_fd_sc_hd__sdfbbp_1
Xc362 net218 net41 net259 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__and3b_1
Xc351 net112 net269 net819 net971 net695 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__o2111a_1
Xc340 net257 net222 net826 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__and3_2
Xc395 net179 net811 net107 net867 net918 clknet_1_0__leaf_net850 VGND VGND VPWR VPWR
+ net294 sky130_fd_sc_hd__mux4_4
XFILLER_0_20_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c214_S1 net134 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c192_B net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c471_D net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net361 clknet_0_net361 VGND VGND VPWR VPWR clknet_1_0__leaf_net361
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net394 clknet_0_net394 VGND VGND VPWR VPWR clknet_1_0__leaf_net394
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c468_SCD net302 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c733_A1 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout151 net833 VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__clkbuf_4
Xfanout162 net82 VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__buf_4
Xfanout173 net817 VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_17_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c346_A3 clknet_1_0__leaf_net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc181 net799 net92 net2 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__nor3_2
Xc170 net784 net71 net778 net853 net786 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__a2111o_4
XFILLER_0_20_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc192 net775 net819 net922 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__nor3_2
XFILLER_0_18_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_87_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c195_Y net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge793_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone3 net74 VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c728_A1 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_rebuffer6_X net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c447_A2 net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_50_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c744_A0 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input43_A in47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c613_SCD net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s843_GATE clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap126 net425 VGND VGND VPWR VPWR net891 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap159 net114 VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_0_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c95_A_N net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net549 net549 VGND VGND VPWR VPWR clknet_0_net549 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_71_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c714_A3 net521 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c730_A2 net372 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c624_A3 net134 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input46_X net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c580_C_N net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c444_RESET_B net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs829 net391 clknet_4_5_0_clk VGND VGND VPWR VPWR net834 sky130_fd_sc_hd__dlxtn_1
Xs818 clknet_4_2_0_clk net244 VGND VGND VPWR VPWR net694 net693 sky130_fd_sc_hd__dfxbp_2
XFILLER_0_63_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c579_D_N net406 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c62_A3 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc703 net761 VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__buf_6
Xc714 net333 net575 net776 net521 net938 net693 VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__mux4_2
Xc725 net430 net589 net581 net577 net688 net744 VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__mux4_2
Xc747 net561 net544 net600 net776 net605 net230 VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__mux4_1
Xc736 net979 net937 net208 net904 net408 net720 VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__mux4_1
Xc758 net319 net785 net789 net144 net622 net746 VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__mux4_4
XANTENNA_c460_A2 net296 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c307_S1 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c87_A0 net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c619_A3 net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge772_A2 net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c635_A2 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output74_A net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge773_CLK_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_clk_X clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge788_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_9_0_clk_X clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c166_A_N net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c280_A2 net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c170_X net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer30 net976 VGND VGND VPWR VPWR net977 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_68_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer41 net989 VGND VGND VPWR VPWR net988 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_95_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c143_S0 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c439_A3 net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c602_X net483 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c736_A1 net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc500 clknet_1_1__leaf_net287 clknet_1_1__leaf_net289 net793 net907 net834 net709
+ VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__mux4_4
XANTENNA_c752_A0 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc555 net677 VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__buf_1
Xc533 net295 net935 VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__nand2b_1
Xc544 net419 net412 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__and2b_1
Xc566 net764 VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__inv_2
Xc577 net110 net453 net203 net69 net240 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__a2111o_1
Xc588 clknet_4_9_0_clk net346 net345 net841 net343 net781 VGND VGND VPWR VPWR net468
+ net467 sky130_fd_sc_hd__sdfbbn_1
Xc599 net248 net3 net470 net927 net958 net970 VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__mux4_1
XFILLER_0_63_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c482_SET_B net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_71_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput106 net871 VGND VGND VPWR VPWR out49 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput117 net987 VGND VGND VPWR VPWR out61 sky130_fd_sc_hd__buf_2
XFILLER_0_50_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c402_B net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c83_A net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c466_A1 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput19 in25 VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_40_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc330 net758 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__buf_1
XANTENNA_c632_A3 net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc363 net188 net272 net945 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__or3_1
Xc352 net6 net110 net258 net934 net185 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__o2111a_1
Xc341 net188 net110 net218 net258 net257 net694 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc396 net981 net195 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__and2_1
XFILLER_0_99_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c392_A0 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c192_C net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c185_B net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c541_A_N net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c178_A net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_1_1__f_net697_X clknet_1_1__leaf_net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c133_X net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c300_X net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c405_Y net304 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c733_A2 net688 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout141 net202 VGND VGND VPWR VPWR net906 sky130_fd_sc_hd__buf_4
Xfanout174 net810 VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__buf_4
Xfanout163 net929 VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__buf_6
XANTENNA_c532_A_N net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c424_Q net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clone21_X net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_526 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc171 net94 net99 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__nor2b_2
Xc160 net798 net81 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__or2b_4
Xc193 net117 net122 net773 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__or3_1
Xc182 net922 net108 net936 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__and3_2
XFILLER_0_18_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c100_B net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c295_A net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone4 net65 net71 VGND VGND VPWR VPWR net1018 sky130_fd_sc_hd__and2_1
XFILLER_0_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c430_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c728_A2 net302 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c594_D1 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_50_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c760_A0 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input36_A in40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net338 clknet_0_net338 VGND VGND VPWR VPWR clknet_1_1__leaf_net338
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c326_S0 net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c219_SET_B net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge775_A2 net795 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap127 net332 VGND VGND VPWR VPWR net892 sky130_fd_sc_hd__buf_1
XANTENNA_max_cap159_X net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net850 clknet_0_net850 VGND VGND VPWR VPWR clknet_1_1__leaf_net850
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c679_D1 net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c315_B net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c210_A net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c308_A net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c283_A2 net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s829_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c739_A1 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c294_D_N net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c755_A0 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_7_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input39_X net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c503_S1 net712 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c368_A2 net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c265_B net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c160_A net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_5_0_clk_X clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs819 clknet_4_1_0_clk net260 VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_46_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc704 net208 net935 net203 clknet_1_0__leaf_net338 net778 net736 VGND VGND VPWR VPWR
+ net568 sky130_fd_sc_hd__mux4_1
XFILLER_0_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc715 net447 net571 net421 net565 net803 net927 VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__mux4_1
Xc737 net345 net938 net935 clknet_1_0__leaf_net686 net688 net742 VGND VGND VPWR VPWR
+ net602 sky130_fd_sc_hd__mux4_4
Xc726 net896 net979 net85 net19 net677 net692 VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__mux4_1
Xc748 net119 net778 net372 net941 net905 net407 VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__mux4_4
Xc759 net503 net797 net73 net621 clknet_1_1__leaf_net697 net701 VGND VGND VPWR VPWR
+ net624 sky130_fd_sc_hd__mux4_4
XANTENNA_c741_A2 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_55_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c87_A1 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c469_A1 net134 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c635_A3 net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_73_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c280_A3 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer20 net968 VGND VGND VPWR VPWR net967 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c268_Y net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout176_X net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_37_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer31 net976 VGND VGND VPWR VPWR net978 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c428_X net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c330_X net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_587 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c736_A2 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc501 net906 net807 net261 net816 clknet_1_1__leaf_net394 net710 VGND VGND VPWR VPWR
+ net400 sky130_fd_sc_hd__mux4_2
XANTENNA_c421_D_N net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc534 net964 net910 net312 net193 net405 VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__o2111ai_1
Xc545 net410 net72 VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__nor2_1
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc567 net444 net417 net330 net797 net910 net441 VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__mux4_1
Xc556 net760 VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__buf_6
Xc578 net92 net416 clknet_1_1__leaf_net361 net326 VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__or4bb_1
Xc589 net240 net210 net185 net358 net457 net466 VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__mux4_1
XANTENNA_s879_GATE clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c334_S0 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c365_A3 net134 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput107 net872 VGND VGND VPWR VPWR out50 sky130_fd_sc_hd__buf_2
Xoutput118 net883 VGND VGND VPWR VPWR out7 sky130_fd_sc_hd__buf_2
XANTENNA_merge776_SCD net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_1_0__f_net697_X clknet_1_0__leaf_net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c687_D1 net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c228_B net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c280_X net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c552_Y net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge811_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c557_SET_B clknet_1_0__leaf_net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c84_A2 net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c83_B net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c424_Q_N net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c763_A0 net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc320 net806 net236 VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__nand2_4
Xc353 net690 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_75_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc342 net251 net142 net819 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__or3b_2
Xc331 net7 net108 net143 net688 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__or4bb_1
Xc364 net935 net35 net915 net280 net276 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__a2111o_1
Xc397 net766 net777 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__nand2b_4
XFILLER_0_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input21_X net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_13_0_clk_X clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s820_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c300_D1 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_97_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c178_B net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c345_B net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout164 net76 VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__buf_8
Xfanout175 net804 VGND VGND VPWR VPWR net940 sky130_fd_sc_hd__clkbuf_8
XANTENNA_net899_5_A clknet_1_0__leaf_net685 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c758_A0 net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c493_A0 net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s869_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c79_X net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc150 net826 net64 net928 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__or3_4
Xc172 net99 net86 net784 net770 net94 net101 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__mux4_2
Xc161 net776 net91 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__nand2b_4
Xc194 net123 net120 net931 net936 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__or4bb_4
Xc183 net808 net853 net931 net108 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__or4bb_4
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c205_D1 net688 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c416_S1 net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone5 net769 net826 net811 VGND VGND VPWR VPWR net1019 sky130_fd_sc_hd__and3_1
XFILLER_0_91_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c728_A3 net535 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c594_C1 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c744_A2 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input29_A in34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c488_A0 net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c269_A_N net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_output97_A net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap139 net905 VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__buf_1
Xmax_cap128 net309 VGND VGND VPWR VPWR net893 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net873 clknet_0_net873 VGND VGND VPWR VPWR clknet_1_1__leaf_net873
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c679_C1 net412 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c308_B net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_1_0_clk_X clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c572_A net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c739_A2 net466 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c755_A1 net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c490_A1 net44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c588_CLK_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_101_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c418_A net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c710_S0 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c320_A net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c591_A0 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc727 net421 net803 net320 net771 net566 net534 VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__mux4_1
Xc716 net434 net576 net792 net472 net345 net886 VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__mux4_4
Xc705 net426 net230 net542 net778 net936 net694 VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__mux4_4
Xc738 net408 net529 net885 net82 net693 net1011 VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__mux4_1
XFILLER_0_97_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c218_SET_B net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc749 net262 net154 net773 net771 net610 net800 VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__mux4_2
XANTENNA_c321_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c741_A3 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c620_S0 net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c485_A1 net44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer24_X net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_78_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input51_X net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net715 clknet_0_net715 VGND VGND VPWR VPWR clknet_1_0__leaf_net715
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net748 clknet_0_net748 VGND VGND VPWR VPWR clknet_1_0__leaf_net748
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c395_A1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c194_D_N net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c270_A net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c705_S0 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer10 net956 VGND VGND VPWR VPWR net957 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_65_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer43 net993 VGND VGND VPWR VPWR net990 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c163_Y net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_37_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer32 net978 VGND VGND VPWR VPWR net979 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_95_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout169_X net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c156_X net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc502 clknet_1_1__leaf_net288 net306 clknet_1_1__leaf_net285 net865 net849 net712
+ VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__mux4_2
Xc535 clknet_4_8_0_clk net406 net408 net405 net312 net666 VGND VGND VPWR VPWR net413
+ net412 sky130_fd_sc_hd__sdfbbn_2
XTAP_TAPCELL_ROW_9_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc546 net773 net72 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__or2_1
Xc568 clknet_4_8_0_clk net315 net439 net890 net417 VGND VGND VPWR VPWR net447 net446
+ sky130_fd_sc_hd__sdfsbp_1
Xc557 clknet_4_8_0_clk net429 net910 net431 net936 clknet_1_0__leaf_net697 VGND VGND
+ VPWR VPWR net436 net435 sky130_fd_sc_hd__sdfbbn_1
Xc579 net93 net248 net412 net406 VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__or4bb_4
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input11_A in18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c496_A0 net893 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput119 net884 VGND VGND VPWR VPWR out9 sky130_fd_sc_hd__buf_2
XFILLER_0_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput108 clknet_1_0__leaf_net873 VGND VGND VPWR VPWR out51 sky130_fd_sc_hd__clkbuf_1
Xoutput90 net897 VGND VGND VPWR VPWR out33 sky130_fd_sc_hd__clkbuf_4
XANTENNA_merge776_SCE net691 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c687_C1 clknet_1_0__leaf_net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout129_A net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input3_A in10 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c538_X net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c83_C net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c763_A1 net298 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc321 clknet_4_0_0_clk net123 net90 net931 net232 VGND VGND VPWR VPWR net240 net239
+ sky130_fd_sc_hd__sdfrbp_1
Xc310 net678 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_75_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc354 net222 net97 net922 net28 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__or4bb_1
Xc332 net125 net923 net78 net819 net675 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__a2111o_1
Xc343 net108 net925 net692 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__nand3_4
XANTENNA_input59_A in61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc365 net280 net152 net279 net134 net935 net934 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__mux4_1
XANTENNA_c158_D_N net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc398 net965 net777 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__nor2b_1
XANTENNA_clone3_X net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input14_X net779 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge791_Q net661 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c300_C1 net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer1 net357 VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c392_A2 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c338_B net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input6_X net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout176 net789 VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__buf_4
XANTENNA_merge796_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c758_A1 net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c493_A1 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc151 net64 net928 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__and2_2
Xc162 net67 net88 VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__and2_2
Xc140 net777 net780 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__or2_2
Xc173 net769 net100 net102 net101 net98 net928 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__mux4_4
Xc195 net639 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__clkinv_8
Xc184 net786 net113 net111 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__nor3_1
XANTENNA_merge804_Q net677 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c607_SCD net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c205_C1 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c288_B net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c183_A net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone6 net75 net766 VGND VGND VPWR VPWR net1020 sky130_fd_sc_hd__nand2_1
XANTENNA_c713_S0 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout151_X net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_B1 net298 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c623_S0 net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c488_A1 net854 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_531 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c478_RESET_B net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c670_A2 net529 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c146_B_N net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s858_GATE_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c679_B1 net521 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c572_B net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c137_B_N net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c589_A0 net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c739_A3 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c755_A2 net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c490_A2 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c618_S0 net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input41_A in45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c317_C_N net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c153_B net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c146_A net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net338 net338 VGND VGND VPWR VPWR clknet_0_net338 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c710_S1 net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c313_A net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_60_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c591_A1 net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc706 net203 net797 net906 net567 net110 net692 VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__mux4_2
Xc717 clknet_4_14_0_clk net577 net84 clknet_1_0__leaf_net459 net544 net345 VGND VGND
+ VPWR VPWR net582 net581 sky130_fd_sc_hd__sdfbbn_1
Xc728 net190 net142 net302 net535 net938 net19 VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__mux4_1
XANTENNA_c169_A_N net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc739 net553 net906 net466 net802 net570 net743 VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__mux4_4
XFILLER_0_97_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c173_S0 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s841_GATE_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c469_A3 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_80_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c485_A2 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net850 net850 VGND VGND VPWR VPWR clknet_0_net850 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input44_X net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net749 clknet_0_net749 VGND VGND VPWR VPWR clknet_1_0__leaf_net749
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_42_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer11 net955 VGND VGND VPWR VPWR net958 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c705_S1 net694 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer44 net993 VGND VGND VPWR VPWR net991 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer22 net914 VGND VGND VPWR VPWR net969 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer33 net976 VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_36_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc503 net284 net816 net851 net671 net710 net712 VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__mux4_1
XFILLER_0_32_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc536 net83 net1017 VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__nor2_1
Xc558 net765 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__inv_6
Xc547 net417 net423 net419 net414 net408 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__a2111oi_2
Xc569 clknet_4_8_0_clk net431 net439 net88 net445 net443 VGND VGND VPWR VPWR net449
+ net448 sky130_fd_sc_hd__sdfbbp_1
XANTENNA_c631_S0 net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c496_A1 net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_334 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput109 net874 VGND VGND VPWR VPWR out52 sky130_fd_sc_hd__buf_2
XFILLER_0_50_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output72_A net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput91 net856 VGND VGND VPWR VPWR out34 sky130_fd_sc_hd__clkbuf_4
Xoutput80 net845 VGND VGND VPWR VPWR out24 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c687_B1 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net568 clknet_0_net568 VGND VGND VPWR VPWR clknet_1_0__leaf_net568
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c217_SET_B net675 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c716_S0 net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c273_Y net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c440_Y net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c747_A3 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c76_C net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c69_B net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc300 net195 net883 net216 net191 net211 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__a2111o_1
Xc311 clknet_1_0__leaf_net685 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__buf_8
XTAP_TAPCELL_ROW_75_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc344 net906 clknet_1_1__leaf_net873 net259 net257 clknet_1_0__leaf_net687 VGND VGND
+ VPWR VPWR net263 sky130_fd_sc_hd__o2111a_2
Xc333 net66 clknet_1_0__leaf_net873 net882 net211 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__or4bb_4
Xc355 net44 net923 net787 VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__nor3_1
Xc366 clknet_4_4_0_clk net279 net915 net125 clknet_1_1__leaf_net843 VGND VGND VPWR
+ VPWR net284 sky130_fd_sc_hd__sdfrtp_1
XANTENNA_c626_S0 net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc399 net190 net766 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__or2_4
XANTENNA_merge769_SET_B net661 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c300_B1 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c323_RESET_B net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge810 clknet_4_6_0_clk net479 net485 VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__edfxtp_1
XFILLER_0_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer2 net877 VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c567_A3 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c338_C net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout141_A net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_88_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c400_B net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout155 net921 VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__buf_12
Xfanout166 net107 VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c758_A2 net789 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc130 net18 net59 net61 net27 net53 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__a2111oi_1
Xc152 net77 net80 net83 net935 net75 net71 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__mux4_2
Xc163 net803 net92 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__nand2b_2
Xc141 net65 net71 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__and2_4
XFILLER_0_85_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc174 net95 net92 net101 net102 net97 net772 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__mux4_1
Xc196 net108 net115 net122 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__nor3_2
Xc185 net114 net106 net112 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c607_SCE net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c205_B1 net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c183_B net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone7 net74 VGND VGND VPWR VPWR net1021 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c713_S1 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c448_B net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c219_RESET_B net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c236_Y net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c594_A1 net781 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s836_Q net712 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c229_X net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c403_Y net302 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c760_A3 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c601_SET_B net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c623_S1 net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c488_A2 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c84_X net21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_rebuffer47_X net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c670_A3 net525 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s859_GATE clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c271_C_N net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c708_S1 net688 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c572_C net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c589_A1 net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c186_Y net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c724_S0 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c179_X net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input34_A in39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c499_A1 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c634_S0 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc90 net780 net18 VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__or2_1
XFILLER_0_97_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c690_D_N net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c442_D_N net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xwire161 net187 VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__buf_2
XFILLER_0_72_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c313_B net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_60_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_15_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c306_A net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c719_S0 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc707 net79 net772 net447 net534 net939 net739 VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__mux4_1
Xc718 net428 net542 clknet_1_1__leaf_net568 net974 clknet_1_0__leaf_net715 net741
+ VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__mux4_4
Xc729 net792 net935 net376 net466 net673 net704 VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_4_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_68_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c99_B net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c485_A3 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net873 net873 VGND VGND VPWR VPWR clknet_0_net873 sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_33_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c629_S0 net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input37_X net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_42_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_60_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer12 net958 VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_65_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer45 net991 VGND VGND VPWR VPWR net992 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer34 net80 VGND VGND VPWR VPWR net981 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_fanout171_A net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer23 net969 VGND VGND VPWR VPWR net970 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c465_C_N net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c149_Y net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c423_A net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c211_X net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc504 net809 net284 net846 net709 net712 net713 VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__mux4_4
Xc537 net666 VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__buf_16
XTAP_TAPCELL_ROW_9_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc559 net318 net937 net912 VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__nor3_1
Xc548 net423 net413 net424 VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__and3_1
XANTENNA_merge814_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c496_A2 net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c456_C_N net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput70 net835 VGND VGND VPWR VPWR out15 sky130_fd_sc_hd__clkbuf_1
Xoutput92 clknet_1_1__leaf_net857 VGND VGND VPWR VPWR out35 sky130_fd_sc_hd__clkbuf_1
Xoutput81 net846 VGND VGND VPWR VPWR out25 sky130_fd_sc_hd__clkbuf_4
XANTENNA_output65_A net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s823_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c208_A0 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_52 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout174_X net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c732_S0 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c433_Y net333 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c763_A3 net696 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc301 net204 net190 net917 net208 net211 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__o2111ai_4
Xc312 net224 net101 net228 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_75_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc345 net255 net230 net925 net259 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__or4bb_1
Xc323 clknet_4_0_0_clk net87 net839 net203 net101 net948 VGND VGND VPWR VPWR net242
+ net241 sky130_fd_sc_hd__sdfbbn_1
Xc334 net219 net826 net250 net864 net97 net245 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__mux4_1
Xc367 net275 net86 clknet_1_0__leaf_net281 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__and3b_4
Xc356 net41 net802 net826 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__and3_1
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge811 clknet_4_0_0_clk net267 net654 VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__sdlclkp_1
XANTENNA_output103_A net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge800 net592 clknet_4_14_0_clk net595 VGND VGND VPWR VPWR net673 net672 sky130_fd_sc_hd__dlrbp_1
XFILLER_0_23_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net377 clknet_0_net377 VGND VGND VPWR VPWR clknet_1_0__leaf_net377
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_80_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c226_B net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c64_S1 net806 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout145 net911 VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__clkbuf_4
Xfanout156 net196 VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__buf_12
Xfanout167 net933 VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__buf_8
XFILLER_0_69_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c462_S0 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c758_A3 net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_7_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c81_B net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc120 net53 net52 net867 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__or3_1
Xc131 net768 net61 net53 net50 net60 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__o2111ai_4
Xc142 net773 net73 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__nor2_8
Xc153 net769 net70 net928 VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__and3b_4
Xc175 net102 net79 net95 net91 c175/D1 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__a2111oi_1
Xc164 net796 net66 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__nand2_2
Xc186 net112 net792 net929 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__nor3b_2
Xc197 net125 net87 net122 net922 net931 net794 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_16_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_99_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c448_C net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c343_B net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c594_A2 net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c660_X net521 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c412_C1 net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c488_A3 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net843 clknet_0_net843 VGND VGND VPWR VPWR clknet_1_1__leaf_net843
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c679_A2 net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_6_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c589_A2 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c339_X net258 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c499_A2 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c634_S1 net822 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input27_A in32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc91 net938 net6 net12 net870 net812 VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__o2111a_1
Xc80 net3 net10 net15 net16 VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__or4bb_4
XFILLER_0_85_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s817_Q_N net691 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c139_B net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c201_A net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c719_S1 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc719 net449 net557 net939 net546 net935 net208 VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__mux4_1
Xc708 net895 net808 net556 net301 net886 net688 VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__mux4_1
XANTENNA_c591_A3 net456 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c735_S0 net372 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c629_S1 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c673_SCD net525 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_78_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c360_D_N net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c692_A2 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_499 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_1 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer24 net921 VGND VGND VPWR VPWR net971 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer13 net192 VGND VGND VPWR VPWR net960 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer35 net913 VGND VGND VPWR VPWR net982 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c535_D net406 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout164_A net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c423_B net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c204_X net134 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc505 net336 net34 net363 net689 net710 net712 VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_9_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc549 net420 net419 net426 VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__nor3_1
Xc538 net303 net666 VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__or2_1
XFILLER_0_99_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c496_A3 net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c328_Q net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_14_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput82 net847 VGND VGND VPWR VPWR out26 sky130_fd_sc_hd__clkbuf_4
Xoutput93 net858 VGND VGND VPWR VPWR out36 sky130_fd_sc_hd__buf_2
Xoutput71 net836 VGND VGND VPWR VPWR out16 sky130_fd_sc_hd__buf_2
XFILLER_0_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c333_D_N net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_70_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c208_A1 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c285_S0 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c324_D_N clknet_1_1__leaf_net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c161_Y net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c597_A2 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c154_X net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc302 net993 net211 net967 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__or3_2
XFILLER_0_60_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc335 net143 net13 net936 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__nand3_1
XFILLER_0_32_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc313 net900 net224 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__and2_0
Xc324 net242 net112 net947 clknet_1_1__leaf_net873 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__or4bb_2
Xc368 net284 net853 net279 net166 clknet_1_1__leaf_net687 VGND VGND VPWR VPWR net286
+ sky130_fd_sc_hd__a2111o_1
Xc357 net127 net915 net151 net273 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__or4bb_1
Xc346 net263 net66 net262 clknet_1_0__leaf_net843 net939 net785 VGND VGND VPWR VPWR
+ net265 sky130_fd_sc_hd__mux4_4
XFILLER_0_99_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c300_A2 net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge801 net573 clknet_4_11_0_clk net585 VGND VGND VPWR VPWR net674 sky130_fd_sc_hd__dlrtn_1
Xmerge812 clknet_4_14_0_clk net597 net611 VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__sdlclkp_2
XFILLER_0_28_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer4 net199 VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_23_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net356 clknet_0_net356 VGND VGND VPWR VPWR clknet_1_0__leaf_net356
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c727_S1 net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout146 net912 VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__buf_1
Xfanout135 net119 VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__buf_4
Xfanout168 net74 VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__buf_12
XANTENNA_input1_A in0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout157 net109 VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__buf_4
XANTENNA_c271_X net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c743_S0 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c462_S1 net694 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c81_C net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c693_CLK_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc110 net39 net18 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__or2_2
XFILLER_0_60_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc121 net51 net18 net1 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__and3_1
Xc143 net822 net70 net769 net64 net800 net932 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__mux4_2
Xc132 net776 net772 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__nor2_8
Xc154 net790 net796 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__or2_4
XANTENNA_c347_C_N net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc165 net790 net90 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__or2_4
XANTENNA_input57_A in6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc176 net640 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_2
Xc187 net794 net116 net968 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__and3b_1
Xc198 net769 net116 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__and2b_1
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input12_X net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c205_A2 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c169_B net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_2_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c343_C net692 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_442 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c199_A_N net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c738_S0 net693 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c457_S1 net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c486_X net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input4_X net769 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c412_B1 net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c131_A1 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c603_C1 net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge802_Q net675 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap2 net332 VGND VGND VPWR VPWR net1014 sky130_fd_sc_hd__buf_1
XFILLER_0_45_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold65_A net371 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s830_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c181_A net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c286_B net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c215_SET_B net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c499_A3 net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc92 net807 net940 VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__nand2b_2
Xc70 net814 net6 net5 VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__nand3b_4
Xc81 net15 net825 net9 VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__nor3_2
XFILLER_0_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire130 net548 VGND VGND VPWR VPWR net895 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output88_A net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net685 clknet_0_net685 VGND VGND VPWR VPWR clknet_1_1__leaf_net685
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_56_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc709 net525 net785 net559 net326 net887 clknet_1_0__leaf_net459 VGND VGND VPWR VPWR
+ net573 sky130_fd_sc_hd__mux4_4
XANTENNA_c201_B net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c289_Y net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c191_Y net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c735_S1 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c415_CLK_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c673_SCE net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge782_S1 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_10_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold60 net712 VGND VGND VPWR VPWR net1007 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_89_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c600_A0 net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_100_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_81_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_2 net195 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer25 net971 VGND VGND VPWR VPWR net972 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer14 net960 VGND VGND VPWR VPWR net961 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer36 net982 VGND VGND VPWR VPWR net983 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer47 net921 VGND VGND VPWR VPWR net994 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c144_A net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout157_A net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c311_A clknet_1_0__leaf_net685 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c409_A net302 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc528 net778 net314 VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__nand2b_2
Xc539 net1017 net307 net413 VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__nand3_1
XANTENNA_c399_X net298 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c592_Q net472 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput94 net859 VGND VGND VPWR VPWR out37 sky130_fd_sc_hd__clkbuf_1
Xoutput83 net848 VGND VGND VPWR VPWR out27 sky130_fd_sc_hd__buf_2
Xoutput72 net837 VGND VGND VPWR VPWR out17 sky130_fd_sc_hd__buf_2
XANTENNA_input42_X net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net549 clknet_0_net549 VGND VGND VPWR VPWR clknet_1_0__leaf_net549
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c208_A2 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c505_A0 net336 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c285_S1 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c199_B net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c240_A0 net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c533_B net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c147_X net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c700_B net529 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c419_Y net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc303 net661 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_60_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc314 net678 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__buf_1
Xc325 net232 clknet_1_0__leaf_net243 net242 net808 net112 net237 VGND VGND VPWR VPWR
+ net244 sky130_fd_sc_hd__mux4_2
Xc336 net758 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__inv_2
Xc369 net130 net17 net944 net157 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__or4bb_1
Xc358 net925 net941 net127 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__nor3b_2
Xc347 net950 net21 net894 net255 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__or4bb_1
XANTENNA_c476_S0 net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c712_D1 net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge802 net135 clknet_4_1_0_clk net138 VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__dlrtn_2
XFILLER_0_95_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge813 clknet_4_1_0_clk net680 net657 VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__sdlclkp_4
XFILLER_0_67_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer5 net951 VGND VGND VPWR VPWR net952 sky130_fd_sc_hd__dlymetal6s2s_1
XANTENNA_c606_C1 net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_39_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c121_C net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout147 net300 VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__clkbuf_2
Xfanout169 net34 VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__buf_4
Xfanout158 net136 VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c264_X net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c529_X net406 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c67_B net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc111 net815 net46 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__nand2_1
Xc100 net16 net31 VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__nor2_1
Xc122 net38 net867 VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__or2_1
Xc133 net769 net826 net811 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__and3_4
Xc144 net75 net766 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__nand2_8
Xc177 net73 net799 net938 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__nand3_2
Xc166 net872 net801 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__and2b_2
Xc155 net81 net790 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__nor2b_4
Xc188 net924 net112 net116 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__and3b_1
Xc199 net767 net20 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__nand2b_1
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c352_D1 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c502_A1 net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c231_B net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c224_A net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c463_D_N net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c698_B net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c754_S0 net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c473_S1 net681 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c412_A1 net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold58_A net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c574_S0 net452 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c181_B net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c684_D_N net677 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c227_X net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c484_S0 net371 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc93 net820 net786 VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__or2_1
Xc71 net796 net7 VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__or2b_2
Xc82 net780 net14 net16 VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__nand3_4
XFILLER_0_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c297_B_N net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire120 net886 VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_80_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c410_C_N net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s853_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net686 clknet_0_net686 VGND VGND VPWR VPWR clknet_1_1__leaf_net686
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net697 clknet_0_net697 VGND VGND VPWR VPWR clknet_1_1__leaf_net697
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c201_C net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c563_B net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c751_S1 net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net843 net843 VGND VGND VPWR VPWR clknet_0_net843 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s835_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input32_A in37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold50 net660 VGND VGND VPWR VPWR net997 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 net655 VGND VGND VPWR VPWR net1008 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_11_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_100_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_3 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer15 net961 VGND VGND VPWR VPWR net962 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c571_S1 net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer26 net972 VGND VGND VPWR VPWR net973 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_65_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer48 net994 VGND VGND VPWR VPWR net995 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer37 net983 VGND VGND VPWR VPWR net984 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c144_B net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c137_A net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc529 net315 net965 net993 VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__or3b_2
XFILLER_0_40_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s817_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c689_C_N net696 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c701_A0 net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c461_X net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput73 net956 VGND VGND VPWR VPWR out18 sky130_fd_sc_hd__clkbuf_4
Xoutput84 net849 VGND VGND VPWR VPWR out28 sky130_fd_sc_hd__clkbuf_4
Xoutput95 net860 VGND VGND VPWR VPWR out38 sky130_fd_sc_hd__clkbuf_4
XANTENNA_input35_X net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c611_A0 net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c208_A3 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_0__f_net459_X clknet_1_0__leaf_net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c505_A1 net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c261_B net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc304 net217 net221 net220 net187 net925 net207 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__mux4_1
XFILLER_0_32_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc315 net101 net882 net821 net108 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__or4bb_1
Xc326 net117 net97 net806 net242 net100 net239 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__mux4_2
Xc359 net91 net185 net28 net916 net915 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__o2111a_1
Xc348 net219 net259 net868 net791 clknet_1_0__leaf_net687 VGND VGND VPWR VPWR net267
+ sky130_fd_sc_hd__a2111oi_1
Xc337 net211 net142 clknet_1_1__leaf_net243 VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__and3_4
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_99_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge803 net364 clknet_4_3_0_clk net373 VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__dlrtn_1
XFILLER_0_95_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge814 clknet_4_0_0_clk merge814/D net679 VGND VGND VPWR VPWR net852 net105 sky130_fd_sc_hd__dfrbp_2
XFILLER_0_82_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer6 net196 VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c606_B1 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c341_A0 net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_19_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_530 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s876_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout148 net914 VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__buf_8
XANTENNA_fanout172_X net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc101 net32 net934 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__and2b_1
XANTENNA_c487_S0 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc123 net15 net46 net54 VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__and3_1
Xc112 net37 net31 net46 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__and3b_1
XANTENNA_c482_SCD net372 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc134 net772 net811 VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__and2_2
Xc145 net71 net937 net780 net928 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__or4bb_4
Xc167 net89 net95 net927 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__and3_4
Xc156 net71 net67 net774 net775 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__or4bb_2
Xc178 net782 net3 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__nand2_4
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc189 net809 net118 net116 net772 net933 net968 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__mux4_2
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c352_C1 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc690 net522 net551 net533 net785 VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__or4bb_1
XPHY_EDGE_ROW_3_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c584_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_499 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c412_A2 net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_67_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c72_A net821 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input62_A in9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_76_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c603_A1 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net857 clknet_0_net857 VGND VGND VPWR VPWR clknet_1_1__leaf_net857
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c574_S1 net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c181_C net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c167_A net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c309_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout135_X net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c749_S1 net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c704_A0 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c484_S1 net675 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c183_C_N net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc94 net826 net20 net15 VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__and3b_1
Xc83 net19 net818 net868 VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__or3_4
Xc72 net821 net818 net6 VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__nor3b_2
XFILLER_0_85_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c82_Y net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xwire132 net898 VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire143 net909 VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_80_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net687 clknet_0_net687 VGND VGND VPWR VPWR clknet_1_1__leaf_net687
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net698 clknet_0_net698 VGND VGND VPWR VPWR clknet_1_1__leaf_net698
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c444_SET_B net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_60_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c459_SET_B net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c354_D_N net28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c563_C net681 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c495_S0 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c593_D_N net472 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c345_D_N net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c156_C_N net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold62 net146 VGND VGND VPWR VPWR net1009 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input25_A in30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold51 net721 VGND VGND VPWR VPWR net998 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c600_A2 net452 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c609_A0 net442 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_4 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c344_B1 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_1_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer16 net962 VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer27 net996 VGND VGND VPWR VPWR net974 sky130_fd_sc_hd__dlygate4sd1_1
Xclkbuf_1_1__f_net473 clknet_0_net473 VGND VGND VPWR VPWR clknet_1_1__leaf_net473
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer49 net994 VGND VGND VPWR VPWR net996 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_merge801_GATE_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_37_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer38 net982 VGND VGND VPWR VPWR net985 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c254_A0 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c575_D_N net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c429_A0 net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net685 net685 VGND VGND VPWR VPWR clknet_0_net685 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput74 net839 VGND VGND VPWR VPWR out19 sky130_fd_sc_hd__clkbuf_4
Xoutput63 net828 VGND VGND VPWR VPWR out0 sky130_fd_sc_hd__clkbuf_4
Xoutput85 clknet_1_0__leaf_net850 VGND VGND VPWR VPWR out29 sky130_fd_sc_hd__clkbuf_1
Xoutput96 net861 VGND VGND VPWR VPWR out39 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input28_X net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c505_A2 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
.ends
