* NGSPICE file created from netlist_1.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_4 abstract view
.subckt sky130_fd_sc_hd__nor3b_4 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_4 abstract view
.subckt sky130_fd_sc_hd__a2111o_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_4 abstract view
.subckt sky130_fd_sc_hd__and2b_4 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbp_1 abstract view
.subckt sky130_fd_sc_hd__dlxbp_1 D GATE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__lpflow_inputisolatch_1 abstract view
.subckt sky130_fd_sc_hd__lpflow_inputisolatch_1 D SLEEP_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_1 abstract view
.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_4 abstract view
.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_0 abstract view
.subckt sky130_fd_sc_hd__and2_0 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_4 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_4 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_4 abstract view
.subckt sky130_fd_sc_hd__mux4_4 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_4 abstract view
.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_1 abstract view
.subckt sky130_fd_sc_hd__dlclkp_1 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_1 abstract view
.subckt sky130_fd_sc_hd__dfxbp_1 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_1 abstract view
.subckt sky130_fd_sc_hd__dlxtn_1 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_4 abstract view
.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_4 abstract view
.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_2 abstract view
.subckt sky130_fd_sc_hd__dfxbp_2 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_2 abstract view
.subckt sky130_fd_sc_hd__dlclkp_2 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_1 abstract view
.subckt sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_4 abstract view
.subckt sky130_fd_sc_hd__dlclkp_4 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_4 abstract view
.subckt sky130_fd_sc_hd__and3b_4 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_2 abstract view
.subckt sky130_fd_sc_hd__dlxbn_2 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtp_1 abstract view
.subckt sky130_fd_sc_hd__dlxtp_1 D GATE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_1 abstract view
.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_1 abstract view
.subckt sky130_fd_sc_hd__dlxbn_1 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_2 abstract view
.subckt sky130_fd_sc_hd__a2111o_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_2 abstract view
.subckt sky130_fd_sc_hd__or4bb_2 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_2 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_2 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_4 abstract view
.subckt sky130_fd_sc_hd__dlxtn_4 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_2 abstract view
.subckt sky130_fd_sc_hd__a2111oi_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_0 abstract view
.subckt sky130_fd_sc_hd__a2111oi_0 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_2 abstract view
.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_2 abstract view
.subckt sky130_fd_sc_hd__dfrbp_2 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrbp_2 abstract view
.subckt sky130_fd_sc_hd__sdfrbp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_2 abstract view
.subckt sky130_fd_sc_hd__o2111ai_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_4 abstract view
.subckt sky130_fd_sc_hd__o2111a_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfstp_2 abstract view
.subckt sky130_fd_sc_hd__sdfstp_2 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_1 abstract view
.subckt sky130_fd_sc_hd__dlrtn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_8 abstract view
.subckt sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfstp_1 abstract view
.subckt sky130_fd_sc_hd__sdfstp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtn_1 abstract view
.subckt sky130_fd_sc_hd__dfrtn_1 CLK_N D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_2 abstract view
.subckt sky130_fd_sc_hd__dlrtn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfsbp_2 abstract view
.subckt sky130_fd_sc_hd__sdfsbp_2 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_1 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_1 abstract view
.subckt sky130_fd_sc_hd__dlrtp_1 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_2 abstract view
.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_16 abstract view
.subckt sky130_fd_sc_hd__buf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbp_1 CLK D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q
+ Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_4 abstract view
.subckt sky130_fd_sc_hd__dlrtp_4 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxbp_1 abstract view
.subckt sky130_fd_sc_hd__sedfxbp_1 CLK D DE SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_2 abstract view
.subckt sky130_fd_sc_hd__o2111a_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtn_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtn_1 CLK_N D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_1 abstract view
.subckt sky130_fd_sc_hd__dfsbp_1 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxbp_1 abstract view
.subckt sky130_fd_sc_hd__edfxbp_1 CLK D DE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_4 abstract view
.subckt sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxtp_1 abstract view
.subckt sky130_fd_sc_hd__edfxtp_1 CLK D DE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_1 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_1 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_2 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_2 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_4 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_4 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_2 abstract view
.subckt sky130_fd_sc_hd__dfstp_2 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_2 abstract view
.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbp_1 abstract view
.subckt sky130_fd_sc_hd__dlrbp_1 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_4 abstract view
.subckt sky130_fd_sc_hd__a2111oi_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_2 abstract view
.subckt sky130_fd_sc_hd__dlrbn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_1 abstract view
.subckt sky130_fd_sc_hd__dlrbn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_2 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_2 abstract view
.subckt sky130_fd_sc_hd__dfsbp_2 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_4 abstract view
.subckt sky130_fd_sc_hd__dfstp_4 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_2 abstract view
.subckt sky130_fd_sc_hd__dlrtp_2 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_4 abstract view
.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_4 abstract view
.subckt sky130_fd_sc_hd__dlrtn_4 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_1 abstract view
.subckt sky130_fd_sc_hd__clkinv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxtp_4 abstract view
.subckt sky130_fd_sc_hd__sedfxtp_4 CLK D DE SCD SCE VGND VNB VPB VPWR Q
.ends

.subckt netlist_1 VGND VPWR clk in0 in1 in10 in11 in12 in13 in14 in15 in16 in17 in18
+ in19 in2 in20 in21 in22 in23 in24 in25 in26 in27 in28 in29 in3 in30 in31 in32 in33
+ in34 in35 in36 in37 in38 in39 in4 in40 in41 in42 in43 in44 in45 in46 in47 in48 in49
+ in5 in50 in51 in52 in53 in54 in55 in56 in57 in58 in59 in6 in60 in61 in7 in8 in9
+ out0 out1 out10 out11 out12 out13 out14 out15 out16 out17 out18 out19 out2 out20
+ out21 out22 out23 out24 out25 out26 out27 out28 out29 out3 out30 out31 out32 out33
+ out34 out35 out36 out37 out38 out39 out4 out40 out41 out42 out43 out44 out45 out46
+ out47 out48 out49 out5 out50 out51 out52 out53 out54 out55 out56 out57 out58 out59
+ out6 out60 out61 out7 out8 out9 rst
XFILLER_0_94_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c359_C net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c261_C clknet_1_0__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net292 clknet_0_net292 VGND VGND VPWR VPWR clknet_1_1__leaf_net292
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_64_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge817_A2 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc305 net224 net223 net222 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__or3b_2
Xc316 net234 net969 net743 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__nor3b_4
Xc327 net243 net238 clknet_1_0__leaf_net899 net964 net210 VGND VGND VPWR VPWR net253
+ sky130_fd_sc_hd__a2111o_4
XFILLER_0_60_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc349 net268 net106 net120 net270 clknet_1_0__leaf_net777 net791 VGND VGND VPWR VPWR
+ net275 sky130_fd_sc_hd__mux4_2
Xc338 net960 net261 net256 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__or3_2
XFILLER_0_99_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c531_C_N net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge826 net567 net578 VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__and2b_4
Xmerge837 net650 net629 VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__nor2b_2
XFILLER_0_67_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge804 net91 clknet_1_0__leaf_net145 clknet_1_0__leaf_net146 net114 clknet_1_0__leaf_net135
+ net19 VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__mux4_2
Xmerge815 net231 net942 net216 net342 net349 net1020 VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__mux4_1
XFILLER_0_95_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs943 net593 clknet_4_5_0_clk VGND VGND VPWR VPWR net820 net819 sky130_fd_sc_hd__dlxbp_1
Xmerge859 net633 net646 VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__or2b_1
Xs932 net506 clknet_4_6_0_clk VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xmerge848 net253 net295 VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__and2b_2
Xs921 clknet_4_11_0_clk net310 VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__dfxtp_4
XFILLER_0_55_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net460 net460 VGND VGND VPWR VPWR clknet_0_net460 sky130_fd_sc_hd__clkbuf_16
Xrebuffer7 net1002 VGND VGND VPWR VPWR net1000 sky130_fd_sc_hd__buf_8
XFILLER_0_23_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c593_S0 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout138 net15 VGND VGND VPWR VPWR net961 sky130_fd_sc_hd__clkbuf_4
Xfanout127 net210 VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__buf_4
Xfanout149 net6 VGND VGND VPWR VPWR net972 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c251_A1 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c152_X net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c531_A net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c417_X net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc102 net923 net32 VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__nor2b_2
Xc124 net51 net908 net53 net891 net45 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__o2111ai_1
Xc113 net861 net44 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__nand2_2
Xc135 net884 net64 VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__or2_1
Xc157 net843 net85 net80 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__nor3b_1
Xc168 net86 net65 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__and2_1
Xc146 net75 net73 net830 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__nand3b_4
Xc179 net852 net96 net847 net878 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__or4bb_4
XFILLER_0_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c617_A0 net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net290 net290 VGND VGND VPWR VPWR clknet_0_net290 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc680 net705 VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__inv_1
Xc691 net720 VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c501_9_A clknet_1_0__leaf_net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net156 clknet_0_net156 VGND VGND VPWR VPWR clknet_1_0__leaf_net156
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net145 clknet_0_net145 VGND VGND VPWR VPWR clknet_1_0__leaf_net145
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c344_RESET_B net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c588_S0 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout125_A net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_40_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_0_net776_A net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c262_A0 net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c498_S0 clknet_1_0__leaf_net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c201_19_A clknet_1_0__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c71_C1 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input55_A in58 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net814 clknet_0_net814 VGND VGND VPWR VPWR clknet_1_1__leaf_net814
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input10_X net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge885_Q net753 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c167_B net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge809_A3 net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c115_X net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout128_X net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c696_A net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c765_S1 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c142_A3 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc73 net837 net873 VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__and2_0
Xc62 net828 net866 net839 net845 net867 net856 VGND VGND VPWR VPWR net0 sky130_fd_sc_hd__mux4_1
Xc84 net12 net861 VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__or2b_1
Xc95 net24 net26 VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_26_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c614_A1 net339 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c630_A0 net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c277_A net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c556_C net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge888_D net499 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net812 net812 VGND VGND VPWR VPWR clknet_0_net812 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c290_D_N net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_C1 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold30 net699 VGND VGND VPWR VPWR net1023 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input18_A in24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c328_A2 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c625_A0 net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c686_S0 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output86_A net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer17 clknet_0_net940 VGND VGND VPWR VPWR net1032 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_83_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net452 clknet_0_net452 VGND VGND VPWR VPWR clknet_1_1__leaf_net452
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_65_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c369_D1 net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net933_X clknet_1_0__leaf_net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c726_C1 net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput64 net887 VGND VGND VPWR VPWR out1 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput75 net898 VGND VGND VPWR VPWR out20 sky130_fd_sc_hd__buf_2
Xoutput86 net958 VGND VGND VPWR VPWR out32 sky130_fd_sc_hd__buf_2
Xoutput97 clknet_1_1__leaf_net920 VGND VGND VPWR VPWR out43 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c611_A2 net396 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c567_SCD net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_8_0_clk_X clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc306 clknet_4_0_0_clk net225 net229 net231 net216 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__sdfrtp_4
Xc317 net82 net945 net743 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__and3_2
Xc339 net133 net264 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__nor2_1
Xc328 net945 net252 clknet_1_0__leaf_net899 net733 net763 VGND VGND VPWR VPWR net254
+ sky130_fd_sc_hd__a2111o_1
XFILLER_0_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c712_A1 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge827 clknet_4_0_0_clk merge827/D net103 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dfrtp_1
Xmerge816 net114 net91 net873 net239 net241 net243 VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__mux4_4
Xmerge805 net872 net119 net8 net223 net95 net216 VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__mux4_2
XANTENNA_c484_D_N net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge849 net426 net318 VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__or2b_4
Xmerge838 net408 net418 VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__nor2_2
Xs922 clknet_4_1_0_clk net352 VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__dlclkp_1
Xs933 clknet_4_15_0_clk net525 VGND VGND VPWR VPWR net806 net805 sky130_fd_sc_hd__dfxbp_1
Xs944 net594 clknet_4_7_0_clk VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__dlxtn_1
XTAP_TAPCELL_ROW_11_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net472 net472 VGND VGND VPWR VPWR clknet_0_net472 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c606_A2 net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer8 net1000 VGND VGND VPWR VPWR net1001 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge892_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c191_C1 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c622_A1 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c593_S1 net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout128 net918 VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__buf_4
Xfanout139 net546 VGND VGND VPWR VPWR net962 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_38_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c531_B net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c466_D_N net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net894 clknet_0_net894 VGND VGND VPWR VPWR clknet_1_0__leaf_net894
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c557_D1 clknet_1_1__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c768_S1 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c312_X net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc114 net32 net34 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__and2b_1
Xc125 net53 net862 net46 net891 net844 net55 VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__mux4_2
Xc103 net14 net29 net957 net828 net31 VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__o2111ai_4
Xc136 net64 net65 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__nand2b_4
XANTENNA_c681_X net562 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc158 net832 net859 net851 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__nor3b_2
Xc169 net89 net79 net97 net973 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__or4bb_1
Xc147 net77 net824 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__and2_4
XFILLER_0_68_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_A1 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net291 net291 VGND VGND VPWR VPWR clknet_0_net291 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c440_C_N clknet_1_0__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc670 net548 clknet_1_1__leaf_net447 net558 VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__nor3b_1
Xc681 net446 net965 VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__and2b_1
Xc692 net572 net441 net968 net542 VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__or4bb_1
XFILLER_0_75_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net135 clknet_0_net135 VGND VGND VPWR VPWR clknet_1_0__leaf_net135
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net146 clknet_0_net146 VGND VGND VPWR VPWR clknet_1_0__leaf_net146
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net179 clknet_0_net179 VGND VGND VPWR VPWR clknet_1_0__leaf_net179
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c588_S1 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout118_A net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c262_A1 net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c718_A0 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c734_C1 net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_94_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input48_A in51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c689_S0 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c628_A0 net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge878_Q net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c222_A net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c704_A2 net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc85 net863 net3 VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__or2_4
Xc74 net4 net8 VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__or2b_1
Xc63 net0 net862 net839 net856 net866 net867 VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__mux4_2
XFILLER_0_97_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc96 net27 net877 VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_26_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c614_A2 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c630_A1 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_88_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c277_B net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_68_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_9_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net813 net813 VGND VGND VPWR VPWR clknet_0_net813 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold31 net130 VGND VGND VPWR VPWR net1024 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_merge895_Q_N net762 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold20 net780 VGND VGND VPWR VPWR net1013 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c594_SCE net762 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c625_A1 net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c686_S1 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output79_A net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net442 clknet_0_net442 VGND VGND VPWR VPWR clknet_1_1__leaf_net442
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c666_B_N net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c369_C1 clknet_1_0__leaf_net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c701_A3 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_4_0_clk_X clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c726_B1 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net643 net643 VGND VGND VPWR VPWR clknet_0_net643 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c63_A1 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput76 clknet_1_1__leaf_net899 VGND VGND VPWR VPWR out21 sky130_fd_sc_hd__clkbuf_1
Xoutput65 net888 VGND VGND VPWR VPWR out10 sky130_fd_sc_hd__buf_2
Xoutput98 clknet_1_0__leaf_net921 VGND VGND VPWR VPWR out44 sky130_fd_sc_hd__clkbuf_1
Xoutput87 clknet_1_1__leaf_net910 VGND VGND VPWR VPWR out34 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input30_A in35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c567_SCE net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output117_A clknet_1_1__leaf_net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_42_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c636_A0 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_hold19_A net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge802_S0 net851 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c249_A2 clknet_1_0__leaf_net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_99_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c407_B net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc307 net101 net229 net231 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__nor3b_1
Xc318 net743 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__inv_6
XFILLER_0_60_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc329 net230 net249 clknet_1_0__leaf_net254 net116 net862 net242 VGND VGND VPWR VPWR
+ net255 sky130_fd_sc_hd__mux4_4
XFILLER_0_40_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge806 net121 net879 net961 clknet_1_0__leaf_net148 net183 net919 VGND VGND VPWR
+ VPWR net667 sky130_fd_sc_hd__mux4_4
Xmerge828 net266 net277 VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__nand2_1
Xmerge817 net428 net431 net941 net432 net434 net326 VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__mux4_1
Xmerge839 net585 net587 VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__nand2_2
Xs934 clknet_4_15_0_clk net526 VGND VGND VPWR VPWR net808 net807 sky130_fd_sc_hd__dfxbp_2
Xs923 clknet_4_12_0_clk net405 VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__dlclkp_2
Xs945 net603 clknet_4_13_0_clk VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__dlxtn_1
Xclkbuf_0_net440 net440 VGND VGND VPWR VPWR clknet_0_net440 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c456_A0 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer9 net1003 VGND VGND VPWR VPWR net1002 sky130_fd_sc_hd__buf_6
XANTENNA_c606_A3 net339 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c237_SCD clknet_1_0__leaf_net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c191_B1 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c622_A2 net519 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net306 clknet_0_net306 VGND VGND VPWR VPWR clknet_1_0__leaf_net306
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_47_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout118 net429 VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__clkbuf_4
Xfanout129 net918 VGND VGND VPWR VPWR net952 sky130_fd_sc_hd__clkbuf_8
XANTENNA_c193_Q_N net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge874_GATE clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c138_X net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc115 net16 net28 VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__and2b_2
Xc104 net36 net18 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__and2b_1
Xc126 net21 net52 net34 net49 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__or4bb_1
Xc159 net73 net848 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__and2_1
Xc137 net834 net827 net825 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__nor3b_4
Xc148 net77 net66 net68 net71 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__or4bb_4
XTAP_TAPCELL_ROW_44_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net292 net292 VGND VGND VPWR VPWR clknet_0_net292 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_12_0_clk_X clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc682 net965 net556 net689 clknet_1_1__leaf_net794 VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__or4bb_4
Xc660 net557 net326 VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__or2_1
Xc671 net545 net548 net962 VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__nand3b_4
Xc693 clknet_1_0__leaf_net563 net226 net573 net962 net216 net766 VGND VGND VPWR VPWR
+ net574 sky130_fd_sc_hd__mux4_4
XFILLER_0_75_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net136 clknet_0_net136 VGND VGND VPWR VPWR clknet_1_0__leaf_net136
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge795_D1 net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net169 clknet_0_net169 VGND VGND VPWR VPWR clknet_1_0__leaf_net169
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c527_A2 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_27_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c125_S0 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c422_X net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_36_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c172_A2 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_45_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c689_S1 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c628_A1 net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc490 net735 VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__inv_6
XPHY_EDGE_ROW_63_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge810_S0 net897 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_72_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c720_A2 net441 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc75 net7 net972 VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__and2b_1
Xc64 net839 net882 net867 net863 net878 net1 VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__mux4_2
Xc86 net22 net7 net23 net842 net13 net846 VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__mux4_1
Xc97 net868 net31 VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_26_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_90_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input60_A in7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c374_B1 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c390_C1 clknet_1_1__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge805_S0 net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net814 net814 VGND VGND VPWR VPWR clknet_0_net814 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_0_0_clk_X clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c715_A2 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c578_D_N net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold32 net367 VGND VGND VPWR VPWR net1025 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 net466 VGND VGND VPWR VPWR net1014 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c502_D_N net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c625_A2 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_1__f_net899_X clknet_1_1__leaf_net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c726_A1 net483 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_8_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput66 net889 VGND VGND VPWR VPWR out11 sky130_fd_sc_hd__buf_2
Xoutput99 net922 VGND VGND VPWR VPWR out45 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput77 net900 VGND VGND VPWR VPWR out22 sky130_fd_sc_hd__buf_2
Xoutput88 net911 VGND VGND VPWR VPWR out35 sky130_fd_sc_hd__buf_2
XANTENNA_input23_A in29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c459_Q net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c636_A1 net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output91_A net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge798_D1 net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge802_S1 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c249_A3 net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c302_B net689 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc308 net735 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__buf_1
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc319 net222 net116 net239 net108 net788 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__a2111oi_1
XFILLER_0_40_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c712_A3 clknet_1_1__leaf_net365 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge906_D net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c452_X net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge818 net433 net431 net427 clknet_1_0__leaf_net442 clknet_1_0__leaf_net447 net943
+ VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__mux4_4
Xmerge807 net236 net269 net386 clknet_1_0__leaf_net292 net966 net261 VGND VGND VPWR
+ VPWR net668 sky130_fd_sc_hd__mux4_4
XANTENNA_c737_A0 net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge829 net298 net304 VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__nand2_2
Xs924 clknet_4_14_0_clk net415 VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__dlclkp_4
Xs946 net625 clknet_4_13_0_clk VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_75_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c456_A1 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs935 clknet_4_15_0_clk net530 VGND VGND VPWR VPWR net809 sky130_fd_sc_hd__dfxtp_1
Xclkbuf_0_net452 net452 VGND VGND VPWR VPWR clknet_0_net452 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_11_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c175_A2 net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c191_A1 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c622_A3 net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c382_B1 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c245_A net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c707_A3 net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc127 net54 net908 net50 VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__and3b_4
Xc116 net870 net972 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__or2_2
Xc105 net959 net29 net37 net18 net35 VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__a2111oi_1
XFILLER_0_20_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc138 net67 net825 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__or2b_4
Xc149 net825 net73 net824 net68 net885 net880 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__mux4_2
XFILLER_0_68_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_A3 net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c633_A2 net897 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc672 clknet_1_1__leaf_net552 net549 net542 net962 net784 VGND VGND VPWR VPWR net553
+ sky130_fd_sc_hd__o2111ai_1
Xc661 net561 net199 VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__and2_4
Xc694 net568 clknet_1_1__leaf_net564 clknet_1_0__leaf_net570 VGND VGND VPWR VPWR net575
+ sky130_fd_sc_hd__or3_2
Xc683 clknet_1_0__leaf_net563 net965 net542 clknet_1_1__leaf_net794 VGND VGND VPWR
+ VPWR net564 sky130_fd_sc_hd__or4bb_1
XFILLER_0_75_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c579_SET_B net473 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c215_S1 net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net148 clknet_0_net148 VGND VGND VPWR VPWR clknet_1_0__leaf_net148
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge795_C1 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c527_A3 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge808_S0 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c262_A3 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c467_B net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c385_SCD clknet_1_0__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c125_S1 net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c718_A2 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c415_X net339 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c71_A2 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c750_A0 net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_100_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc491 net409 net386 net931 VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__nor3b_1
Xc480 net147 net973 net916 net82 VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__or4bb_1
XFILLER_0_29_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c501_7_A clknet_1_0__leaf_net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge810_S1 net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout123_A net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c478_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c584_B net473 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c570_A0 net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc76 net13 net972 VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__or2_1
Xc65 net856 net835 net849 net826 net851 net857 VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__mux4_1
Xc98 net30 net28 net958 VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__and3b_1
Xc87 net24 net5 net14 net18 net875 net873 VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__mux4_1
XFILLER_0_97_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c745_A0 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xwire136 net20 VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__buf_1
XANTENNA_c201_17_A clknet_1_1__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input53_A in56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c374_A1 net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c390_B1 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge805_S1 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_0__f_net899_X clknet_1_0__leaf_net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_A2 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold22 net751 VGND VGND VPWR VPWR net1015 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 net791 VGND VGND VPWR VPWR net1026 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c194_A1 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c404_Q net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c625_A3 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input56_X net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net477 clknet_0_net477 VGND VGND VPWR VPWR clknet_1_1__leaf_net477
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c580_CLK_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c282_B net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c275_A net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_1__f_net794_X clknet_1_1__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c335_Y net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge886_D net703 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c726_A2 clknet_1_1__leaf_net584 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_0_net894_X clknet_0_net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput67 net890 VGND VGND VPWR VPWR out12 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c461_A2 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput78 clknet_1_1__leaf_net901 VGND VGND VPWR VPWR out24 sky130_fd_sc_hd__clkbuf_1
Xoutput89 net978 VGND VGND VPWR VPWR out36 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_98_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input16_A in22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output84_A net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge798_C1 net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc309 net108 net836 net204 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__nor3b_4
XFILLER_0_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c671_C net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c128_S1 net49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input8_A in15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge819 net431 net435 net339 net322 clknet_1_0__leaf_net438 net965 VGND VGND VPWR
+ VPWR net680 sky130_fd_sc_hd__mux4_1
Xmerge808 net421 clknet_1_0__leaf_net254 net30 net411 net122 net741 VGND VGND VPWR
+ VPWR net669 sky130_fd_sc_hd__mux4_1
XFILLER_0_48_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs925 net424 clknet_4_14_0_clk VGND VGND VPWR VPWR net935 net796 sky130_fd_sc_hd__dlxbn_2
Xs947 net645 clknet_4_15_0_clk VGND VGND VPWR VPWR net895 sky130_fd_sc_hd__dlxtp_1
Xs936 clknet_4_15_0_clk net531 VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__dfxtp_4
XTAP_TAPCELL_ROW_11_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c472_CLK_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net442 net442 VGND VGND VPWR VPWR clknet_0_net442 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c175_A3 net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c753_A0 net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input19_X net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c382_A1 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_85_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c682_C_N net689 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c245_B net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c140_A net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc106 net39 net959 net40 net35 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__or4bb_1
Xc117 net44 net26 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_96_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc128 net48 net54 net55 net925 net58 net49 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__mux4_1
Xc139 net880 net66 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__nor2b_1
XANTENNA_c562_X net461 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c748_A0 net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c633_A3 net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc673 net965 net784 VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__or2_1
Xc662 net199 net542 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__or2_2
Xc695 net226 clknet_1_0__leaf_net575 clknet_1_1__leaf_net570 net549 net965 net968
+ VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__mux4_1
Xc684 net319 clknet_1_1__leaf_net363 net451 net542 VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__or4bb_4
XFILLER_0_75_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge899_GATE_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c393_A0 net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge808_S1 net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c193_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c734_A2 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c628_A3 net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c197_A1 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc470 net390 clknet_1_1__leaf_net389 net392 net383 net122 net911 VGND VGND VPWR VPWR
+ net394 sky130_fd_sc_hd__mux4_2
Xc481 net930 net232 net402 clknet_1_0__leaf_net394 net699 net780 VGND VGND VPWR VPWR
+ net405 sky130_fd_sc_hd__mux4_2
Xc492 net727 VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__inv_4
XANTENNA_c388_A0 net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c591_D net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c198_Y net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc66 net0 net879 VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__or2_1
XFILLER_0_97_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc99 net33 net958 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__nor2_2
Xc77 net6 net14 VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__or2_1
Xc88 net25 net24 VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__nand2b_1
XFILLER_0_97_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c745_A1 net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input46_A in5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c358_A3 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c374_A2 net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c390_A1 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_1_0__f_net794_X clknet_1_0__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c158_B net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c700_S0 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c687_A net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold23 net922 VGND VGND VPWR VPWR net1016 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c756_A0 net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c194_A2 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net423 clknet_0_net423 VGND VGND VPWR VPWR clknet_1_1__leaf_net423
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net445 clknet_0_net445 VGND VGND VPWR VPWR clknet_1_1__leaf_net445
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net478 clknet_0_net478 VGND VGND VPWR VPWR clknet_1_1__leaf_net478
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge816_S1 net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_9_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c282_C net192 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_69_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c576_A0 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s928_Q net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput68 net891 VGND VGND VPWR VPWR out13 sky130_fd_sc_hd__buf_2
Xoutput79 net902 VGND VGND VPWR VPWR out25 sky130_fd_sc_hd__buf_2
XFILLER_0_98_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c189_A2 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_42_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c636_A3 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output77_A net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge798_B1 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net286 clknet_0_net286 VGND VGND VPWR VPWR clknet_1_1__leaf_net286
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c479_SCD net869 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c562_A2 net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c403_SCD net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c173_X net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c425_S0 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge809 net218 net116 net238 net23 clknet_1_0__leaf_net160 net162 VGND VGND VPWR
+ VPWR net670 sky130_fd_sc_hd__mux4_2
XANTENNA_c587_C1 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c737_A2 net571 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs937 clknet_4_15_0_clk net532 VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xs926 net468 clknet_4_3_0_clk VGND VGND VPWR VPWR net798 net797 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_90_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c753_A1 net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output115_A net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c74_B_N net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_hold17_A net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xnet899_2 net746 VGND VGND VPWR VPWR net976 sky130_fd_sc_hd__inv_1
XFILLER_0_54_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c140_B net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout146_A net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c238_B net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc107 net28 net37 net932 net38 net32 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__a2111o_4
Xc118 net47 net49 VGND VGND VPWR VPWR net891 sky130_fd_sc_hd__and2_2
XFILLER_0_41_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc129 net53 net925 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__and2b_1
XANTENNA_c290_X net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c748_A1 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c764_A0 net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc630 net402 net907 net988 net806 net809 net810 VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__mux4_1
Xc663 net847 net965 VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__or2b_1
XANTENNA_c581_Q net483 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc685 net547 net826 net773 VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__nor3_1
Xc696 net216 net547 net770 clknet_1_0__leaf_net813 VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__or4bb_4
Xc674 net554 net550 net547 net784 VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__or4bb_1
XANTENNA_c361_C_N net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c163_B_N net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c750_A2 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_14_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c197_A2 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc471 clknet_1_1__leaf_net143 net129 net393 net930 net992 VGND VGND VPWR VPWR net395
+ sky130_fd_sc_hd__a2111o_2
Xc460 net370 net334 net381 clknet_1_0__leaf_net373 clknet_1_0__leaf_net366 net1025
+ VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__mux4_2
Xc482 net404 net991 net780 clknet_1_0__leaf_net795 VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__or4bb_4
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc493 net412 net986 net897 VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__nor3b_2
XFILLER_0_35_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c388_A1 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_32_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge819_S1 net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c608_DE net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_41_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c206_D1 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c570_A2 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc67 net841 net863 VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__nor2b_1
XPHY_EDGE_ROW_50_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc89 net846 net871 VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__or2_1
Xc78 net10 net972 VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__and2b_1
XANTENNA_c260_Y net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c152_S1 net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c595_C1 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input39_A in43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net638 clknet_0_net638 VGND VGND VPWR VPWR clknet_1_1__leaf_net638
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge913_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge792_A2 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_97_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc290 net212 net840 net79 net1030 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__or4bb_4
XANTENNA_c390_A2 clknet_1_1__leaf_net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_5_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c220_B net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_31_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s922_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c687_B net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c428_S0 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold24 net512 VGND VGND VPWR VPWR net1017 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c194_A3 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_523 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c275_C net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c268_B net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net894_A clknet_0_net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c576_A1 net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c330_A net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c742_A3 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput69 net892 VGND VGND VPWR VPWR out15 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_98_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c621_S0 net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge901_Q net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_6_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net254 clknet_0_net254 VGND VGND VPWR VPWR clknet_1_1__leaf_net254
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net276 clknet_0_net276 VGND VGND VPWR VPWR clknet_1_1__leaf_net276
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c479_SCE net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c706_S0 net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c425_S1 net689 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c587_B1 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs938 clknet_4_5_0_clk net574 VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__dlclkp_1
Xs927 net471 clknet_4_4_0_clk VGND VGND VPWR VPWR net800 net799 sky130_fd_sc_hd__dlxbp_1
XFILLER_0_90_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net477 net477 VGND VGND VPWR VPWR clknet_0_net477 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c124_D1 net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input21_A in27 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_13_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c497_A0 net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output108_A net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_97_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c526_S0 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xnet899_3 net746 VGND VGND VPWR VPWR net977 sky130_fd_sc_hd__inv_1
XFILLER_0_38_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net899 clknet_0_net899 VGND VGND VPWR VPWR clknet_1_0__leaf_net899
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_72_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout139_A net546 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc108 net41 net37 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__nand2_2
XFILLER_0_5_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc119 net50 net44 net48 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__nor3b_1
XFILLER_0_41_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c662_A net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge904_D net461 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c555_Y net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c748_A2 clknet_1_1__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc620 net163 clknet_1_1__leaf_net899 net128 net913 net887 clknet_1_0__leaf_net904
+ VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__mux4_4
Xc631 net515 net534 clknet_1_1__leaf_net414 net805 net807 net809 VGND VGND VPWR VPWR
+ net893 sky130_fd_sc_hd__mux4_4
Xc664 clknet_1_1__leaf_net439 net194 VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__or2b_1
Xc686 net566 net562 clknet_1_1__leaf_net564 net840 net226 net952 VGND VGND VPWR VPWR
+ net567 sky130_fd_sc_hd__mux4_4
Xc697 net571 clknet_1_0__leaf_net575 net968 net779 VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__or4bb_2
Xc675 net705 VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c346_S0 clknet_1_0__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input24_X net847 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge899_Q net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s925_Q_N net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c211_C1 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c250_B net49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c355_C net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c568_A2 net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c703_S1 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c750_A3 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c105_B1 net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c665_X net546 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c197_A3 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc450 net232 net75 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__nor2b_1
Xc461 net381 net236 net886 net1020 net771 net1016 VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__mux4_1
Xc472 clknet_4_12_0_clk net269 net388 net259 net930 clknet_1_1__leaf_net939 VGND VGND
+ VPWR VPWR net916 net396 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc494 clknet_1_1__leaf_net161 net411 net409 net383 clknet_1_1__leaf_net795 net796
+ VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__mux4_1
Xc483 clknet_1_1__leaf_net406 net403 net404 clknet_1_0__leaf_net399 net973 net392
+ VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__mux4_4
XFILLER_0_35_22 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_1_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc79 net16 net11 VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__and2b_1
Xc68 net861 net873 VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__or2_1
XFILLER_0_97_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net460 clknet_0_net460 VGND VGND VPWR VPWR clknet_1_0__leaf_net460
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c420_Y net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s932_SLEEP_B clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c624_S0 net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc280 net196 net198 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__nand2_1
Xc291 net67 net208 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__nor2b_1
XANTENNA_clkbuf_1_0__f_net894_A clknet_0_net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c501_5_A clknet_1_1__leaf_net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c491_C_N net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge790 net341 net320 net322 net77 net1011 VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__a2111o_1
XTAP_TAPCELL_ROW_31_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c428_S1 net689 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold25 net906 VGND VGND VPWR VPWR net1018 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c62_S0 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge840_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c530_X net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c756_A2 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net290 clknet_0_net290 VGND VGND VPWR VPWR clknet_1_0__leaf_net290
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c459_RESET_B net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c201_15_A clknet_1_1__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c619_S0 net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input51_A in54 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net447 clknet_0_net447 VGND VGND VPWR VPWR clknet_1_1__leaf_net447
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net414 clknet_0_net414 VGND VGND VPWR VPWR clknet_1_1__leaf_net414
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net425 clknet_0_net425 VGND VGND VPWR VPWR clknet_1_1__leaf_net425
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c473_C_N clknet_1_0__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c330_B net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge889_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c592_A1 net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c111_X net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout124_X net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c174_S0 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c767_A1 net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c235_Q net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c621_S1 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c64_X net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input54_X net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap134_A net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge798_A2 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c320_D1 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c446_C_N net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c378_B clknet_1_0__leaf_net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c552_C net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c333_Y net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs939 clknet_4_5_0_clk net576 VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__dlclkp_2
Xs917 clknet_4_2_0_clk net125 VGND VGND VPWR VPWR net788 net787 sky130_fd_sc_hd__dfxbp_1
Xclkbuf_0_net423 net423 VGND VGND VPWR VPWR clknet_0_net423 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c326_X net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs928 net490 clknet_4_6_0_clk VGND VGND VPWR VPWR net906 sky130_fd_sc_hd__dlxtn_4
XFILLER_0_90_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net445 net445 VGND VGND VPWR VPWR clknet_0_net445 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net478 net478 VGND VGND VPWR VPWR clknet_0_net478 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c753_A3 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c616_S1 net753 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input14_A in20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c600_C_N net339 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c526_S1 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net812 clknet_0_net812 VGND VGND VPWR VPWR clknet_1_0__leaf_net812
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc109 net956 net932 VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__nor2_4
XFILLER_0_53_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_96_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c488_A net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c662_B net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input6_A in13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c748_A3 net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net286 net286 VGND VGND VPWR VPWR clknet_0_net286 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_32_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc610 net346 net968 net513 net906 VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__or4bb_1
XFILLER_0_32_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc621 net252 net519 net958 clknet_1_1__leaf_net366 net402 net951 VGND VGND VPWR VPWR
+ net527 sky130_fd_sc_hd__mux4_2
Xc632 net31 net455 net850 net30 net772 net809 VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__mux4_1
Xc687 net542 net556 net998 VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__and3_2
Xc676 net705 VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__inv_4
Xc698 net451 net947 net962 net770 clknet_1_0__leaf_net813 VGND VGND VPWR VPWR net579
+ sky130_fd_sc_hd__a2111oi_2
Xc665 net560 net869 VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__and2b_2
XANTENNA_input17_X net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge871_GATE_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_hold22_A net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c211_B1 net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c729_CLK_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c236_A net762 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc201_20 clknet_1_0__leaf_net776 VGND VGND VPWR VPWR net994 sky130_fd_sc_hd__inv_2
XANTENNA_c65_S0 net851 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c759_A2 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c91_A net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc440 net237 net251 clknet_1_0__leaf_net794 VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__or3b_2
Xc451 net681 VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__inv_4
Xc462 net263 net347 net1026 VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__nand3b_4
Xc473 net367 net391 clknet_1_0__leaf_net939 net191 VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__or4bb_4
Xc484 net391 net123 clknet_1_1__leaf_net254 net796 VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__or4bb_1
Xc495 net727 VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c388_A3 clknet_1_0__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c416_A_N net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c206_B1 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c186_A net848 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc69 net857 net972 VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__and2_1
XFILLER_0_78_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c141_X net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net472 clknet_0_net472 VGND VGND VPWR VPWR clknet_1_0__leaf_net472
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c413_Y net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer4_A net436 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c761_A3 net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c624_S1 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c94_X net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c72_C_N net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc281 net207 net205 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__or2b_1
Xc270 net836 net194 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__and2b_1
Xc292 net213 net946 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__nand2_1
XFILLER_0_75_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge791 clknet_1_0__leaf_net425 clknet_1_1__leaf_net292 net350 clknet_1_0__leaf_net423
+ clknet_1_1__leaf_net289 net31 VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__mux4_2
XFILLER_0_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge801_B1 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold26 net752 VGND VGND VPWR VPWR net1019 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net291 clknet_0_net291 VGND VGND VPWR VPWR clknet_1_0__leaf_net291
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_38_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c187_D_N net689 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c619_S1 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input44_A in48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c370_S0 clknet_1_0__leaf_net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge874_Q net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c178_D_N net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_90_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_38_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c576_A3 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net638 net638 VGND VGND VPWR VPWR clknet_0_net638 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c592_A2 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c692_B net441 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c169_D_N net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c349_S1 net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input47_X net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net289 clknet_0_net289 VGND VGND VPWR VPWR clknet_1_1__leaf_net289
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_57_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c693_A1 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c378_C net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c273_B net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c440_B net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c587_A2 net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs929 net494 clknet_4_7_0_clk VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__dlxtn_1
Xs918 clknet_4_10_0_clk net171 VGND VGND VPWR VPWR net790 net789 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_90_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge912_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output75_A net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net813 clknet_0_net813 VGND VGND VPWR VPWR clknet_1_0__leaf_net813
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_18_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_130 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c609_SCD net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_96_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c241_D1 net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c171_X net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c550_A net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c764_A3 clknet_1_1__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net254 net254 VGND VGND VPWR VPWR clknet_0_net254 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net276 net276 VGND VGND VPWR VPWR clknet_0_net276 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc611 net512 clknet_1_0__leaf_net406 net396 net481 net774 net798 VGND VGND VPWR VPWR
+ net516 sky130_fd_sc_hd__mux4_2
Xc622 net410 net844 net519 net327 net966 net907 VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__mux4_2
Xc600 net510 net519 net339 net513 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__or4bb_1
Xc633 net522 net502 net897 net887 net802 net810 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__mux4_1
Xc677 net192 net72 VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__or2b_1
Xc688 net194 net204 net568 net947 VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__or4bb_2
Xc666 net557 net962 VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__or2b_1
XANTENNA_c627_S1 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc699 net962 net568 net826 net328 net779 net783 VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output113_A net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c362_S1 clknet_1_0__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_80_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c699_A0 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net643 clknet_0_net643 VGND VGND VPWR VPWR clknet_1_0__leaf_net643
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout144_A net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net748_X clknet_1_1__leaf_net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c728_S0 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c65_S1 net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c81_S0 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c230_SCE net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c494_A3 net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc430 net348 net353 VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__nand2_1
XFILLER_0_20_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc452 net717 VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__buf_6
Xc463 net948 net763 net791 clknet_1_0__leaf_net794 VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__or4bb_1
Xc441 net75 clknet_1_0__leaf_net365 net950 clknet_1_0__leaf_net899 net689 VGND VGND
+ VPWR VPWR net366 sky130_fd_sc_hd__a2111o_2
XFILLER_0_20_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc496 net416 clknet_1_0__leaf_net937 net896 net410 net898 clknet_1_1__leaf_net423
+ VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__mux4_4
Xc485 net422 clknet_1_1__leaf_net289 clknet_1_1__leaf_net748 VGND VGND VPWR VPWR net937
+ sky130_fd_sc_hd__nor3_4
Xc474 net393 net916 net261 clknet_1_0__leaf_net394 clknet_1_0__leaf_net747 VGND VGND
+ VPWR VPWR net398 sky130_fd_sc_hd__a2111o_2
XFILLER_0_19_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c373_S0 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge916_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_10_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c186_B net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c353_B net850 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net440 clknet_0_net440 VGND VGND VPWR VPWR clknet_1_0__leaf_net440
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c595_A2 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout147_X net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire119 net219 VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__buf_1
XFILLER_0_33_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c690_SCE net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc260 net734 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__inv_4
Xc271 net66 net78 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__or2b_1
Xc293 net211 net83 net831 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__nor3b_1
Xc282 net206 net194 net192 VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__nand3_4
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge792 net112 net116 net204 net236 net945 net722 VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__mux4_1
XFILLER_0_70_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c101_B net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold27 net376 VGND VGND VPWR VPWR net1020 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c463_A net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c741_S0 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net292 clknet_0_net292 VGND VGND VPWR VPWR clknet_1_0__leaf_net292
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input37_A in41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net438 clknet_0_net438 VGND VGND VPWR VPWR clknet_1_1__leaf_net438
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_77_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c323_C net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c316_B net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c685_B net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c767_A3 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c201_20_A clknet_1_0__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c591_CLK_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c266_B net192 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xs919 clknet_4_9_0_clk net273 VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__dfxtp_2
Xclkbuf_0_net414 net414 VGND VGND VPWR VPWR clknet_0_net414 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net447 net447 VGND VGND VPWR VPWR clknet_0_net447 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c600_B net519 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net425 net425 VGND VGND VPWR VPWR clknet_0_net425 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_2_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s919_Q net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_66_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_85_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net814 clknet_0_net814 VGND VGND VPWR VPWR clknet_1_0__leaf_net814
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_18_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_75_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_1_0__f_net748_X clknet_1_0__leaf_net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_96_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c609_SCE net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_84_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c383_B net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c488_C net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c241_C1 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c550_B net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c480_D_N net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc612 net1005 net454 clknet_1_0__leaf_net516 net799 VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__or4bb_1
Xc601 net128 net504 net403 clknet_1_0__leaf_net517 net513 net803 VGND VGND VPWR VPWR
+ net505 sky130_fd_sc_hd__mux4_1
Xc634 net163 net938 net123 clknet_1_1__leaf_net899 clknet_1_0__leaf_net527 net888
+ VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__mux4_1
Xc623 net30 net523 clknet_1_1__leaf_net939 clknet_1_0__leaf_net527 net413 net808 VGND
+ VGND VPWR VPWR net528 sky130_fd_sc_hd__mux4_2
Xc667 net559 net543 VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__nand2_2
Xc678 net705 VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__clkbuf_1
Xc689 net329 clknet_1_0__leaf_net564 net327 net541 net962 net770 VGND VGND VPWR VPWR
+ net570 sky130_fd_sc_hd__mux4_1
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c607_D1 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c211_A2 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c229_B net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout137_A net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c744_S0 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c81_S1 net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc420 net717 VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__clkinv_8
XFILLER_0_20_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc453 net723 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__inv_1
Xc431 net229 net354 net966 VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__or3_1
Xc464 net735 VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__buf_4
Xc442 net681 VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__buf_6
XFILLER_0_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc475 clknet_1_0__leaf_net389 net973 net269 net763 VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__or4bb_4
Xc497 net163 clknet_1_1__leaf_net286 net985 net416 net396 net759 VGND VGND VPWR VPWR
+ net418 sky130_fd_sc_hd__mux4_1
Xc486 net772 VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__inv_2
XANTENNA_input22_X net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c373_S1 net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c692_D_N net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c353_C net869 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c683_D_N clknet_1_1__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net452 clknet_0_net452 VGND VGND VPWR VPWR clknet_1_0__leaf_net452
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c134_Y net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c127_X net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s945_GATE_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c674_D_N net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc250 net155 net49 clknet_1_0__leaf_net901 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__and3_4
XFILLER_0_20_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc261 net175 net188 clknet_1_0__leaf_net776 VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__or3_2
Xc272 net198 net197 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__nand2_2
Xc294 net83 net900 net216 net946 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__or4bb_1
Xc283 net207 net196 net192 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__and3_1
XANTENNA_c384_S0 net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge793 net434 net319 net197 net322 VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__or4bb_1
XFILLER_0_15_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c270_A_N net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c400_C_N net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c233_B1 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold17 net911 VGND VGND VPWR VPWR net1010 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold28 net800 VGND VGND VPWR VPWR net1021 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c741_S1 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c467_C_N net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c408_D_N net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c87_S0 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c450_B_N net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net406 clknet_0_net406 VGND VGND VPWR VPWR clknet_1_1__leaf_net406
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net439 clknet_0_net439 VGND VGND VPWR VPWR clknet_1_1__leaf_net439
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output98_A clknet_1_0__leaf_net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_90_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net940 clknet_0_net940 VGND VGND VPWR VPWR clknet_1_1__leaf_net940
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c697_C_N net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c309_B net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge812_A1 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c752_S0 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c410_A1 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c201_13_A clknet_1_1__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c601_A0 net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c581_SCE net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c693_A3 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c161_B net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c154_A net869 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c433_C net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout122_X net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c124_A2 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input52_X net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c306_SCE net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_96_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c550_C net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_A3 net328 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s931_Q net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net289 net289 VGND VGND VPWR VPWR clknet_0_net289 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc602 net500 net504 net496 net754 net786 net797 VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__mux4_1
Xc613 clknet_4_3_0_clk net963 clknet_1_0__leaf_net517 net840 net455 net798 VGND VGND
+ VPWR VPWR net519 net518 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_32_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc624 net402 clknet_1_0__leaf_net527 net503 net989 net518 net909 VGND VGND VPWR VPWR
+ net529 sky130_fd_sc_hd__mux4_2
Xc635 net536 net535 net31 net122 clknet_1_0__leaf_net905 net807 VGND VGND VPWR VPWR
+ net538 sky130_fd_sc_hd__mux4_2
Xc668 net204 net548 VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__or2b_1
Xc679 net761 VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__inv_1
XANTENNA_input12_A in19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c607_C1 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output80_A net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c472_SCD net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c699_A2 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c660_B net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input4_A in11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c274_X net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c760_S0 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc421 net773 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__clkbuf_2
Xc410 net209 net334 net321 net79 net686 net752 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__mux4_1
XFILLER_0_32_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc443 net851 net72 clknet_1_0__leaf_net899 net122 net97 VGND VGND VPWR VPWR net368
+ sky130_fd_sc_hd__a2111o_4
Xc432 net717 VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__clkbuf_2
Xc454 net341 net339 net346 net377 VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__or4bb_2
XFILLER_0_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c443_D1 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc465 net375 net1025 net386 net1010 VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__or4bb_1
Xc487 net772 VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__clkbuf_2
Xc476 clknet_1_1__leaf_net394 net259 net700 net1026 VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__or4bb_2
XANTENNA_merge791_S1 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc498 clknet_1_1__leaf_net366 net984 clknet_1_0__leaf_net414 net410 clknet_1_0__leaf_net748
+ net759 VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__mux4_4
XFILLER_0_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input15_X net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_93_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net442 clknet_0_net442 VGND VGND VPWR VPWR clknet_1_0__leaf_net442
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c234_A net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_444 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c438_D1 clknet_1_0__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc240 net162 net165 clknet_1_0__leaf_net161 clknet_1_1__leaf_net156 net150 VGND VGND
+ VPWR VPWR net168 sky130_fd_sc_hd__a2111oi_0
Xc251 net105 net178 net45 net159 net790 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__a2111oi_1
Xc262 net128 net188 clknet_1_1__leaf_net182 net908 net919 clknet_1_0__leaf_net901
+ VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__mux4_1
Xc295 net215 net723 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__and2b_1
Xc273 net71 net194 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__nor2_2
Xc284 net193 net209 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__or2_2
XFILLER_0_87_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge794 net157 clknet_1_1__leaf_net169 net55 net176 net173 net694 VGND VGND VPWR
+ VPWR net655 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_31_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c233_A1 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold29 net735 VGND VGND VPWR VPWR net1022 sky130_fd_sc_hd__dlygate4sd3_1
Xhold18 net328 VGND VGND VPWR VPWR net1011 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_39_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c87_S1 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net407 clknet_0_net407 VGND VGND VPWR VPWR clknet_1_1__leaf_net407
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c354_X net915 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc537_1 net746 VGND VGND VPWR VPWR net975 sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_76_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input42_A in46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c478_Q net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net254_X clknet_1_0__leaf_net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge807_A2 net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c321_B net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net438 net438 VGND VGND VPWR VPWR clknet_0_net438 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc501_10 clknet_1_0__leaf_net748 VGND VGND VPWR VPWR net984 sky130_fd_sc_hd__clkinv_2
XFILLER_0_101_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c471_X net395 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c165_C1 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_96_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c403_SET_B net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c317_X net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc603 net510 net504 net500 net496 net791 net804 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__mux4_1
XFILLER_0_32_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc636 net455 net480 clknet_1_1__leaf_net527 net951 net772 net808 VGND VGND VPWR VPWR
+ net539 sky130_fd_sc_hd__mux4_2
Xc614 net339 net938 net514 net429 net1021 VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__a2111oi_1
Xc625 net480 net128 net31 net792 net805 net808 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__mux4_4
Xc669 net544 net557 VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__nand2b_1
XFILLER_0_86_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s928_GATE_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c607_B1 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c472_SCE net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output73_A net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c699_A3 net328 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc201_13 clknet_1_1__leaf_net776 VGND VGND VPWR VPWR net987 sky130_fd_sc_hd__inv_2
XFILLER_0_14_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc411 net335 net898 net332 net322 net1019 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__a2111o_1
Xc400 net320 net321 net75 net950 VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__or4bb_1
Xc422 net72 net851 VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__or2b_4
Xc444 net126 net898 net347 net946 clknet_1_0__leaf_net794 VGND VGND VPWR VPWR net369
+ sky130_fd_sc_hd__o2111ai_4
Xc433 net357 net356 net346 VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__and3b_2
Xc455 clknet_1_0__leaf_net372 net378 VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__nor2b_1
XPHY_EDGE_ROW_8_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c443_C1 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc466 net147 net191 clknet_1_0__leaf_net747 net347 VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__or4bb_4
Xc488 net378 net422 net896 VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__nand3_1
Xc477 net388 net337 net261 net347 clknet_1_0__leaf_net373 VGND VGND VPWR VPWR net401
+ sky130_fd_sc_hd__a2111oi_0
XFILLER_0_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc499 net419 net422 clknet_1_1__leaf_net425 net886 clknet_1_0__leaf_net904 net935
+ VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__mux4_1
XANTENNA_output111_A net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge910 clknet_4_7_0_clk net577 net632 VGND VGND VPWR VPWR net779 net778 sky130_fd_sc_hd__dfrbp_2
XFILLER_0_51_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c503_A2 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout142_A net441 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge815_A2 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c401_B net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c710_A0 net571 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c306_Q net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc230 clknet_4_8_0_clk clknet_1_1__leaf_net152 net157 clknet_1_0__leaf_net156 net150
+ VGND VGND VPWR VPWR net927 net158 sky130_fd_sc_hd__sdfrbp_2
Xc252 net871 net159 net693 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__and3_1
Xc241 clknet_1_1__leaf_net156 net162 net165 net873 net741 VGND VGND VPWR VPWR net169
+ sky130_fd_sc_hd__o2111ai_2
Xc263 net188 clknet_1_0__leaf_net920 clknet_1_0__leaf_net182 net970 net891 net758
+ VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__mux4_4
Xc296 net723 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__clkbuf_2
Xc285 net195 net208 net207 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__nor3b_1
Xc274 net200 net193 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__or2_4
XFILLER_0_46_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c620_A0 net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge795 clknet_1_0__leaf_net439 net435 net200 net941 net948 VGND VGND VPWR VPWR
+ net656 sky130_fd_sc_hd__o2111a_4
XFILLER_0_70_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c217_A3 net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c233_A2 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold19 net774 VGND VGND VPWR VPWR net1012 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout145_X net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c705_A0 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_98_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c92_Y net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c85_X net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_90_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge915_Q net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net920 clknet_0_net920 VGND VGND VPWR VPWR clknet_1_1__leaf_net920
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c350_B1 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c294_A net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c410_A3 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge793_B net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c496_S0 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input35_A in4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge865_Q net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net794 clknet_0_net794 VGND VGND VPWR VPWR clknet_1_1__leaf_net794
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net439 net439 VGND VGND VPWR VPWR clknet_0_net439 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_29_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net406 net406 VGND VGND VPWR VPWR clknet_0_net406 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc501_11 clknet_1_0__leaf_net748 VGND VGND VPWR VPWR net985 sky130_fd_sc_hd__clkinv_2
XFILLER_0_16_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c683_B net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c702_A1 net562 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c297_X net223 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c763_S1 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c569_Y net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c464_X net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c294_C_N net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net940 net940 VGND VGND VPWR VPWR clknet_0_net940 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c301_22_A clknet_1_0__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c372_D1 clknet_1_0__leaf_net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c241_A2 net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c529_B net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c424_A net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net776_X clknet_1_1__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_62_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc604 net500 net504 clknet_1_0__leaf_net407 net886 net760 net804 VGND VGND VPWR VPWR
+ net508 sky130_fd_sc_hd__mux4_1
Xc626 clknet_1_1__leaf_net414 clknet_1_1__leaf_net527 net454 net386 net753 net760
+ VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__mux4_4
Xc637 net916 net979 net760 net774 clknet_1_0__leaf_net904 net810 VGND VGND VPWR VPWR
+ net540 sky130_fd_sc_hd__mux4_1
Xc615 net514 net402 clknet_1_1__leaf_net516 clknet_1_0__leaf_net917 net913 net802
+ VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__mux4_2
XANTENNA_c713_A0 net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_71_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_80_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c594_DE net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c623_A0 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output66_A net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc201_14 clknet_1_1__leaf_net776 VGND VGND VPWR VPWR net988 sky130_fd_sc_hd__inv_2
XFILLER_0_1_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c267_Y net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c708_A0 net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c610_D_N net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc412 net331 net200 net335 net338 net752 net771 VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__mux4_2
Xc401 net321 net199 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__or2_2
Xc434 net354 net191 net358 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__and3b_1
Xc445 net364 net2 net946 VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__nand3_2
Xc423 net343 net65 net967 VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__or3_4
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c443_B1 clknet_1_0__leaf_net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc456 net85 net875 clknet_1_0__leaf_net379 clknet_1_0__leaf_net365 net342 net771 VGND
+ VGND VPWR VPWR net380 sky130_fd_sc_hd__mux4_1
Xc467 net129 net259 net930 net263 VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__or4bb_1
Xc478 clknet_4_12_0_clk clknet_1_0__leaf_net899 clknet_1_1__leaf_net939 net1023 net1013
+ VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__sdfstp_2
Xc489 clknet_1_1__leaf_net748 VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c740_D1 clknet_1_1__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c459_Q_N net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge911 clknet_4_13_0_clk net647 net400 VGND VGND VPWR VPWR net781 net780 sky130_fd_sc_hd__dfrbp_1
XANTENNA_output104_A net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge900 net287 clknet_4_11_0_clk merge900/RESET_B VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__dlrtn_1
XFILLER_0_51_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c223_B_N net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c503_A3 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net477 clknet_0_net477 VGND VGND VPWR VPWR clknet_1_0__leaf_net477
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_62_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout135_A net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c263_A0 net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c710_A1 net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c438_B1 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c613_Q_N net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_79_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc220 net132 net827 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__and2b_1
Xc231 net741 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__inv_6
Xc253 net38 net173 net180 clknet_1_0__leaf_net901 net789 VGND VGND VPWR VPWR net181
+ sky130_fd_sc_hd__o2111a_4
Xc242 net34 net55 net958 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__and3b_1
XFILLER_0_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc297 net723 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__buf_6
Xc286 net208 net67 net195 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__nor3_1
Xc264 net78 net74 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__nand2_8
Xc275 net191 net71 net201 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__nand3_1
XFILLER_0_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A1 clknet_1_1__leaf_net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge866_GATE_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge796 net449 net451 net344 net857 net950 net319 VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__mux4_1
XFILLER_0_55_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_524 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c380_D1 clknet_1_0__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c184_C net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput1 in0 VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_67_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c177_B net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_39_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout138_X net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c705_A1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c766_S1 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c661_X net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c501_12_A clknet_1_1__leaf_net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c729_RESET_B clknet_1_1__leaf_net365 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c615_A1 net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net921 clknet_0_net921 VGND VGND VPWR VPWR clknet_1_1__leaf_net921
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net910 clknet_0_net910 VGND VGND VPWR VPWR clknet_1_1__leaf_net910
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_0_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c375_D1 clknet_1_0__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c294_B net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c287_A net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c454_A net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s947_Q net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c716_A0 net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c435_A1 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge839_Y net703 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input28_A in33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_87_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c329_A2 clknet_1_0__leaf_net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output96_A net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net795 clknet_0_net795 VGND VGND VPWR VPWR clknet_1_1__leaf_net795
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net776_X clknet_1_0__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net407 net407 VGND VGND VPWR VPWR clknet_0_net407 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c239_A2 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c597_S0 net762 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc501_12 clknet_1_1__leaf_net748 VGND VGND VPWR VPWR net986 sky130_fd_sc_hd__clkinv_2
XFILLER_0_101_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c727_C1 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_18_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c356_A0 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c210_S0 net138 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_96_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net570 clknet_0_net570 VGND VGND VPWR VPWR clknet_1_1__leaf_net570
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c431_C net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c424_B net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c417_A net339 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc616 net123 net30 net518 net252 net502 net753 VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__mux4_1
Xc605 net973 net454 net492 net403 net800 VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__a2111oi_1
Xc627 net163 net952 net402 net980 net700 net810 VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__mux4_4
XANTENNA_c713_A1 net546 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_23_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c607_A2 net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input50_X net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c325_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc201_15 clknet_1_1__leaf_net776 VGND VGND VPWR VPWR net989 sky130_fd_sc_hd__inv_2
XFILLER_0_14_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c383_D_N net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c769_S1 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc402 net324 net341 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__and2_1
XFILLER_0_32_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c443_A1 net851 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc424 net97 net835 net1009 VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__or3_1
Xc413 net193 net131 VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__nand2_8
Xc435 net359 net85 net950 net90 net349 net353 VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__mux4_1
Xc446 clknet_1_0__leaf_net365 net341 net947 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__nor3b_1
Xc468 net347 net930 net261 VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__or3_1
Xc457 net377 net232 net343 net341 net375 net682 VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__mux4_2
Xc479 clknet_4_12_0_clk clknet_1_1__leaf_net387 net869 net968 clknet_1_0__leaf_net747
+ VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__sdfstp_1
XANTENNA_c740_C1 net571 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c126_D_N net49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input10_A in17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge912 clknet_4_4_0_clk net462 net745 VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__dfrtn_1
Xmerge901 net374 clknet_4_0_0_clk net336 VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__dlrtn_2
XFILLER_0_51_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c613_Q net519 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c618_A1 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c634_A0 net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c695_S0 net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c176_C_N net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net423 clknet_0_net423 VGND VGND VPWR VPWR clknet_1_0__leaf_net423
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net445 clknet_0_net445 VGND VGND VPWR VPWR clknet_1_0__leaf_net445
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net478 clknet_0_net478 VGND VGND VPWR VPWR clknet_1_0__leaf_net478
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_62_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout128_A net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c491_B net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input2_A in1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c710_A2 net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c499_S1 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc221 clknet_1_0__leaf_net140 net974 net957 VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__nor3_4
Xc210 clknet_1_0__leaf_net136 net23 net88 net993 net138 clknet_1_1__leaf_net135 VGND
+ VGND VPWR VPWR net140 sky130_fd_sc_hd__mux4_2
XANTENNA_c604_A3 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc243 clknet_1_0__leaf_net169 net150 net38 net57 net908 net958 VGND VGND VPWR VPWR
+ net171 sky130_fd_sc_hd__mux4_2
XANTENNA_input58_A in60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc232 clknet_1_0__leaf_net156 net19 net158 net154 net105 net961 VGND VGND VPWR VPWR
+ net160 sky130_fd_sc_hd__mux4_2
XANTENNA_c173_A1 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc254 net166 clknet_1_0__leaf_net179 net958 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__or3b_2
XFILLER_0_32_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c158_C_N net851 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc287 net859 net69 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__and2_1
Xc265 net858 net63 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__and2b_2
Xc276 net197 net74 net869 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__nor3_1
Xc298 net221 net67 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_5_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A2 net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input13_X net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge888_Q net754 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge797 clknet_1_1__leaf_net135 net157 clknet_1_1__leaf_net140 net19 clknet_1_0__leaf_net161
+ VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__a2111o_4
XTAP_TAPCELL_ROW_31_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c586_D_N net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput2 in1 VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_67_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c177_C net848 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_39_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net584_X clknet_1_1__leaf_net584 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net286 clknet_0_net286 VGND VGND VPWR VPWR clknet_1_0__leaf_net286
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c705_A2 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c721_A1 net850 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_244 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net933 clknet_0_net933 VGND VGND VPWR VPWR clknet_1_1__leaf_net933
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c350_A2 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c287_B net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c454_B net339 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout150_X net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net899_X clknet_0_net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c435_A2 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c533_C_N net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_41_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c146_A_N net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_8_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c202_B net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput60 in7 VGND VGND VPWR VPWR net883 sky130_fd_sc_hd__buf_1
XFILLER_0_58_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c149_A3 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c727_B1 net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net920 net920 VGND VGND VPWR VPWR clknet_0_net920 sky130_fd_sc_hd__clkbuf_16
XANTENNA_rebuffer3_X net436 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input40_A in44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c637_A0 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c356_A1 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c367_A_N net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c424_C net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc628 net833 net454 clknet_1_1__leaf_net527 net888 net760 net810 VGND VGND VPWR VPWR
+ net532 sky130_fd_sc_hd__mux4_1
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc606 net403 clknet_1_0__leaf_net366 net93 net339 net903 net798 VGND VGND VPWR VPWR
+ net917 sky130_fd_sc_hd__mux4_4
Xc617 net454 net252 clknet_1_0__leaf_net414 net163 net792 clknet_1_0__leaf_net904
+ VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__mux4_4
XANTENNA_merge915_RESET_B net621 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c713_A2 net562 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net794 net794 VGND VGND VPWR VPWR clknet_0_net794 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_50_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c623_A2 clknet_1_1__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net638 clknet_0_net638 VGND VGND VPWR VPWR clknet_1_0__leaf_net638
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc201_16 clknet_1_1__leaf_net776 VGND VGND VPWR VPWR net990 sky130_fd_sc_hd__inv_2
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c155_Y net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c148_X net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c131_S0 net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc403 clknet_4_1_0_clk net340 net199 net325 net341 VGND VGND VPWR VPWR net327 net326
+ sky130_fd_sc_hd__sdfsbp_2
Xc425 net195 net226 net347 net946 net967 net689 VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__mux4_2
Xc436 net355 net356 net358 net967 net966 VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__a2111oi_1
Xc414 net202 net206 VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__and2_1
XANTENNA_c443_A2 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc447 net368 net346 net951 VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__or3_4
Xc469 clknet_4_9_0_clk clknet_1_0__leaf_net387 net269 net390 net388 net263 VGND VGND
+ VPWR VPWR net393 net392 sky130_fd_sc_hd__sdfbbn_1
Xc458 net946 clknet_1_0__leaf_net366 net850 net381 net682 VGND VGND VPWR VPWR net382
+ sky130_fd_sc_hd__a2111o_4
XFILLER_0_87_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge913 clknet_4_6_0_clk net579 net508 VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__dfrtp_4
Xmerge902 net533 clknet_4_14_0_clk net652 VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__dlrtp_1
XFILLER_0_95_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c618_A2 net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c634_A1 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c695_S1 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output71_A clknet_1_0__leaf_net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c216_S0 clknet_1_0__leaf_net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c484_B net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_net939_A net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c710_A3 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c272_Y net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c265_X net192 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c68_B net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc211 net139 net83 net69 net961 net787 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__a2111oi_1
Xc200 net704 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_68_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc244 net57 net694 net789 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__or3b_1
Xc222 net961 net838 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__or2b_2
Xc233 net827 net838 net927 net154 clknet_1_0__leaf_net152 VGND VGND VPWR VPWR net161
+ sky130_fd_sc_hd__o2111ai_1
XANTENNA_c173_A2 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc255 net740 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__clkbuf_2
Xc288 net846 net213 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__nor2b_1
Xc266 net826 net192 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__nand2b_2
Xc277 net201 net900 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__and2_4
Xc299 net65 net223 net722 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__and3_1
XFILLER_0_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A3 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c629_A1 net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge798 net119 net875 net879 net857 net128 VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__o2111ai_1
XFILLER_0_23_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput3 in10 VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_39_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge811_S0 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net276 clknet_0_net276 VGND VGND VPWR VPWR clknet_1_0__leaf_net276
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net254 clknet_0_net254 VGND VGND VPWR VPWR clknet_1_0__leaf_net254
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c609_D net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c449_A1 net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net901 clknet_0_net901 VGND VGND VPWR VPWR clknet_1_1__leaf_net901
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c375_B1 net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c672_D1 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_4_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c182_B net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c447_B net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout143_X net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c435_A3 net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_87_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c626_A2 net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge894_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge913_Q net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput50 in53 VGND VGND VPWR VPWR net873 sky130_fd_sc_hd__clkbuf_4
Xinput61 in8 VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__buf_1
XFILLER_0_12_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c397_B net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c564_B net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c345_X net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c64_A2 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net921 net921 VGND VGND VPWR VPWR clknet_0_net921 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0_net910 net910 VGND VGND VPWR VPWR clknet_0_net910 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge876_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c743_A0 net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input33_A in38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c356_A2 net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_22_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c312_B net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c404_Q_N net328 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc618 clknet_1_1__leaf_net366 net966 net163 net981 net251 net792 VGND VGND VPWR VPWR
+ net524 sky130_fd_sc_hd__mux4_4
Xc607 net375 net857 net252 net967 net840 VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__a2111o_1
XTAP_TAPCELL_ROW_73_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c681_B net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc629 net503 net454 clknet_1_1__leaf_net527 net806 net807 net809 VGND VGND VPWR VPWR
+ net533 sky130_fd_sc_hd__mux4_4
XFILLER_0_99_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_40_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c457_A1 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net795 net795 VGND VGND VPWR VPWR clknet_0_net795 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_50_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_12_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input36_X net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc201_17 clknet_1_1__leaf_net776 VGND VGND VPWR VPWR net991 sky130_fd_sc_hd__inv_2
XANTENNA_merge814_S0 net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c422_A net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c708_A3 net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c574_C1 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc426 net717 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__buf_16
Xc415 net77 net885 VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__and2b_4
Xc437 net356 net213 net340 net967 net946 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__o2111ai_1
Xc404 clknet_4_1_0_clk net206 net339 net326 net322 VGND VGND VPWR VPWR net329 net328
+ sky130_fd_sc_hd__sdfsbp_2
Xc448 net878 clknet_1_0__leaf_net372 net689 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__and3b_1
XFILLER_0_40_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc459 clknet_4_3_0_clk clknet_1_1__leaf_net379 net238 net370 net376 net1010 VGND VGND
+ VPWR VPWR net886 net383 sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_99_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge903 net456 clknet_4_4_0_clk net711 VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__dlrtp_4
XFILLER_0_67_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge914 clknet_4_4_0_clk net553 net384 VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_67_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net570 net570 VGND VGND VPWR VPWR clknet_0_net570 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c634_A2 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output64_A net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net425 clknet_0_net425 VGND VGND VPWR VPWR clknet_1_0__leaf_net425
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net414 clknet_0_net414 VGND VGND VPWR VPWR clknet_1_0__leaf_net414
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net447 clknet_0_net447 VGND VGND VPWR VPWR clknet_1_0__leaf_net447
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c232_S0 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c108_B net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c263_A3 net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_187 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c569_C1 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c719_A2 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_81_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c142_S0 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_33_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c585_D1 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc212 net954 net120 clknet_1_1__leaf_net140 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__nand3_1
XFILLER_0_20_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc234 net741 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__clkinv_8
Xc245 net55 net925 net790 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__nand3_2
Xc223 net130 net69 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__nor2b_1
Xc256 net183 net175 net128 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__nor3b_1
Xc267 net70 net826 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__nor2_4
Xc278 net202 net192 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__or2_1
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc289 net213 net1028 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_5_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c677_B_N net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output102_A net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge799 net953 net236 clknet_1_0__leaf_net372 net126 VGND VGND VPWR VPWR net660
+ sky130_fd_sc_hd__or4bb_4
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput4 in11 VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c389_C1 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge811_S1 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_0_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c721_A3 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c542_X net441 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c746_A0 net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c481_A0 net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net924 clknet_0_net924 VGND VGND VPWR VPWR clknet_1_1__leaf_net924
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge893_Q net760 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c672_C1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge806_S1 net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_87_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c447_C net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net899_A clknet_0_net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c716_A3 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c123_X net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c502_A net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c103_D1 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c501_10_A clknet_1_0__leaf_net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c626_A3 net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge906_Q net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s946_GATE_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net776 clknet_0_net776 VGND VGND VPWR VPWR clknet_1_1__leaf_net776
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c478_SCD clknet_1_1__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput40 in44 VGND VGND VPWR VPWR net863 sky130_fd_sc_hd__buf_1
Xinput51 in54 VGND VGND VPWR VPWR net874 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput62 in9 VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c292_B net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c577_C1 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c727_A2 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net933 net933 VGND VGND VPWR VPWR clknet_0_net933 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c599_SET_B net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input26_A in31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c637_A2 net760 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge790_A1 net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net595 clknet_0_net595 VGND VGND VPWR VPWR clknet_1_1__leaf_net595
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net584 clknet_0_net584 VGND VGND VPWR VPWR clknet_1_1__leaf_net584
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c305_B net223 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc608 clknet_4_3_0_clk net93 net941 net337 clknet_1_0__leaf_net794 VGND VGND VPWR
+ VPWR net512 net511 sky130_fd_sc_hd__sedfxbp_1
Xc619 net413 net892 net515 clknet_1_1__leaf_net414 net251 net792 VGND VGND VPWR VPWR
+ net525 sky130_fd_sc_hd__mux4_4
XFILLER_0_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c462_Y net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c622_X net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c98_C net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c579_Q net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc201_18 clknet_1_0__leaf_net776 VGND VGND VPWR VPWR net992 sky130_fd_sc_hd__inv_2
XANTENNA_c179_C_N net847 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c429_SET_B net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c150_A net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c412_S1 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c574_B1 net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc427 net838 net201 net967 VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__nand3b_1
Xc416 net898 net338 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__and2b_1
Xc405 net686 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__inv_1
Xc449 net349 net948 net953 net945 net342 net951 VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__mux4_1
Xc438 net359 net343 net97 net721 clknet_1_0__leaf_net794 VGND VGND VPWR VPWR net363
+ sky130_fd_sc_hd__o2111a_4
XTAP_TAPCELL_ROW_28_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c603_S0 net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge904 net461 clknet_4_14_0_clk net724 VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__dlrtp_4
XFILLER_0_95_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge915 clknet_4_5_0_clk net551 net621 VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_95_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c634_A3 clknet_1_1__leaf_net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c232_S1 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c394_A0 net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge809_S1 net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_0_net395_A net395 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c365_A net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c160_Y net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_53_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c735_A2 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc202 net1024 net120 net951 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__or3b_1
XFILLER_0_60_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc224 clknet_1_1__leaf_net142 net42 net957 net37 net958 VGND VGND VPWR VPWR net152
+ sky130_fd_sc_hd__o2111a_2
Xc213 net137 net139 net1004 clknet_1_0__leaf_net142 clknet_1_0__leaf_net135 VGND VGND
+ VPWR VPWR net894 sky130_fd_sc_hd__a2111o_2
Xc235 clknet_4_10_0_clk net159 clknet_1_1__leaf_net161 net162 net35 VGND VGND VPWR
+ VPWR net163 sky130_fd_sc_hd__sdfrtn_1
XTAP_TAPCELL_ROW_92_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc246 net56 net31 net57 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__and3_1
Xc257 net172 clknet_1_0__leaf_net179 net158 net175 net34 net790 VGND VGND VPWR VPWR
+ net185 sky130_fd_sc_hd__mux4_4
Xc268 net76 net194 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__nand2b_1
Xc279 net205 net202 net201 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__and3_1
XFILLER_0_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c364_A3 clknet_1_0__leaf_net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput5 in12 VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_36_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net899_A clknet_0_net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c243_S0 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net289 clknet_0_net289 VGND VGND VPWR VPWR clknet_1_0__leaf_net289
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c571_A1 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c449_A3 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c596_D1 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c746_A1 net483 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c80_C net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c73_B net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c762_A0 net519 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c481_A1 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input56_A in59 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge886_Q net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c375_A2 clknet_1_0__leaf_net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c672_B1 net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c168_B net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c193_SCD net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net894_A net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c502_B net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c116_X net49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout129_X net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c697_A net571 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input3_X net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c560_A_N net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c611_S0 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c195_A2 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net777 clknet_0_net777 VGND VGND VPWR VPWR clknet_1_1__leaf_net777
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c386_A1 net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_504 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput30 in35 VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__clkbuf_1
Xinput41 in45 VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__buf_1
Xinput52 in55 VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__buf_4
XFILLER_0_31_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge817_S1 net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c180_A net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net901 net901 VGND VGND VPWR VPWR clknet_0_net901 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c743_A2 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c606_S0 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input19_A in25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c637_A3 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net563 clknet_0_net563 VGND VGND VPWR VPWR clknet_1_1__leaf_net563
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net552 clknet_0_net552 VGND VGND VPWR VPWR clknet_1_1__leaf_net552
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc609 clknet_4_3_0_clk net941 net1017 net386 net93 net1012 VGND VGND VPWR VPWR net514
+ net513 sky130_fd_sc_hd__sdfbbp_1
XANTENNA_c563_A2 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c667_B net543 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c457_A3 net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_23_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc201_19 clknet_1_0__leaf_net776 VGND VGND VPWR VPWR net993 sky130_fd_sc_hd__inv_2
XFILLER_0_1_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net382 clknet_0_net382 VGND VGND VPWR VPWR clknet_1_1__leaf_net382
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net371 clknet_0_net371 VGND VGND VPWR VPWR clknet_1_1__leaf_net371
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c150_B net869 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c143_A net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c310_A net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c574_A1 net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc406 net65 net199 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__nor2b_2
Xc428 net340 net349 net966 net331 net967 net689 VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__mux4_1
Xc417 net339 net205 VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__and2_2
XANTENNA_c590_A0 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc439 net967 net361 net97 net835 net359 net721 VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c749_A1 net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c86_A2 net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c404_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge916 clknet_4_13_0_clk net696 net616 VGND VGND VPWR VPWR net786 net785 sky130_fd_sc_hd__dfsbp_1
Xmerge905 clknet_4_14_0_clk net484 net307 VGND VGND VPWR VPWR net775 net889 sky130_fd_sc_hd__edfxbp_1
XANTENNA_c765_A0 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net438 clknet_0_net438 VGND VGND VPWR VPWR clknet_1_0__leaf_net438
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_19_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c365_B net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c153_Y net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s920_Q net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_61_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc203 net734 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__clkinv_8
XFILLER_0_32_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc214 clknet_1_0__leaf_net140 net955 net134 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__or3_4
Xc225 net974 clknet_1_1__leaf_net140 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__nor2b_4
Xc236 net762 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_92_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c751_A2 net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc258 net180 net175 net38 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__or3_1
XFILLER_0_13_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc247 net740 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__clkbuf_2
Xc269 net831 net66 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__nand2_1
XANTENNA_c470_A3 net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge805_X net666 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput6 in13 VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c243_S1 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c207_D1 net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c475_A net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c66_B net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c481_A2 net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input49_A in52 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net904 clknet_0_net904 VGND VGND VPWR VPWR clknet_1_1__leaf_net904
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net937 clknet_0_net937 VGND VGND VPWR VPWR clknet_1_1__leaf_net937
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_87_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge821_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c193_SCE net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c463_C_N net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c757_A1 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c454_C_N net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput20 in26 VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__clkbuf_1
Xinput31 in36 VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__clkbuf_1
Xinput53 in56 VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__buf_1
Xinput42 in46 VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c249_S0 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c278_B net192 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c445_B net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net924 net924 VGND VGND VPWR VPWR clknet_0_net924 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c612_B net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c743_A3 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c622_S0 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net564 clknet_0_net564 VGND VGND VPWR VPWR clknet_1_1__leaf_net564
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net575 clknet_0_net575 VGND VGND VPWR VPWR clknet_1_1__leaf_net575
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_73_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c707_S0 net328 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_84_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
Xclone12 net345 VGND VGND VPWR VPWR net1027 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_23_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net776 net776 VGND VGND VPWR VPWR clknet_0_net776 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_51_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_95_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c617_S0 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input31_A in36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c527_S0 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net372 clknet_0_net372 VGND VGND VPWR VPWR clknet_1_1__leaf_net372
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net394 clknet_0_net394 VGND VGND VPWR VPWR clknet_1_1__leaf_net394
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c262_S0 net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c310_B net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc418 net79 net885 VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__nand2_2
Xc407 net325 net329 net330 net331 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__or4bb_1
XANTENNA_c590_A1 net473 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc429 clknet_4_0_0_clk net344 net231 net349 net967 net90 VGND VGND VPWR VPWR net354
+ net353 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_99_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c749_A2 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c86_A3 net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge906 clknet_4_13_0_clk net469 net644 VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__edfxtp_1
XFILLER_0_67_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c96_B net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c89_A net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net584 net584 VGND VGND VPWR VPWR clknet_0_net584 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net595 net595 VGND VGND VPWR VPWR clknet_0_net595 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_50_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c347_S0 clknet_1_0__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input34_X net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge796_A2 net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net406 clknet_0_net406 VGND VGND VPWR VPWR clknet_1_0__leaf_net406
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net439 clknet_0_net439 VGND VGND VPWR VPWR clknet_1_0__leaf_net439
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c394_A2 clknet_1_0__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c198_C net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net940 net1032 VGND VGND VPWR VPWR clknet_1_0__leaf_net940 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_81_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc215 net8 clknet_1_0__leaf_net143 net91 net949 net1 net128 VGND VGND VPWR VPWR net144
+ sky130_fd_sc_hd__mux4_4
Xc204 net704 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__inv_4
Xc226 net869 net23 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_92_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c751_A3 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc259 net35 net186 net180 net175 net174 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__a2111o_1
Xc248 net170 clknet_1_0__leaf_net894 net925 net175 net790 VGND VGND VPWR VPWR net176
+ sky130_fd_sc_hd__o2111a_2
Xc237 clknet_4_8_0_clk net164 net132 clknet_1_0__leaf_net921 net149 VGND VGND VPWR
+ VPWR net165 sky130_fd_sc_hd__sdfrtp_1
XANTENNA_c675_X net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc760 net950 net634 net497 net611 net802 net971 VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__mux4_1
Xinput7 in14 VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c389_A2 clknet_1_0__leaf_net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c207_C1 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c468_A net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c746_A3 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c423_X net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net905 clknet_0_net905 VGND VGND VPWR VPWR clknet_1_1__leaf_net905
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_87_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output100_A net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c391_A3 net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc590 net938 net473 net251 clknet_1_1__leaf_net440 net892 net756 VGND VGND VPWR VPWR
+ net491 sky130_fd_sc_hd__mux4_2
XFILLER_0_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c160_C_N net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c582_A2 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_65_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c109_Y net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_74_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c340_D_N net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c757_A2 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input61_A in8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_92_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c386_A3 clknet_1_1__leaf_net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput10 in17 VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__clkbuf_4
Xinput21 in27 VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__buf_4
XFILLER_0_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput32 in37 VGND VGND VPWR VPWR net855 sky130_fd_sc_hd__buf_1
Xinput54 in57 VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__clkbuf_2
Xinput43 in47 VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_58_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c180_C net689 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c445_C net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c593_A1 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c500_A net436 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c622_S1 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c363_C_N clknet_1_0__leaf_net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge904_Q net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net598 clknet_0_net598 VGND VGND VPWR VPWR clknet_1_1__leaf_net598
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c608_SCD net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c290_B net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c354_C_N net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c325_Q_N net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c176_Y net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c450_A net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_84_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c754_A3 clknet_1_1__leaf_net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net777 net777 VGND VGND VPWR VPWR clknet_0_net777 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_95_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input24_A in3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c633_S0 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output92_A net915 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c584_C_N net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c689_A0 net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net373 clknet_0_net373 VGND VGND VPWR VPWR clknet_1_1__leaf_net373
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net395 clknet_0_net395 VGND VGND VPWR VPWR clknet_1_1__leaf_net395
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c136_B net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc408 net332 net320 net203 net829 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__or4bb_1
Xc419 net1000 VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__inv_8
XANTENNA_clkbuf_4_6_0_clk_X clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c590_A2 net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap151 net88 VGND VGND VPWR VPWR net974 sky130_fd_sc_hd__buf_2
Xmax_cap140 net1005 VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c749_A3 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c172_S1 net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge907 clknet_4_10_0_clk net715 net190 VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__sdlclkp_1
XANTENNA_c765_A2 net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net563 net563 VGND VGND VPWR VPWR clknet_0_net563 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net552 net552 VGND VGND VPWR VPWR clknet_0_net552 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c628_S0 net760 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c347_S1 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input27_X net850 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge796_A3 net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net407 clknet_0_net407 VGND VGND VPWR VPWR clknet_1_0__leaf_net407
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_66_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c309_C_N net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_81_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge906_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c585_A2 net339 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_61_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc227 net954 net154 net150 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__or3b_1
Xc216 clknet_1_0__leaf_net142 clknet_1_1__leaf_net136 net138 clknet_1_0__leaf_net140
+ clknet_1_0__leaf_net894 net734 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__mux4_2
Xc205 net994 net974 net133 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__nand3_4
XFILLER_0_20_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc249 net46 net174 clknet_1_0__leaf_net921 net970 net908 net789 VGND VGND VPWR VPWR
+ net177 sky130_fd_sc_hd__mux4_1
Xc238 net151 net162 net165 net159 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__or4bb_1
XFILLER_0_99_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c325_Q net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c630_S1 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net382 net382 VGND VGND VPWR VPWR clknet_0_net382 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net371 net371 VGND VGND VPWR VPWR clknet_0_net371 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc750 net327 clknet_1_0__leaf_net395 net886 clknet_1_1__leaf_net940 net792 net971
+ VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__mux4_2
Xc761 clknet_1_1__leaf_net395 clknet_1_1__leaf_net638 net634 net82 net768 net792 VGND
+ VGND VPWR VPWR net642 sky130_fd_sc_hd__mux4_4
XANTENNA_c313_C1 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput8 in15 VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__buf_1
XFILLER_0_78_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c686_A1 net562 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c207_B1 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c468_B net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c363_A net138 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c596_A1 net473 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c762_A3 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net917 clknet_0_net917 VGND VGND VPWR VPWR clknet_1_1__leaf_net917
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net939 clknet_0_net939 VGND VGND VPWR VPWR clknet_1_1__leaf_net939
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_28_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc591 clknet_4_6_0_clk net238 net892 net346 clknet_1_1__leaf_net372 net1018 VGND VGND
+ VPWR VPWR net493 net492 sky130_fd_sc_hd__sdfbbn_2
Xc580 clknet_4_6_0_clk net475 clknet_1_0__leaf_net373 clknet_1_0__leaf_net477 clknet_1_1__leaf_net445
+ net346 VGND VGND VPWR VPWR net938 net481 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c501_8_A clknet_1_0__leaf_net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout124_A net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c63_S1 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c757_A3 net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c461_S0 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c201_18_A clknet_1_0__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input54_A in57 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net747 clknet_0_net747 VGND VGND VPWR VPWR clknet_1_1__leaf_net747
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c385_RESET_B net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput22 in28 VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__buf_2
Xinput11 in18 VGND VGND VPWR VPWR net834 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_40_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput33 in38 VGND VGND VPWR VPWR net856 sky130_fd_sc_hd__buf_1
Xinput44 in48 VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__clkbuf_2
Xinput55 in58 VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_24_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c166_B net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net904 net904 VGND VGND VPWR VPWR clknet_0_net904 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net937 net937 VGND VGND VPWR VPWR clknet_0_net937 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_28_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout127_X net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c490_Y net897 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c768_A2 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net599 clknet_0_net599 VGND VGND VPWR VPWR clknet_1_1__leaf_net599
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c608_SCE clknet_1_0__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c215_A0 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c588_A2 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_2_0_clk_X clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c610_A net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s936_Q net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c290_C_N net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input17_A in23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c633_S1 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_output85_A net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net363 clknet_0_net363 VGND VGND VPWR VPWR clknet_1_1__leaf_net363
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c129_B net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc409 net324 net326 net686 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__nor3_4
Xmax_cap141 net248 VGND VGND VPWR VPWR net964 sky130_fd_sc_hd__clkbuf_2
Xmax_cap130 net361 VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c665_B net869 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input9_A in16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge908 clknet_4_8_0_clk net737 net757 VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__sdlclkp_2
XANTENNA_c765_A3 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net575 net575 VGND VGND VPWR VPWR clknet_0_net575 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net564 net564 VGND VGND VPWR VPWR clknet_0_net564 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c628_S1 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c472_Q net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c254_C_N net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c327_D1 net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold25_A net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net160 clknet_0_net160 VGND VGND VPWR VPWR clknet_1_1__leaf_net160
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net182 clknet_0_net182 VGND VGND VPWR VPWR clknet_1_1__leaf_net182
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net920 clknet_0_net920 VGND VGND VPWR VPWR clknet_1_0__leaf_net920
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_53_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c682_D_N clknet_1_1__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c246_B net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c493_C_N net897 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c406_A net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc206 net864 clknet_1_0__leaf_net135 net227 net134 net961 VGND VGND VPWR VPWR net136
+ sky130_fd_sc_hd__a2111o_2
Xc217 net874 net133 clknet_1_0__leaf_net145 net23 net138 net734 VGND VGND VPWR VPWR
+ net146 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_92_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc228 clknet_1_0__leaf_net153 net931 net43 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__nand3_2
Xc239 net165 clknet_1_1__leaf_net148 net2 net158 net833 net120 VGND VGND VPWR VPWR
+ net167 sky130_fd_sc_hd__mux4_1
XANTENNA_merge800_A net223 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net372 net372 VGND VGND VPWR VPWR clknet_0_net372 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net394 net394 VGND VGND VPWR VPWR clknet_0_net394 sky130_fd_sc_hd__clkbuf_16
Xc740 net493 net620 net890 net571 clknet_1_1__leaf_net794 VGND VGND VPWR VPWR net621
+ sky130_fd_sc_hd__o2111ai_1
Xc762 net519 clknet_1_0__leaf_net638 net497 net875 net935 net971 VGND VGND VPWR VPWR
+ net643 sky130_fd_sc_hd__mux4_2
Xc751 net497 net538 net327 net838 clknet_1_0__leaf_net584 net875 VGND VGND VPWR VPWR
+ net632 sky130_fd_sc_hd__mux4_4
XANTENNA_c313_B1 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c729_SCD clknet_1_1__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput9 in16 VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__buf_1
XFILLER_0_86_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c227_C_N net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c207_A1 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c468_C net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c151_Y net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c596_A2 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c144_X net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net794 clknet_0_net794 VGND VGND VPWR VPWR clknet_1_0__leaf_net794
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_36_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc581 clknet_4_6_0_clk clknet_1_1__leaf_net371 clknet_1_0__leaf_net366 net466 net251
+ net683 VGND VGND VPWR VPWR net483 net482 sky130_fd_sc_hd__sdfbbp_1
XANTENNA_c324_C1 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc570 net201 net451 net455 net1014 net782 net797 VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__mux4_1
Xc592 clknet_1_1__leaf_net372 net892 net204 net492 net903 net906 VGND VGND VPWR VPWR
+ net494 sky130_fd_sc_hd__mux4_4
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c696_C_N net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c209_B net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c111_B net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput110 clknet_1_0__leaf_net933 VGND VGND VPWR VPWR out57 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge802_A1 net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c578_B net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c480_B net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c526_X net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c189_S0 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c422_B_N net851 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input47_A in50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net748 clknet_0_net748 VGND VGND VPWR VPWR clknet_1_1__leaf_net748
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_29_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput12 in19 VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_24_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput23 in29 VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__clkbuf_4
Xinput34 in39 VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__clkbuf_4
Xinput45 in49 VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput56 in59 VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_24_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c166_C net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c159_B net848 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net905 net905 VGND VGND VPWR VPWR clknet_0_net905 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c107_X net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c737_S0 net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c688_A net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c456_S1 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_17_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c580_SET_B net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c283_C net192 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c269_A net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c610_B net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s931_GATE clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_95_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c125_A1 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c427_A_N net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_89_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c689_A2 net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmax_cap131 net141 VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c750_S0 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge909 clknet_4_10_0_clk net729 net177 VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__sdlclkp_4
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c472_SET_B clknet_1_1__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c573_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_net598 net598 VGND VGND VPWR VPWR clknet_0_net598 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output116_A clknet_1_0__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c190_C_N net850 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_hold18_A net328 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net161 clknet_0_net161 VGND VGND VPWR VPWR clknet_1_1__leaf_net161
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net910 clknet_0_net910 VGND VGND VPWR VPWR clknet_1_0__leaf_net910
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_81_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net921 clknet_0_net921 VGND VGND VPWR VPWR clknet_1_0__leaf_net921
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_53_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c570_S0 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c141_B net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc207 net83 net8 net969 net862 net23 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__a2111oi_2
XFILLER_0_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc218 net704 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__inv_4
XTAP_TAPCELL_ROW_92_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc229 net949 net37 net155 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__and3b_1
XANTENNA_c396_Y net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c745_S0 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c738_SCE net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net373 net373 VGND VGND VPWR VPWR clknet_0_net373 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net395 net395 VGND VGND VPWR VPWR clknet_0_net395 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc730 net571 clknet_1_1__leaf_net407 clknet_1_1__leaf_net894 net786 net804 net817
+ VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__mux4_2
Xc752 net630 net622 clknet_1_1__leaf_net939 net892 net802 net822 VGND VGND VPWR VPWR
+ net633 sky130_fd_sc_hd__mux4_2
Xc763 net628 clknet_1_1__leaf_net584 net875 net634 net778 net810 VGND VGND VPWR VPWR
+ net644 sky130_fd_sc_hd__mux4_1
Xc741 net259 clknet_1_1__leaf_net940 net934 net782 net784 net906 VGND VGND VPWR VPWR
+ net622 sky130_fd_sc_hd__mux4_2
XANTENNA_merge792_S0 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c313_A1 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c361_D_N net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c729_SCE net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c686_A3 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c207_A2 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net795 clknet_0_net795 VGND VGND VPWR VPWR clknet_1_0__leaf_net795
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c409_Y net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c154_C_N net847 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge856_GATE_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc582 clknet_1_1__leaf_net478 net950 clknet_1_1__leaf_net440 net482 clknet_1_0__leaf_net382
+ VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__a2111o_2
Xc571 net450 net950 net465 net463 net346 net466 VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__mux4_4
XANTENNA_c324_B1 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc560 net95 net453 net201 VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__and3b_2
Xc593 net489 net945 clknet_1_0__leaf_net478 clknet_1_0__leaf_net472 net826 net892
+ VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_16_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput100 net923 VGND VGND VPWR VPWR out46 sky130_fd_sc_hd__buf_2
XFILLER_0_42_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput111 net934 VGND VGND VPWR VPWR out59 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c299_A net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_34_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c466_A net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net570 clknet_0_net570 VGND VGND VPWR VPWR clknet_1_0__leaf_net570
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_38_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_43_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_531 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_52_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c441_D1 net689 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput13 in2 VGND VGND VPWR VPWR net836 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_40_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput24 in3 VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__buf_2
Xinput46 in5 VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__buf_4
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput35 in4 VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__buf_1
XFILLER_0_12_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput57 in6 VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_70_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c366_C_N net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc390 net925 clknet_1_1__leaf_net899 net774 clknet_1_1__leaf_net776 net793 VGND VGND
+ VPWR VPWR net910 sky130_fd_sc_hd__o2111a_4
XFILLER_0_74_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net917 net917 VGND VGND VPWR VPWR clknet_0_net917 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net939 net939 VGND VGND VPWR VPWR clknet_0_net939 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c688_B net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c753_S0 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c436_D1 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c276_C net869 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge808_A1 clknet_1_0__leaf_net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone16 clknet_0_net940 VGND VGND VPWR VPWR net1031 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net747 net747 VGND VGND VPWR VPWR clknet_0_net747 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_51_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c578_C_N net473 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c483_S0 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c393_S0 net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net365 clknet_0_net365 VGND VGND VPWR VPWR clknet_1_1__leaf_net365
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net387 clknet_0_net387 VGND VGND VPWR VPWR clknet_1_1__leaf_net387
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c568_S0 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap132 net137 VGND VGND VPWR VPWR net955 sky130_fd_sc_hd__clkbuf_1
Xmax_cap121 net430 VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_96_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge810_A2 net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c560_C net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net599 net599 VGND VGND VPWR VPWR clknet_0_net599 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c193_Q net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input22_A in28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output109_A net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c327_B1 clknet_1_0__leaf_net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output90_A net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net140 clknet_0_net140 VGND VGND VPWR VPWR clknet_1_1__leaf_net140
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net933 clknet_0_net933 VGND VGND VPWR VPWR clknet_1_0__leaf_net933
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_53_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge805_A2 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc208 net704 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_92_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc219 clknet_1_1__leaf_net145 net147 net840 net120 clknet_1_0__leaf_net894 VGND VGND
+ VPWR VPWR net148 sky130_fd_sc_hd__a2111o_1
XANTENNA_c291_Y net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c663_A net847 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c284_X net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge905_D net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c556_Y net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net363 net363 VGND VGND VPWR VPWR clknet_0_net363 sky130_fd_sc_hd__clkbuf_16
Xc720 net568 net558 net441 clknet_1_1__leaf_net595 net816 net819 VGND VGND VPWR VPWR
+ net601 sky130_fd_sc_hd__mux4_4
Xc731 net608 net945 net610 net926 net818 VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__o2111a_1
XANTENNA_c444_D1 clknet_1_0__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc764 net888 clknet_1_1__leaf_net643 net634 clknet_1_1__leaf_net939 net810 net822
+ VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__mux4_2
Xc742 net618 net569 net619 net875 net620 net755 VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__mux4_2
Xc753 net329 net1009 net496 net783 net802 net807 VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__mux4_2
XANTENNA_c313_A2 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input25_X net848 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s930_GATE_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c504_A1 net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c137_Y net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c756_S0 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc501_4 clknet_1_1__leaf_net748 VGND VGND VPWR VPWR net978 sky130_fd_sc_hd__clkinv_2
XFILLER_0_68_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net182 net182 VGND VGND VPWR VPWR clknet_0_net182 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net160 net160 VGND VGND VPWR VPWR clknet_0_net160 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc550 net90 net344 net946 VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__and3_1
Xc572 net464 net455 clknet_1_0__leaf_net440 net453 net951 VGND VGND VPWR VPWR net472
+ sky130_fd_sc_hd__o2111a_4
Xc561 net457 clknet_1_0__leaf_net445 net459 net943 clknet_1_0__leaf_net363 net357
+ VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__mux4_1
Xc594 clknet_4_6_0_clk clknet_1_1__leaf_net472 net826 clknet_1_0__leaf_net517 net762
+ VGND VGND VPWR VPWR net497 net496 sky130_fd_sc_hd__sedfxbp_1
Xc583 clknet_1_0__leaf_net472 clknet_1_0__leaf_net372 net337 net473 net479 VGND VGND
+ VPWR VPWR net485 sky130_fd_sc_hd__o2111ai_2
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput101 clknet_1_1__leaf_net924 VGND VGND VPWR VPWR out47 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_88_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput112 net935 VGND VGND VPWR VPWR out6 sky130_fd_sc_hd__buf_2
XANTENNA_c576_S0 net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge802_A3 net842 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c299_B net223 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c128_A2 net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c441_C1 clknet_1_0__leaf_net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput25 in30 VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput36 in40 VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__clkbuf_4
Xinput14 in20 VGND VGND VPWR VPWR net837 sky130_fd_sc_hd__buf_1
XFILLER_0_24_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput58 in60 VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput47 in50 VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__buf_2
XFILLER_0_52_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_75_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc380 clknet_1_1__leaf_net179 clknet_1_0__leaf_net302 clknet_1_1__leaf_net933 net297
+ clknet_1_0__leaf_net939 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__o2111a_1
Xc391 clknet_1_0__leaf_net910 net308 net740 net919 net754 net793 VGND VGND VPWR VPWR
+ net314 sky130_fd_sc_hd__mux4_2
XFILLER_0_74_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_48_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c501_6_A clknet_1_0__leaf_net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge890 net282 net303 VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__or2_2
XFILLER_0_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout122_A net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge813_A2 net847 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c411_A2 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c130_A3 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c293_C_N net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c436_C1 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c201_16_A clknet_1_1__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_362 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input52_A in55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_17_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c473_D_N net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_7_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge808_A2 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net748 net748 VGND VGND VPWR VPWR clknet_0_net748 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout125_X net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_0_net776_X clknet_0_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c764_S0 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c403_Q net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input55_X net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net366 clknet_0_net366 VGND VGND VPWR VPWR clknet_1_1__leaf_net366
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net399 clknet_0_net399 VGND VGND VPWR VPWR clknet_1_1__leaf_net399
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_29_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_13_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap133 net40 VGND VGND VPWR VPWR net956 sky130_fd_sc_hd__buf_1
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c167_Y net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_443 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c759_S0 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c152_A1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input15_A in21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c327_A1 net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c222_B_N net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_output83_A net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge836_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net152 clknet_0_net152 VGND VGND VPWR VPWR clknet_1_1__leaf_net152
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net901 clknet_0_net901 VGND VGND VPWR VPWR clknet_1_0__leaf_net901
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c289_B_N net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c127_B net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge805_A3 net223 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc209 net849 net970 net133 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__or3_1
XANTENNA_merge827_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_92_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_A clknet_1_1__leaf_net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input7_A in14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c277_X net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c761_S1 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc721 clknet_1_0__leaf_net598 net850 clknet_1_1__leaf_net595 net962 net816 net821
+ VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__mux4_4
Xc710 net571 net845 net892 net922 net802 net818 VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__mux4_1
XANTENNA_c444_C1 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc743 net556 net620 net952 clknet_1_1__leaf_net940 net784 net785 VGND VGND VPWR VPWR
+ net624 sky130_fd_sc_hd__mux4_1
Xc732 net493 clknet_1_0__leaf_net399 net804 clknet_1_1__leaf_net812 net817 VGND VGND
+ VPWR VPWR net940 sky130_fd_sc_hd__a2111o_4
Xc754 net611 net634 clknet_1_0__leaf_net584 clknet_1_1__leaf_net894 net783 net792
+ VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__mux4_2
Xc765 net350 net524 net887 net792 net935 net895 VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__mux4_2
XANTENNA_clkbuf_4_15_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_30_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge822_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_hold23_A net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge816_A2 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c248_B1 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc501_5 clknet_1_1__leaf_net748 VGND VGND VPWR VPWR net979 sky130_fd_sc_hd__clkinv_2
XFILLER_0_83_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c92_A net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c344_SCE net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net161 net161 VGND VGND VPWR VPWR clknet_0_net161 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc540 net437 net977 VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__or2b_4
XANTENNA_c605_A1 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc551 net344 net948 net943 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__nor3b_1
Xc573 clknet_4_1_0_clk clknet_1_1__leaf_net445 net337 net967 net1015 VGND VGND VPWR
+ VPWR net473 sky130_fd_sc_hd__sdfstp_2
Xc562 clknet_1_0__leaf_net460 net327 net459 net944 net1001 VGND VGND VPWR VPWR net461
+ sky130_fd_sc_hd__o2111a_1
Xc584 clknet_1_1__leaf_net382 net473 net903 clknet_1_1__leaf_net794 VGND VGND VPWR
+ VPWR net486 sky130_fd_sc_hd__or4bb_4
XFILLER_0_47_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc595 clknet_1_1__leaf_net516 net941 clknet_1_1__leaf_net373 net259 net764 VGND VGND
+ VPWR VPWR net498 sky130_fd_sc_hd__a2111o_1
XFILLER_0_47_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c621_A0 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge884_Q_N net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c664_B_N net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput113 net936 VGND VGND VPWR VPWR out60 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_100_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput102 net925 VGND VGND VPWR VPWR out49 sky130_fd_sc_hd__buf_2
XANTENNA_c576_S1 net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c592_S0 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c361_B net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_187 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c128_A3 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_98_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c767_S0 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c425_A1 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c441_B1 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c95_X net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput15 in21 VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__clkbuf_4
Xinput26 in31 VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_40_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput37 in41 VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__buf_1
XANTENNA_c616_A0 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput59 in61 VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__buf_1
Xinput48 in51 VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_75_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc370 net278 clknet_1_0__leaf_net290 net154 net37 clknet_1_0__leaf_net933 clknet_1_0__leaf_net291
+ VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__mux4_4
Xc381 net188 clknet_1_0__leaf_net933 clknet_1_0__leaf_net291 net923 net728 VGND VGND
+ VPWR VPWR net924 sky130_fd_sc_hd__o2111a_1
XFILLER_0_58_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c351_A0 net138 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc392 net150 clknet_1_0__leaf_net306 net309 clknet_1_1__leaf_net291 net749 net793
+ VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_48_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c448_A_N net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge891 clknet_4_11_0_clk net417 net714 VGND VGND VPWR VPWR net759 net758 sky130_fd_sc_hd__dfsbp_1
Xmerge880 clknet_4_1_0_clk net675 net678 VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__sdlclkp_1
XANTENNA_c526_A0 net49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_3_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c102_A net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c717_C1 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c497_S0 net396 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input45_A in49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c235_SCD net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge875_Q net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c346_A0 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c157_B net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c317_A net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout118_X net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_58_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net389 clknet_0_net389 VGND VGND VPWR VPWR clknet_1_1__leaf_net389
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c567_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c357_C1 clknet_1_1__leaf_net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap134 net30 VGND VGND VPWR VPWR net957 sky130_fd_sc_hd__buf_4
XFILLER_0_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge819_A2 net339 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c222_X net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c494_S1 net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c152_A2 net847 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_4_11_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c327_A2 net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c624_A0 net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output76_A clknet_1_1__leaf_net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net142 clknet_0_net142 VGND VGND VPWR VPWR clknet_1_1__leaf_net142
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net153 clknet_0_net153 VGND VGND VPWR VPWR clknet_1_1__leaf_net153
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net924 clknet_0_net924 VGND VGND VPWR VPWR clknet_1_0__leaf_net924
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_81_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_61_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c700_A2 net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c551_A net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c709_A0 net562 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net365 net365 VGND VGND VPWR VPWR clknet_0_net365 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net387 net387 VGND VGND VPWR VPWR clknet_0_net387 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc722 net601 net597 clknet_1_1__leaf_net599 clknet_1_1__leaf_net598 net816 net821
+ VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__mux4_4
Xc711 net558 net962 clknet_1_1__leaf_net365 net948 clknet_1_1__leaf_net814 net815
+ VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__mux4_2
Xc700 net573 clknet_1_1__leaf_net575 net965 net580 net783 clknet_1_1__leaf_net813
+ VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c444_B1 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc744 net620 net556 net235 net769 net803 net971 VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__mux4_4
Xc733 net556 clknet_1_0__leaf_net940 net934 net906 clknet_1_1__leaf_net812 net817
+ VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__mux4_4
Xc755 net631 clknet_1_0__leaf_net584 net952 net350 net634 net778 VGND VGND VPWR VPWR
+ net636 sky130_fd_sc_hd__mux4_2
XFILLER_0_31_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc766 net386 net639 net634 clknet_1_0__leaf_net584 net971 net895 VGND VGND VPWR VPWR
+ net647 sky130_fd_sc_hd__mux4_2
XANTENNA_c157_C_N net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_98_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c504_A3 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c148_C_N net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c729_SET_B net396 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net776 clknet_0_net776 VGND VGND VPWR VPWR clknet_1_0__leaf_net776
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c545_C1 net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire2 net509 VGND VGND VPWR VPWR net1005 sky130_fd_sc_hd__clkbuf_1
Xc501_6 clknet_1_0__leaf_net748 VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__clkinv_2
XANTENNA_c711_A1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c439_A0 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net140 net140 VGND VGND VPWR VPWR clknet_0_net140 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c174_A0 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc530 net338 net200 VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__and2_1
XANTENNA_c605_A2 net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc552 net448 net943 net344 VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__nand3_4
Xc541 net330 net976 net950 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__nor3b_1
XANTENNA_c580_Q net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc563 clknet_1_1__leaf_net460 clknet_1_1__leaf_net452 net455 net459 net684 net774
+ VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__mux4_4
XFILLER_0_47_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc574 net337 net464 net383 net204 net798 VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__o2111a_1
Xc596 net473 net123 net511 clknet_1_0__leaf_net517 net911 VGND VGND VPWR VPWR net499
+ sky130_fd_sc_hd__o2111ai_1
Xc585 net453 net339 net479 clknet_1_0__leaf_net472 net775 VGND VGND VPWR VPWR net487
+ sky130_fd_sc_hd__a2111oi_2
XANTENNA_c621_A1 net519 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput103 net926 VGND VGND VPWR VPWR out5 sky130_fd_sc_hd__clkbuf_4
Xoutput114 clknet_1_1__leaf_net937 VGND VGND VPWR VPWR out61 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c592_S1 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c541_C_N net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net595 clknet_0_net595 VGND VGND VPWR VPWR clknet_1_0__leaf_net595
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net584 clknet_0_net584 VGND VGND VPWR VPWR clknet_1_0__leaf_net584
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_12_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c706_A1 net543 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c767_S1 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c425_A2 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c441_A1 net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_21_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_30_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput27 in32 VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_12_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput16 in22 VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__buf_1
XFILLER_0_37_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge901_GATE_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput49 in52 VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__clkbuf_1
Xinput38 in42 VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__buf_1
XANTENNA_c616_A1 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c693_S0 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc382 net844 net299 net875 clknet_1_0__leaf_net182 net749 VGND VGND VPWR VPWR net305
+ sky130_fd_sc_hd__a2111oi_2
Xc371 clknet_1_1__leaf_net153 clknet_1_0__leaf_net291 net154 clknet_1_0__leaf_net289
+ clknet_1_1__leaf_net292 c371/S1 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__mux4_4
Xc360 net750 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__inv_2
XANTENNA_c632_A0 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc393 net55 clknet_1_1__leaf_net306 net308 clknet_1_1__leaf_net182 net889 net793 VGND
+ VGND VPWR VPWR net316 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_48_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge870 net588 net623 VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__nor2b_1
XFILLER_0_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge881 clknet_4_9_0_clk net690 net274 VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__sdlclkp_2
XFILLER_0_55_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge892 clknet_4_12_0_clk net401 net369 VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__dfstp_2
XFILLER_0_82_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c602_A3 net754 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input38_A in42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net516 clknet_0_net516 VGND VGND VPWR VPWR clknet_1_1__leaf_net516
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net527 clknet_0_net527 VGND VGND VPWR VPWR clknet_1_1__leaf_net527
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c627_A0 net163 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c362_A0 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc190 net115 net116 net850 net742 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__or4bb_1
XFILLER_0_20_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c429_D net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_467 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net776_A clknet_0_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c317_B net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_S0 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclone1 net64 net824 VGND VGND VPWR VPWR net1006 sky130_fd_sc_hd__nor2b_1
XFILLER_0_39_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_72_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net302 clknet_0_net302 VGND VGND VPWR VPWR clknet_1_1__leaf_net302
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net379 clknet_0_net379 VGND VGND VPWR VPWR clknet_1_1__leaf_net379
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_58_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c357_B1 net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c162_A net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c267_B net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c434_B net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c714_A1 net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c730_A0 net571 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_55_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_4_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c429_SCE net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c376_SET_B clknet_1_1__leaf_net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output69_A net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c237_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net143 clknet_0_net143 VGND VGND VPWR VPWR clknet_1_1__leaf_net143
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c368_C1 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c551_B net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_77_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c165_X net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c428_A2 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net366 net366 VGND VGND VPWR VPWR clknet_0_net366 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net399 net399 VGND VGND VPWR VPWR clknet_0_net399 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c725_A0 net543 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc712 net592 net966 net568 clknet_1_1__leaf_net365 clknet_1_1__leaf_net814 net815
+ VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__mux4_4
XPHY_EDGE_ROW_86_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc701 net580 clknet_1_0__leaf_net564 net573 net968 net568 clknet_1_0__leaf_net813
+ VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__mux4_2
Xc723 clknet_1_0__leaf_net595 clknet_1_0__leaf_net599 net493 net481 net767 net819
+ VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__mux4_1
Xc745 net259 net329 net620 clknet_1_1__leaf_net407 net926 net823 VGND VGND VPWR VPWR
+ net626 sky130_fd_sc_hd__mux4_1
Xc756 net82 net634 net774 net778 net782 net971 VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__mux4_1
Xc734 clknet_1_1__leaf_net517 net840 clknet_1_0__leaf_net940 net892 net818 VGND VGND
+ VPWR VPWR net615 sky130_fd_sc_hd__o2111a_2
Xc767 clknet_1_0__leaf_net643 net887 net781 net782 net792 net895 VGND VGND VPWR VPWR
+ net648 sky130_fd_sc_hd__mux4_2
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input20_A in26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output107_A net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c619_A1 net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c379_D1 clknet_1_0__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net777 clknet_0_net777 VGND VGND VPWR VPWR clknet_1_0__leaf_net777
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c248_A2 clknet_1_0__leaf_net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c132_B net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c545_B1 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc501_7 clknet_1_0__leaf_net748 VGND VGND VPWR VPWR net981 sky130_fd_sc_hd__clkinv_2
XANTENNA_c711_A2 clknet_1_1__leaf_net365 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net152 net152 VGND VGND VPWR VPWR clknet_0_net152 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc531 net82 net334 net771 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__nor3b_1
Xc542 net761 VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__buf_6
Xc564 net459 net900 net448 VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__or3b_2
Xc553 net357 net943 clknet_1_0__leaf_net363 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__or3b_1
Xc597 net123 net952 net945 net683 net762 net764 VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__mux4_1
XANTENNA_c471_C1 net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc575 net467 net907 net952 net473 net800 VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__o2111ai_4
Xc586 net346 net482 net756 net775 VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__or4bb_1
XFILLER_0_47_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c573_Q net473 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c621_A2 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input23_X net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput115 net938 VGND VGND VPWR VPWR out7 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_70_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput104 net927 VGND VGND VPWR VPWR out50 sky130_fd_sc_hd__buf_2
XFILLER_0_2_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c381_C1 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net552 clknet_0_net552 VGND VGND VPWR VPWR clknet_1_0__leaf_net552
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net563 clknet_0_net563 VGND VGND VPWR VPWR clknet_1_0__leaf_net563
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_33_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c706_A2 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c425_A3 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c572_D1 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c304_S0 net436 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput17 in23 VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__buf_4
XFILLER_0_91_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput28 in33 VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_40_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput39 in43 VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__buf_4
XFILLER_0_52_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c616_A2 net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c690_Q net571 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge893_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc350 net256 net960 net862 net269 clknet_1_0__leaf_net777 VGND VGND VPWR VPWR net276
+ sky130_fd_sc_hd__o2111a_2
Xc361 net283 net873 net960 net833 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__or4bb_1
Xc372 net293 clknet_1_0__leaf_net291 clknet_1_1__leaf_net289 clknet_1_0__leaf_net290
+ clknet_1_0__leaf_net899 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__o2111a_1
XANTENNA_c632_A1 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc383 net47 net925 clknet_1_0__leaf_net920 net835 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__or4bb_1
Xc394 net970 clknet_1_0__leaf_net306 clknet_1_0__leaf_net939 net740 net753 net793
+ VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__mux4_4
XANTENNA_c351_A2 net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_0__f_net776_A clknet_0_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge871 net731 clknet_4_13_0_clk net687 VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__dlrtn_1
Xmerge860 net250 net255 VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__or2b_4
Xmerge882 clknet_4_11_0_clk net702 net669 VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__sdlclkp_4
Xmerge893 clknet_4_12_0_clk net507 net707 VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__dfstp_2
XFILLER_0_28_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c526_A2 net869 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge884_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c400_D_N net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net382 clknet_0_net382 VGND VGND VPWR VPWR clknet_1_0__leaf_net382
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net371 clknet_0_net371 VGND VGND VPWR VPWR clknet_1_0__leaf_net371
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c412_X net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c733_A0 net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c202_C_N net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net517 clknet_0_net517 VGND VGND VPWR VPWR clknet_1_1__leaf_net517
+ sky130_fd_sc_hd__clkbuf_16
Xfanout150 net93 VGND VGND VPWR VPWR net973 sky130_fd_sc_hd__buf_4
XFILLER_0_44_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c627_A1 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c346_A2 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output99_A net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c362_A1 net138 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc180 net105 net106 net689 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__and3_1
Xc191 net97 net115 net969 net105 net108 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__o2111a_2
XFILLER_0_85_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c501_4_A clknet_1_1__leaf_net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c598_S1 net754 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c212_B net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c403_Q_N net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c688_D_N net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone2 net343 net65 net967 VGND VGND VPWR VPWR net1007 sky130_fd_sc_hd__or3_1
XFILLER_0_78_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c65_A1 net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c201_14_A clknet_1_1__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input50_A in53 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c373_A0 net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c162_B net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c427_B net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c322_A net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout123_X net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c208_X net138 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net939_X clknet_1_1__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c714_A2 net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c739_C1 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c266_A_N net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c455_B_N net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c458_B1 net850 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c70_Y net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input53_X net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net904 clknet_0_net904 VGND VGND VPWR VPWR clknet_1_0__leaf_net904
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net937 clknet_0_net937 VGND VGND VPWR VPWR clknet_1_0__leaf_net937
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c368_B1 net138 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c709_A2 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_101_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net389 net389 VGND VGND VPWR VPWR clknet_0_net389 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c725_A1 net483 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc713 net845 net546 net562 net569 net770 net820 VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__mux4_1
Xc702 net582 net562 net451 net580 clknet_1_0__leaf_net813 clknet_1_0__leaf_net814
+ VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__mux4_2
XFILLER_0_31_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c444_A2 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc724 net586 clknet_1_1__leaf_net595 clknet_1_1__leaf_net599 clknet_1_0__leaf_net812
+ net815 net819 VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__mux4_2
Xc746 net556 net483 net619 net926 net770 net823 VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__mux4_1
Xc735 clknet_1_1__leaf_net407 net613 net840 clknet_1_1__leaf_net517 clknet_1_0__leaf_net940
+ net906 VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__mux4_4
XANTENNA_c741_A0 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc757 net987 clknet_1_1__leaf_net940 net875 net888 net971 net823 VGND VGND VPWR VPWR
+ net638 sky130_fd_sc_hd__mux4_4
Xc768 net641 net640 net936 net781 net971 net895 VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__mux4_4
XANTENNA_c460_A1 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input13_A in2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c217_S0 net138 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_66_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c379_C1 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c93_D_N net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc501_8 clknet_1_0__leaf_net748 VGND VGND VPWR VPWR net982 sky130_fd_sc_hd__clkinv_2
XANTENNA_c711_A3 net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c661_B net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input5_A in12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c282_Y net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c439_A2 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c736_B1 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net142 net142 VGND VGND VPWR VPWR clknet_0_net142 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net153 net153 VGND VGND VPWR VPWR clknet_0_net153 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c174_A2 net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc554 net765 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__clkbuf_2
Xc532 net325 net330 VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__nand2_1
Xc543 net746 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__dlymetal6s2s_1
Xc576 net455 net454 net343 net966 net751 net887 VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__mux4_1
Xc598 clknet_1_1__leaf_net373 net488 clknet_1_0__leaf_net516 net328 net973 net754
+ VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__mux4_2
Xc565 net344 net357 net782 VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__nand3b_2
Xc587 net488 net480 net204 net123 net467 VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__o2111ai_2
XFILLER_0_99_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c349_A2 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput105 net928 VGND VGND VPWR VPWR out51 sky130_fd_sc_hd__buf_2
Xoutput116 clknet_1_0__leaf_net939 VGND VGND VPWR VPWR out8 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net575 clknet_0_net575 VGND VGND VPWR VPWR clknet_1_0__leaf_net575
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net564 clknet_0_net564 VGND VGND VPWR VPWR clknet_1_0__leaf_net564
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c242_B net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout150_A net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_net899_A net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c706_A3 net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input8_X net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c304_S1 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput18 in24 VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_40_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput29 in34 VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c616_A3 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc362 net877 net138 net69 clknet_1_1__leaf_net921 clknet_1_1__leaf_net933 clknet_1_0__leaf_net939
+ VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__mux4_2
Xc340 clknet_1_0__leaf_net146 net260 net262 net969 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__or4bb_4
Xc351 net138 clknet_1_1__leaf_net146 net102 net269 net106 clknet_1_0__leaf_net777
+ VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__mux4_1
Xc373 net102 clknet_1_0__leaf_net290 clknet_1_0__leaf_net292 net900 net950 net902
+ VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__mux4_2
XANTENNA_c632_A2 net850 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc384 net826 clknet_1_1__leaf_net302 net297 clknet_1_0__leaf_net939 net45 net299 VGND
+ VGND VPWR VPWR net307 sky130_fd_sc_hd__mux4_2
Xc395 clknet_1_0__leaf_net910 net297 net753 net754 net758 net793 VGND VGND VPWR VPWR
+ net318 sky130_fd_sc_hd__mux4_2
XFILLER_0_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge872 net600 net606 VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__nor2_2
XFILLER_0_7_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_416 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge850 net189 net317 VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__nor2b_2
Xmerge861 net708 clknet_4_11_0_clk net671 VGND VGND VPWR VPWR net728 net727 sky130_fd_sc_hd__dlrbp_1
XFILLER_0_55_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge894 clknet_4_4_0_clk net679 net680 VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__dfstp_1
Xmerge883 clknet_4_11_0_clk net662 net691 VGND VGND VPWR VPWR net750 net749 sky130_fd_sc_hd__dfrbp_1
XFILLER_0_43_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c526_A3 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge807_S0 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net394 clknet_0_net394 VGND VGND VPWR VPWR clknet_1_0__leaf_net394
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net372 clknet_0_net372 VGND VGND VPWR VPWR clknet_1_0__leaf_net372
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c717_A2 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_rebuffer3_A net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge851_B net666 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge898_GATE clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c477_C1 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c93_X net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c627_A2 net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc181 net82 net109 net689 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__or3_1
XFILLER_0_20_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c362_A2 net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc170 net98 net99 net86 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__and3_1
Xc192 net113 net107 net108 net742 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__or4bb_1
XFILLER_0_18_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_34_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net939_X clknet_1_0__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclone3 net67 net825 VGND VGND VPWR VPWR net1008 sky130_fd_sc_hd__or2b_1
XFILLER_0_39_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c728_A1 clknet_1_1__leaf_net365 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c187_C_N net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input43_A in47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c613_SCD net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c699_S1 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c357_A2 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap126 net113 VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_20_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c155_B net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c427_C net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net527 net527 VGND VGND VPWR VPWR clknet_0_net527 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c322_B net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net516 net516 VGND VGND VPWR VPWR clknet_0_net516 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c315_A net762 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c684_A net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c169_C_N net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c730_A2 clknet_1_1__leaf_net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c341_C_N net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c739_B1 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c458_A1 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c474_B1 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input46_X net869 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net145 clknet_0_net145 VGND VGND VPWR VPWR clknet_1_1__leaf_net145
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net156 clknet_0_net156 VGND VGND VPWR VPWR clknet_1_1__leaf_net156
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net905 clknet_0_net905 VGND VGND VPWR VPWR clknet_1_0__leaf_net905
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_97_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c384_A0 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c559_B1 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c709_A3 net328 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net302 net302 VGND VGND VPWR VPWR clknet_0_net302 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c575_C1 net473 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net379 net379 VGND VGND VPWR VPWR clknet_0_net379 sky130_fd_sc_hd__clkbuf_16
XANTENNA_s925_Q net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c62_A3 net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc703 net580 clknet_1_1__leaf_net564 net766 net999 net779 net783 VGND VGND VPWR VPWR
+ net584 sky130_fd_sc_hd__mux4_1
XFILLER_0_31_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc725 net543 net483 clknet_1_0__leaf_net599 net767 net819 net821 VGND VGND VPWR VPWR
+ net606 sky130_fd_sc_hd__mux4_1
Xc747 net235 net769 net784 net817 net823 VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__o2111a_1
Xc714 net542 net965 net492 net801 clknet_1_0__leaf_net814 VGND VGND VPWR VPWR net595
+ sky130_fd_sc_hd__a2111oi_4
Xc736 net571 clknet_1_0__leaf_net940 net783 net786 net818 VGND VGND VPWR VPWR net617
+ sky130_fd_sc_hd__a2111oi_1
XANTENNA_c741_A1 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc769 net642 net649 net768 net781 net811 net895 VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__mux4_1
Xc758 net634 net755 net796 net811 net971 net823 VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_4_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_531 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge911_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c635_A2 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_78_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output74_A net897 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_66_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c379_B1 clknet_1_0__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_0_clk_X clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c118_B net49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net365_X clknet_1_1__leaf_net365 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_0__f_net921_X clknet_1_0__leaf_net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c599_D net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc501_9 clknet_1_0__leaf_net748 VGND VGND VPWR VPWR net983 sky130_fd_sc_hd__clkinv_2
XFILLER_0_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c166_A_N net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c439_A3 net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c736_A1 net571 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net143 net143 VGND VGND VPWR VPWR clknet_0_net143 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_64_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c174_A3 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc500 net436 net771 VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_9_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc533 net325 net943 net771 VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__or3b_1
Xc555 net765 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__clkinv_4
Xc544 net685 VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__inv_2
Xc566 net720 VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__buf_1
Xc577 net343 net476 clknet_1_0__leaf_net440 net72 net797 VGND VGND VPWR VPWR net477
+ sky130_fd_sc_hd__o2111ai_1
Xc588 clknet_1_1__leaf_net477 clknet_1_0__leaf_net472 net941 clknet_1_1__leaf_net373
+ net913 net775 VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__mux4_4
Xc599 clknet_4_12_0_clk net941 net514 net511 clknet_1_0__leaf_net407 net803 VGND VGND
+ VPWR VPWR net503 net502 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_99_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output112_A net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_71_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput106 net929 VGND VGND VPWR VPWR out53 sky130_fd_sc_hd__buf_2
Xoutput117 clknet_1_1__leaf_net940 VGND VGND VPWR VPWR out9 sky130_fd_sc_hd__clkbuf_1
XANTENNA_s927_GATE clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c381_A1 net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge812_S1 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c242_C net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net598 clknet_0_net598 VGND VGND VPWR VPWR clknet_1_0__leaf_net598
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout143_A net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c402_B net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c500_B_N net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c747_B1 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c90_B net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput19 in25 VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_40_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc330 net232 net252 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__nand2_1
XFILLER_0_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc341 net265 net259 net960 net763 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__or4bb_1
Xc363 net138 net271 clknet_1_0__leaf_net933 net43 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__or4bb_2
Xc352 net750 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__inv_1
XANTENNA_c632_A3 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc374 net970 net932 net42 net47 net693 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__o2111a_1
Xc385 clknet_4_11_0_clk net300 net908 clknet_1_0__leaf_net939 clknet_1_1__leaf_net747
+ clknet_1_1__leaf_net777 VGND VGND VPWR VPWR net309 net308 sky130_fd_sc_hd__sdfbbn_2
Xc396 net203 net948 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__nand2b_2
XFILLER_0_99_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge840 clknet_4_8_0_clk net659 net665 VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__dfstp_2
Xmerge851 net187 net666 VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__and2b_1
Xmerge873 net655 clknet_4_10_0_clk net716 VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__dlrtp_1
Xmerge862 net311 net713 VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__nor2b_1
XFILLER_0_28_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge895 net726 clknet_4_9_0_clk net730 VGND VGND VPWR VPWR net763 net762 sky130_fd_sc_hd__dlrbn_2
Xmerge884 clknet_4_0_0_clk net323 net385 VGND VGND VPWR VPWR net752 net751 sky130_fd_sc_hd__dfrbp_1
XFILLER_0_55_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c392_A0 net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c558_B_N net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge807_S1 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c729_D net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net373 clknet_0_net373 VGND VGND VPWR VPWR clknet_1_0__leaf_net373
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_80_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net395 clknet_0_net395 VGND VGND VPWR VPWR clknet_1_0__leaf_net395
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout146_X net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c300_X net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c583_C1 net473 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c733_A2 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c477_B1 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c196_A1 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc160 net80 net855 net859 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__nor3b_2
XFILLER_0_20_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc171 net858 net96 net98 VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__and3b_2
XFILLER_0_85_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc182 net882 net82 net87 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__nand3b_1
XFILLER_0_20_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc193 clknet_4_2_0_clk net121 net109 net75 net969 VGND VGND VPWR VPWR net123 net122
+ sky130_fd_sc_hd__sdfrbp_2
XFILLER_0_18_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c387_B1 net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c100_B net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge857_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c65_A3 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c744_A1 net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c760_A0 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c613_SCE net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input36_A in40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c505_A_N net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge905_Q_N net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net894 clknet_0_net894 VGND VGND VPWR VPWR clknet_1_1__leaf_net894
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c155_C net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net517 net517 VGND VGND VPWR VPWR clknet_0_net517 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c103_Y net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c479_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c677_A net192 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c739_A1 net546 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c403_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c294_D_N net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_30_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input39_X net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net135 clknet_0_net135 VGND VGND VPWR VPWR clknet_1_1__leaf_net135
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net146 clknet_0_net146 VGND VGND VPWR VPWR clknet_1_1__leaf_net146
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net179 clknet_0_net179 VGND VGND VPWR VPWR clknet_1_1__leaf_net179
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net917 clknet_0_net917 VGND VGND VPWR VPWR clknet_1_0__leaf_net917
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net939 clknet_0_net939 VGND VGND VPWR VPWR clknet_1_0__leaf_net939
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c368_A2 net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c503_S1 net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c301_23_A clknet_1_0__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c591_RESET_B net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c160_A net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_46_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c575_B1 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c213_X net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc704 net541 net845 clknet_1_1__leaf_net584 net556 net948 VGND VGND VPWR VPWR net585
+ sky130_fd_sc_hd__a2111o_4
XFILLER_0_71_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc726 net483 clknet_1_1__leaf_net584 net952 net556 net818 VGND VGND VPWR VPWR net607
+ sky130_fd_sc_hd__o2111ai_4
Xc715 clknet_1_0__leaf_net595 net481 net936 net801 net820 net821 VGND VGND VPWR VPWR
+ net596 sky130_fd_sc_hd__mux4_4
Xc737 net556 net617 net571 clknet_1_0__leaf_net940 net518 clknet_1_1__leaf_net812
+ VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__mux4_1
XFILLER_0_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c741_A2 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc759 net637 net540 net952 net634 net810 net811 VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__mux4_2
XANTENNA_merge903_GATE clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc748 net1009 net898 clknet_1_1__leaf_net939 net796 net808 net971 VGND VGND VPWR VPWR
+ net629 sky130_fd_sc_hd__mux4_1
XANTENNA_c582_X net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_55_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c604_S0 net760 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_80_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c635_A3 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c370_A3 net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c379_A1 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net747 clknet_0_net747 VGND VGND VPWR VPWR clknet_1_0__leaf_net747
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_91_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c163_X net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net894_X clknet_1_1__leaf_net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c480_C_N net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc534 net685 VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__inv_2
Xc545 net975 clknet_1_1__leaf_net442 net941 net82 net943 VGND VGND VPWR VPWR net444
+ sky130_fd_sc_hd__o2111a_2
Xc578 clknet_1_1__leaf_net440 net968 net473 net751 VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__or4bb_1
Xc589 net334 net475 net489 net467 net799 VGND VGND VPWR VPWR net892 sky130_fd_sc_hd__o2111a_4
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc556 net829 net201 net454 VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__nand3b_4
Xc567 clknet_4_1_0_clk net457 net459 net455 net941 net782 VGND VGND VPWR VPWR net467
+ net466 sky130_fd_sc_hd__sdfbbp_1
XTAP_TAPCELL_ROW_63_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput107 net930 VGND VGND VPWR VPWR out54 sky130_fd_sc_hd__buf_2
XFILLER_0_23_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c381_A2 clknet_1_0__leaf_net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge820_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net599 clknet_0_net599 VGND VGND VPWR VPWR clknet_1_0__leaf_net599
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c228_B net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c747_A1 net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c601_S1 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge878_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc320 net240 net242 net239 net84 net951 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__o2111ai_1
XTAP_TAPCELL_ROW_75_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc331 net732 net787 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__nand2b_1
XANTENNA_c329_S0 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc342 net84 net267 net263 net261 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__or4bb_2
Xc353 clknet_1_0__leaf_net276 net850 net869 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__and3_2
Xc375 clknet_1_0__leaf_net182 clknet_1_0__leaf_net894 net970 net694 clknet_1_0__leaf_net776
+ VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__o2111ai_4
Xc364 net149 clknet_1_0__leaf_net286 clknet_1_1__leaf_net276 clknet_1_0__leaf_net933
+ net43 clknet_1_0__leaf_net777 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__mux4_2
Xc386 clknet_1_1__leaf_net306 net948 clknet_1_1__leaf_net921 clknet_1_1__leaf_net899
+ net308 net733 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__mux4_4
Xc397 net338 net900 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__or2_1
XFILLER_0_74_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input21_X net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_13_0_clk_X clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c692_C_N net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge830 net677 net127 VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__nand2_1
Xmerge841 clknet_4_4_0_clk net654 net674 VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__dfstp_1
Xmerge852 net305 net315 VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__nand2_1
XFILLER_0_28_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge863 net670 net521 VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__nor2b_4
XFILLER_0_99_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge874 net658 clknet_4_8_0_clk net697 VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__dlrtp_4
XFILLER_0_43_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge885 clknet_4_14_0_clk net420 net316 VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__dfrtn_1
Xmerge896 net657 clknet_4_3_0_clk net520 VGND VGND VPWR VPWR net765 net764 sky130_fd_sc_hd__dlrbn_1
XFILLER_0_82_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c239_S0 net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c683_C_N net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net363 clknet_0_net363 VGND VGND VPWR VPWR clknet_1_0__leaf_net363
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c338_A net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout139_X net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c583_B1 net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c733_A3 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout120 net430 VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c662_X net543 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout142 net441 VGND VGND VPWR VPWR net965 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_96_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c196_A2 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc172 net92 net100 net85 net88 net852 net857 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__mux4_2
Xc161 net855 net68 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__or2_1
Xc150 net227 net869 net76 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__or3_2
XFILLER_0_85_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc194 net110 net877 net879 net876 net108 net742 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__mux4_1
Xc183 net848 net873 net110 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__and3_1
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c288_A net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c462_B net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net160 clknet_0_net160 VGND VGND VPWR VPWR clknet_1_0__leaf_net160
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c728_A3 clknet_1_1__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net182 clknet_0_net182 VGND VGND VPWR VPWR clknet_1_0__leaf_net182
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c744_A2 net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net306 clknet_0_net306 VGND VGND VPWR VPWR clknet_1_1__leaf_net306
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_input29_A in34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge791_A2 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c373_A3 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_1_0_clk_X clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c474_A2 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net136 clknet_0_net136 VGND VGND VPWR VPWR clknet_1_1__leaf_net136
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net169 clknet_0_net169 VGND VGND VPWR VPWR clknet_1_1__leaf_net169
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net894_X clknet_1_0__leaf_net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c153_A net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_101_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c710_S0 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c418_A net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc705 net844 net962 net204 clknet_1_0__leaf_net563 net922 clknet_1_1__leaf_net814
+ VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__mux4_1
Xc738 clknet_4_7_0_clk net614 net612 clknet_1_1__leaf_net517 net968 net785 VGND VGND
+ VPWR VPWR net890 net619 sky130_fd_sc_hd__sdfbbp_1
Xc716 net542 net596 net541 net840 clknet_1_0__leaf_net595 net819 VGND VGND VPWR VPWR
+ net597 sky130_fd_sc_hd__mux4_4
Xc727 net514 net259 net326 net803 net817 VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__o2111ai_1
XFILLER_0_31_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc749 net627 net888 net886 net810 net811 net822 VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__mux4_4
XANTENNA_c741_A3 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c766_A0 net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c620_S0 net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c379_A2 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net748 clknet_0_net748 VGND VGND VPWR VPWR clknet_1_0__leaf_net748
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c705_S0 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer10 net773 VGND VGND VPWR VPWR net1003 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_1_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s930_Q net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net156 net156 VGND VGND VPWR VPWR clknet_0_net156 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net145 net145 VGND VGND VPWR VPWR clknet_0_net145 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c752_A2 clknet_1_1__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc502 net2 net931 net421 net923 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__or4bb_4
XTAP_TAPCELL_ROW_9_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc535 net746 VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__clkbuf_8
Xc546 net443 clknet_1_0__leaf_net442 VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__nor2_2
Xc557 clknet_1_0__leaf_net452 net450 net943 clknet_1_0__leaf_net363 clknet_1_1__leaf_net794
+ VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__a2111o_4
Xc568 net358 net464 net319 net944 net941 net684 VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__mux4_1
Xc579 clknet_4_3_0_clk net476 net475 clknet_1_0__leaf_net371 clknet_1_1__leaf_net372
+ net473 VGND VGND VPWR VPWR net480 net479 sky130_fd_sc_hd__sdfbbn_2
XANTENNA_c185_D_N net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c615_S0 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input11_A in18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput108 net931 VGND VGND VPWR VPWR out55 sky130_fd_sc_hd__buf_2
XFILLER_0_50_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput90 net913 VGND VGND VPWR VPWR out37 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_93_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c123_B net49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c116_A net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout129_A net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c572_A2 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input3_A in10 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c404_SCD net339 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c83_C net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c763_A1 clknet_1_1__leaf_net584 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c69_A net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc321 net241 net876 net732 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__and3_1
Xc310 net836 net945 net948 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__or3b_2
XTAP_TAPCELL_ROW_75_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input59_A in61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc332 net257 net84 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__nor2_1
Xc343 clknet_4_9_0_clk net248 net133 net262 net268 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__sdfrtp_2
Xc354 net271 net278 net950 net960 VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__or4bb_1
Xc365 net37 net960 net928 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__or3b_1
Xc376 clknet_4_10_0_clk clknet_1_1__leaf_net291 net173 clknet_1_1__leaf_net933 net47
+ clknet_1_1__leaf_net894 VGND VGND VPWR VPWR net300 net299 sky130_fd_sc_hd__sdfbbp_1
Xc387 net309 clknet_1_1__leaf_net182 net128 clknet_1_1__leaf_net777 net793 VGND VGND
+ VPWR VPWR net311 sky130_fd_sc_hd__a2111oi_4
Xc398 net686 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_48_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge794_A2 net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge820 clknet_4_2_0_clk net380 net660 VGND VGND VPWR VPWR net682 net681 sky130_fd_sc_hd__dfrbp_1
Xmerge864 net626 net624 VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__or2b_1
Xmerge831 clknet_4_10_0_clk net62 net61 VGND VGND VPWR VPWR net694 net693 sky130_fd_sc_hd__dfsbp_2
Xmerge853 clknet_4_0_0_clk net664 net676 VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__dfstp_4
Xmerge842 net362 net360 VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__nand2b_1
XFILLER_0_99_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge897 net744 clknet_4_5_0_clk net688 VGND VGND VPWR VPWR net767 net766 sky130_fd_sc_hd__dlrbp_1
XFILLER_0_82_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge875 net185 clknet_4_10_0_clk net698 VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__dlrtp_2
XFILLER_0_28_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge886 clknet_4_9_0_clk net703 net314 VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_43_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer1 net78 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c239_S1 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c338_B net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout143 net350 VGND VGND VPWR VPWR net966 sky130_fd_sc_hd__buf_4
XANTENNA_input6_X net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c477_A2 net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c196_A3 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc162 net831 net83 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__nand2_1
Xc151 net76 net81 net63 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__nand3_4
Xc140 net69 net68 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__and2_4
Xc184 net107 net108 net105 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__nor3_1
Xc173 net94 net862 net973 net101 net79 net951 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__mux4_2
Xc195 net109 net108 net969 net124 net122 net743 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__mux4_1
XFILLER_0_87_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c164_B_N net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c183_A net848 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c713_S0 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c98_A_N net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net161 clknet_0_net161 VGND VGND VPWR VPWR clknet_1_0__leaf_net161
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_83_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c755_A2 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c618_S0 net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input41_A in45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net148 clknet_0_net148 VGND VGND VPWR VPWR clknet_1_1__leaf_net148
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_97_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge914_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge871_Q net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c384_A3 clknet_1_0__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c153_B net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s923_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c575_A2 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_60_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc728 net569 clknet_1_1__leaf_net365 clknet_1_1__leaf_net399 clknet_1_1__leaf_net794
+ net802 net818 VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__mux4_1
Xc717 clknet_1_0__leaf_net595 net72 net568 net947 net820 VGND VGND VPWR VPWR net598
+ sky130_fd_sc_hd__o2111a_2
Xc706 net549 net543 net72 net383 net542 clknet_1_0__leaf_net812 VGND VGND VPWR VPWR
+ net587 sky130_fd_sc_hd__mux4_4
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc739 net546 net890 net945 net906 net817 VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__o2111ai_4
XANTENNA_c682_A net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c173_S0 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net894 net894 VGND VGND VPWR VPWR clknet_0_net894 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_91_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c348_S0 clknet_1_0__leaf_net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input44_X net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c395_A2 net753 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_467 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c270_B net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer11 net69 VGND VGND VPWR VPWR net1009 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c323_A_N net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_65_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c149_X net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net135 net135 VGND VGND VPWR VPWR clknet_0_net135 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net146 net146 VGND VGND VPWR VPWR clknet_0_net146 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net179 net179 VGND VGND VPWR VPWR clknet_0_net179 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_72_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c752_A3 net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc503 net422 net983 net261 net966 clknet_1_1__leaf_net366 net383 VGND VGND VPWR VPWR
+ net423 sky130_fd_sc_hd__mux4_2
Xc536 net427 net943 VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_9_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c107_B1 net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc569 net465 net459 net467 net334 net463 VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__o2111ai_4
Xc558 net331 net344 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__or2b_1
Xc547 net428 net685 VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__and2b_1
XANTENNA_c615_S1 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c230_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput109 net932 VGND VGND VPWR VPWR out56 sky130_fd_sc_hd__buf_2
XFILLER_0_50_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_output72_A net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput80 net903 VGND VGND VPWR VPWR out26 sky130_fd_sc_hd__clkbuf_4
Xoutput91 net914 VGND VGND VPWR VPWR out38 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c224_D1 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c404_SCE net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c597_A0 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge907_GCLK net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c763_A2 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc300 net99 net222 net224 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__or3b_4
Xc311 net852 net222 net120 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__and3b_1
XFILLER_0_32_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc333 net106 net248 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__nor2b_4
Xc322 net833 net846 net222 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__nor3b_2
Xc344 clknet_4_9_0_clk net268 net232 net248 net83 net262 VGND VGND VPWR VPWR net271
+ net270 sky130_fd_sc_hd__sdfbbn_1
Xc355 net262 net15 net741 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__nand3b_1
Xc366 net932 net960 net30 clknet_1_1__leaf_net777 VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__or4bb_4
Xc388 net45 net42 net309 clknet_1_0__leaf_net939 clknet_1_0__leaf_net901 net793 VGND
+ VGND VPWR VPWR net312 sky130_fd_sc_hd__mux4_4
Xc377 clknet_1_1__leaf_net160 net297 net300 clknet_1_1__leaf_net921 VGND VGND VPWR
+ VPWR net301 sky130_fd_sc_hd__or4bb_1
XANTENNA_c626_S0 net753 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc399 net198 net338 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__or2b_2
XTAP_TAPCELL_ROW_48_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output110_A clknet_1_0__leaf_net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge810 net411 net410 net386 clknet_1_1__leaf_net254 net897 net383 VGND VGND VPWR
+ VPWR net671 sky130_fd_sc_hd__mux4_4
Xmerge821 clknet_4_1_0_clk net458 net470 VGND VGND VPWR VPWR net684 net683 sky130_fd_sc_hd__dfrbp_1
XFILLER_0_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge832 net245 net246 VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__nand2_1
Xmerge854 net537 net312 VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__nor2b_4
Xmerge843 net528 net529 VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__or2_4
Xmerge876 clknet_4_2_0_clk net692 net118 VGND VGND VPWR VPWR net743 net742 sky130_fd_sc_hd__edfxbp_1
Xmerge865 net712 clknet_4_9_0_clk net695 VGND VGND VPWR VPWR net733 net732 sky130_fd_sc_hd__dlrbp_1
Xmerge887 clknet_4_14_0_clk net719 net301 VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_99_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge898 net739 clknet_4_13_0_clk net725 VGND VGND VPWR VPWR net769 net768 sky130_fd_sc_hd__dlrbp_1
XTAP_TAPCELL_ROW_11_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer2 net78 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c690_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c698_C1 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net365 clknet_0_net365 VGND VGND VPWR VPWR clknet_1_0__leaf_net365
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net387 clknet_0_net387 VGND VGND VPWR VPWR clknet_1_0__leaf_net387
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_88_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c226_A net869 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c219_D1 clknet_1_0__leaf_net894 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c505_C net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c64_S0 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout122 net235 VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__buf_4
Xfanout144 net968 VGND VGND VPWR VPWR net967 sky130_fd_sc_hd__buf_8
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c758_A2 net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc130 net58 net60 net56 net925 net891 net59 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__mux4_1
Xc152 net63 net80 net847 net74 net76 net82 VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__mux4_2
Xc141 net883 net836 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__and2b_4
Xc163 net860 net844 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__or2b_2
Xc185 net108 net852 net113 net951 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__or4bb_1
Xc174 net68 net101 net102 net85 net846 net86 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__mux4_1
Xc196 net116 net873 net969 net122 net742 net788 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__mux4_2
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c183_B net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net140 clknet_0_net140 VGND VGND VPWR VPWR clknet_1_0__leaf_net140
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout144_X net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge914_Q net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c695_A0 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c708_S1 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c589_A1 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c755_A3 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c618_S1 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input34_A in39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc90 net26 net870 VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__nor2_2
XFILLER_0_97_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c472_Q_N net396 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net306 net306 VGND VGND VPWR VPWR clknet_0_net306 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_32_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc718 net947 net493 net204 clknet_1_0__leaf_net595 net815 net820 VGND VGND VPWR VPWR
+ net599 sky130_fd_sc_hd__mux4_2
Xc707 clknet_1_0__leaf_net563 net569 net568 net892 net328 net801 VGND VGND VPWR VPWR
+ net588 sky130_fd_sc_hd__mux4_4
Xc729 clknet_4_6_0_clk net968 clknet_1_1__leaf_net365 clknet_1_1__leaf_net939 net952
+ net396 VGND VGND VPWR VPWR net611 net610 sky130_fd_sc_hd__sdfbbn_1
XANTENNA_c101_Y net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c682_B net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge841_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_68_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c173_S1 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c99_B net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c348_S1 net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_42_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_89_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c395_A3 net754 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c301_21_A clknet_1_0__leaf_net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_51_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_60_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge823_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_65_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c465_C_N net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c423_A net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net136 net136 VGND VGND VPWR VPWR clknet_0_net136 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net169 net169 VGND VGND VPWR VPWR clknet_0_net169 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc526 net49 clknet_1_0__leaf_net289 net869 net927 net934 net922 VGND VGND VPWR VPWR
+ net914 sky130_fd_sc_hd__mux4_4
Xc504 clknet_1_0__leaf_net286 net842 net990 net923 net422 net982 VGND VGND VPWR VPWR
+ net424 sky130_fd_sc_hd__mux4_2
Xc559 net449 clknet_1_0__leaf_net445 net973 net358 net451 VGND VGND VPWR VPWR net458
+ sky130_fd_sc_hd__o2111ai_4
Xc548 net324 clknet_1_0__leaf_net440 clknet_1_0__leaf_net445 VGND VGND VPWR VPWR net447
+ sky130_fd_sc_hd__nor3_2
XFILLER_0_79_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c496_A2 net896 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput70 net893 VGND VGND VPWR VPWR out16 sky130_fd_sc_hd__clkbuf_1
Xoutput92 net915 VGND VGND VPWR VPWR out39 sky130_fd_sc_hd__buf_2
Xoutput81 clknet_1_1__leaf_net904 VGND VGND VPWR VPWR out28 sky130_fd_sc_hd__clkbuf_1
XANTENNA_output65_A net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c109_B net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c224_C1 net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c485_C clknet_1_1__leaf_net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c597_A1 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c240_D1 net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c426_X net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc312 net111 net1029 net215 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__or3_4
XFILLER_0_32_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc334 net134 net734 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__and2b_1
Xc323 net876 net242 net232 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__nand3b_1
Xc345 net134 net267 net242 clknet_1_0__leaf_net143 net270 net264 VGND VGND VPWR VPWR
+ net939 sky130_fd_sc_hd__mux4_1
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc378 net288 clknet_1_0__leaf_net894 net931 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__nor3_4
Xc356 net120 net870 net102 net262 net280 net960 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__mux4_1
Xc367 net867 net154 clknet_1_0__leaf_net289 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__nand3b_4
Xc389 net309 clknet_1_0__leaf_net933 clknet_1_1__leaf_net160 net878 net793 VGND VGND
+ VPWR VPWR net313 sky130_fd_sc_hd__a2111o_4
XANTENNA_c626_S1 net760 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output103_A net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge811 net463 net459 net464 clknet_1_0__leaf_net570 net216 net226 VGND VGND VPWR
+ VPWR net672 sky130_fd_sc_hd__mux4_1
Xmerge800 net223 net233 net335 net340 VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__or4bb_1
Xmerge855 net591 net648 VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__nand2b_4
XFILLER_0_67_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge822 clknet_4_4_0_clk net444 net656 VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__dfrtn_1
XFILLER_0_23_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge844 net281 net285 VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__nor2_2
Xmerge833 net505 net498 VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__or2_2
Xmerge877 net602 net605 VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__or2_2
Xmerge866 net667 clknet_4_8_0_clk net144 VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__dlrtn_4
Xmerge888 clknet_4_11_0_clk net499 net313 VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__dfrtp_4
Xmerge899 net738 clknet_4_4_0_clk net565 VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__dlrtn_2
XFILLER_0_70_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer3 net227 VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c698_B1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c210_A1 net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net366 clknet_0_net366 VGND VGND VPWR VPWR clknet_1_0__leaf_net366
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_80_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net399 clknet_0_net399 VGND VGND VPWR VPWR clknet_1_0__leaf_net399
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c226_B net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c219_C1 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout145 net345 VGND VGND VPWR VPWR net968 sky130_fd_sc_hd__buf_12
Xfanout123 net217 VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_7_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc120 net891 net21 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__and2_1
XFILLER_0_33_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc131 net57 net59 net51 net925 net55 net58 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc153 net79 net80 net69 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__nor3b_4
Xc142 net70 net71 net834 net72 net65 net824 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__mux4_2
Xc186 net848 net877 net108 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__or3b_1
Xc164 net853 net85 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__nor2b_1
Xc175 net100 net91 net859 net102 net101 c175/S1 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__mux4_1
Xc197 net124 net123 net97 net969 net742 net787 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__mux4_1
XANTENNA_c356_S1 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_16_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c448_C net689 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net152 clknet_0_net152 VGND VGND VPWR VPWR clknet_1_0__leaf_net152
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout137_X net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c501_11_A clknet_1_0__leaf_net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap1 net141 VGND VGND VPWR VPWR net1004 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c581_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_6_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c293_B net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c565_C net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c82_C_N net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input27_A in32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c634_S1 net888 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc91 net835 net18 VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__and2_2
Xc80 net849 net972 net961 VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__nand3b_4
XFILLER_0_85_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output95_A net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c306_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc719 clknet_1_1__leaf_net599 clknet_1_1__leaf_net595 net922 net816 net820 net821
+ VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__mux4_2
Xc708 net965 net569 net558 net556 net801 net802 VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__mux4_1
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c191_X net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c668_A net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c121_D_N net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c470_S0 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_89_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_1 net930 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c179_D_N net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_65_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer13 net191 VGND VGND VPWR VPWR net1028 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_76_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c423_B net65 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net148 net148 VGND VGND VPWR VPWR clknet_0_net148 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c309_Y net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c449_S1 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c107_A2 net37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc527 net912 clknet_1_0__leaf_net924 net966 net936 net889 clknet_1_1__leaf_net795
+ VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__mux4_2
Xc505 net261 clknet_1_0__leaf_net795 net935 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__and3b_1
Xc549 net761 VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__inv_1
Xc538 net761 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c153_C_N net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c342_D_N net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c230_Q net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_14_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput82 clknet_1_1__leaf_net905 VGND VGND VPWR VPWR out29 sky130_fd_sc_hd__clkbuf_1
Xoutput71 clknet_1_0__leaf_net894 VGND VGND VPWR VPWR out17 sky130_fd_sc_hd__clkbuf_1
Xoutput93 net916 VGND VGND VPWR VPWR out4 sky130_fd_sc_hd__buf_2
XFILLER_0_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c366_A net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c597_A2 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc302 net997 net689 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__and2b_4
XTAP_TAPCELL_ROW_75_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc313 net870 net876 net946 net969 net722 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__o2111a_1
Xc335 net134 net788 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__nor2_2
Xc324 net215 net239 net946 net945 net722 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__o2111a_1
XFILLER_0_32_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc379 net42 net862 clknet_1_0__leaf_net939 net844 clknet_1_0__leaf_net776 VGND VGND
+ VPWR VPWR net303 sky130_fd_sc_hd__a2111oi_4
Xc357 net43 net878 net37 clknet_1_1__leaf_net894 net242 VGND VGND VPWR VPWR net933
+ sky130_fd_sc_hd__o2111ai_2
Xc346 net960 net271 net900 net264 clknet_1_0__leaf_net939 clknet_1_0__leaf_net747
+ VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__mux4_1
Xc368 clknet_1_1__leaf_net290 net835 net138 net931 net728 VGND VGND VPWR VPWR net291
+ sky130_fd_sc_hd__o2111a_4
XANTENNA_c195_S0 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge801 net242 clknet_1_0__leaf_net160 net960 net279 net270 VGND VGND VPWR VPWR
+ net662 sky130_fd_sc_hd__o2111a_2
Xmerge812 net942 net216 net995 net376 net370 net907 VGND VGND VPWR VPWR net673 sky130_fd_sc_hd__mux4_4
Xmerge834 net168 net167 VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__nand2b_2
Xmerge845 net663 net673 VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__and2b_1
Xmerge823 clknet_4_0_0_clk net333 net651 VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__dfrtp_2
Xs940 clknet_4_5_0_clk net581 VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_82_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge878 clknet_4_6_0_clk net491 net487 VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__edfxtp_1
Xmerge867 net653 clknet_4_9_0_clk net668 VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__dlrtn_2
Xmerge856 net706 clknet_4_1_0_clk net672 VGND VGND VPWR VPWR net721 net720 sky130_fd_sc_hd__dlrbn_1
Xmerge889 clknet_4_6_0_clk net486 net710 VGND VGND VPWR VPWR net756 net755 sky130_fd_sc_hd__dfsbp_1
XFILLER_0_63_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer4 net436 VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net389 clknet_0_net389 VGND VGND VPWR VPWR clknet_1_0__leaf_net389
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c121_B net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c219_B1 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout127_A net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout146 net970 VGND VGND VPWR VPWR net969 sky130_fd_sc_hd__clkbuf_4
Xfanout135 net909 VGND VGND VPWR VPWR net958 sky130_fd_sc_hd__buf_4
Xfanout124 net217 VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__clkbuf_2
XANTENNA_input1_A in0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c743_S0 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc110 net841 net21 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__nor2_1
XFILLER_0_33_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc121 net972 net873 net52 net870 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__or4bb_1
XFILLER_0_20_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc154 net869 net832 net847 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__nor3b_2
Xc132 net830 net836 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__nand2b_4
Xc143 net68 net63 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__nor2b_2
XANTENNA_c637_S1 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc176 net881 net874 net870 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__nor3b_4
Xc165 net837 net94 net86 net227 net67 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__a2111o_2
Xc187 net109 net111 net862 net689 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__or4bb_2
XANTENNA_input57_A in6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc198 net866 net949 net23 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__nand3_4
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input12_X net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge887_Q net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc301_21 clknet_1_0__leaf_net776 VGND VGND VPWR VPWR net995 sky130_fd_sc_hd__clkinv_1
XFILLER_0_3_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c169_B net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net142 clknet_0_net142 VGND VGND VPWR VPWR clknet_1_0__leaf_net142
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_clkbuf_4_2_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net153 clknet_0_net153 VGND VGND VPWR VPWR clknet_1_0__leaf_net153
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c231_A net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input4_X net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_83_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net899 clknet_0_net899 VGND VGND VPWR VPWR clknet_1_1__leaf_net899
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c181_A net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge908_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c704_D1 net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c499_A3 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc81 net11 net1 net17 net7 net846 net842 VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__mux4_2
Xc92 net859 net28 net972 VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__nor3b_4
Xc70 net5 net972 VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__nand2b_2
XFILLER_0_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s917_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_output88_A net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc709 net562 clknet_1_1__leaf_net563 net840 net328 clknet_1_0__leaf_net812 net816
+ VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__mux4_4
XANTENNA_c735_S1 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c470_S1 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer2_X net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_91_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c565_A_N net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_10_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c328_C1 net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_81_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_2 net951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c556_A_N net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c571_S0 net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net460 clknet_0_net460 VGND VGND VPWR VPWR clknet_1_1__leaf_net460
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_1_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer14 net1028 VGND VGND VPWR VPWR net1029 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge806_A1 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc528 net196 net331 VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__or2b_1
Xc539 net943 net434 VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__and2_1
XANTENNA_c746_S0 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c740_Y net621 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c591_SCD net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput72 net895 VGND VGND VPWR VPWR out18 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput83 net906 VGND VGND VPWR VPWR out3 sky130_fd_sc_hd__clkbuf_4
Xoutput94 clknet_1_1__leaf_net917 VGND VGND VPWR VPWR out40 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c391_S0 net754 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net516 clknet_0_net516 VGND VGND VPWR VPWR clknet_1_0__leaf_net516
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net527 clknet_0_net527 VGND VGND VPWR VPWR clknet_1_0__leaf_net527
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c199_B net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c478_D clknet_1_0__leaf_net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c366_B net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net290 clknet_0_net290 VGND VGND VPWR VPWR clknet_1_1__leaf_net290
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c573_SCD net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc303 net723 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_13_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc336 net109 net133 net259 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__nand3b_2
Xc314 net1022 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__inv_2
XFILLER_0_32_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc325 clknet_4_2_0_clk net244 net239 net964 net241 net743 VGND VGND VPWR VPWR net252
+ net251 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_60_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc358 net258 net280 net262 net2 clknet_1_0__leaf_net153 clknet_1_1__leaf_net933 VGND
+ VGND VPWR VPWR net282 sky130_fd_sc_hd__mux4_4
Xc369 net284 clknet_1_1__leaf_net290 clknet_1_0__leaf_net291 clknet_1_0__leaf_net933
+ net902 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__o2111a_2
Xc347 net264 net271 net269 net964 clknet_1_0__leaf_net939 net259 VGND VGND VPWR VPWR
+ net273 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge802 net214 net833 net942 net842 net851 net216 VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__mux4_1
XFILLER_0_95_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge824 net607 net609 VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__or2_1
Xmerge846 net701 net615 VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__nor2b_1
Xmerge813 clknet_1_1__leaf_net438 net847 net555 net446 clknet_1_0__leaf_net552 VGND
+ VGND VPWR VPWR net674 sky130_fd_sc_hd__a2111o_1
XFILLER_0_67_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge835 net181 net184 VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__or2_1
XFILLER_0_28_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs941 net589 clknet_4_7_0_clk VGND VGND VPWR VPWR net816 net815 sky130_fd_sc_hd__dlxbn_2
XFILLER_0_82_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge879 net604 net736 VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__and2_2
Xmerge868 net635 net636 VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__and2_1
Xs930 net495 clknet_4_6_0_clk VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__dlxtn_4
Xmerge857 net709 clknet_4_2_0_clk net220 VGND VGND VPWR VPWR net723 net722 sky130_fd_sc_hd__dlrbn_1
XFILLER_0_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer5 net773 VGND VGND VPWR VPWR net998 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_11_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c698_A2 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net302 clknet_0_net302 VGND VGND VPWR VPWR clknet_1_0__leaf_net302
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net379 clknet_0_net379 VGND VGND VPWR VPWR clknet_1_0__leaf_net379
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_80_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout125 net896 VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__clkbuf_8
Xfanout147 net117 VGND VGND VPWR VPWR net970 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc100 net29 net958 VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__nand2b_1
Xc111 net828 net835 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__and2_2
XFILLER_0_60_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc122 net52 net891 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__and2_0
Xc133 net63 net883 net884 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__nor3_2
Xc144 net74 net68 net72 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__and3_2
Xc166 net829 net859 net973 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__nand3b_2
Xc177 net96 net85 net848 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__or3_4
Xc155 net81 net68 net836 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__nand3b_4
Xc188 net743 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__inv_2
Xc199 net1 net857 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__nand2b_1
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc301_22 clknet_1_0__leaf_net776 VGND VGND VPWR VPWR net996 sky130_fd_sc_hd__clkinv_1
XFILLER_0_24_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge880_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c563_S1 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net143 clknet_0_net143 VGND VGND VPWR VPWR clknet_1_0__leaf_net143
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c336_C net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c463_D_N clknet_1_0__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c608_D net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge814_A1 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c754_S0 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c437_D1 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_94_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net812 clknet_0_net812 VGND VGND VPWR VPWR clknet_1_1__leaf_net812
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c256_C_N net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c216_A2 net138 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge853_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c684_D_N net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c446_B net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout142_X net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c234_Y net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c86_S1 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c704_C1 net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc82 net17 net9 net961 VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__nor3b_1
Xc71 net3 net827 net849 net873 net8 VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__o2111ai_2
Xc93 net865 net29 net957 net961 VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__or4bb_4
XFILLER_0_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge796_S0 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c614_C1 net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge912_Q net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c394_S0 net753 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c396_B net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c751_S1 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input32_A in37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c599_CLK_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_11_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c328_B1 clknet_1_0__leaf_net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer15 net1028 VGND VGND VPWR VPWR net1030 sky130_fd_sc_hd__dlygate4sd1_1
Xclkbuf_1_1__f_net472 clknet_0_net472 VGND VGND VPWR VPWR clknet_1_1__leaf_net472
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_65_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c144_B net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge806_A2 net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c409_B net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_77_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc529 net205 net329 VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__nand2_1
XANTENNA_c673_A net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge803_B net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c762_S0 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c97_B net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput73 net948 VGND VGND VPWR VPWR out19 sky130_fd_sc_hd__buf_2
XFILLER_0_37_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput84 net907 VGND VGND VPWR VPWR out30 sky130_fd_sc_hd__buf_2
Xoutput95 net952 VGND VGND VPWR VPWR out41 sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_net517 clknet_0_net517 VGND VGND VPWR VPWR clknet_1_0__leaf_net517
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c663_B_N net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c224_A2 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c240_A1 net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c429_CLK_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c359_B net138 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c261_B net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net291 clknet_0_net291 VGND VGND VPWR VPWR clknet_1_1__leaf_net291
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c573_SCE net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c406_B_N net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net940_X net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc315 net762 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__buf_16
Xc304 net228 net996 net195 net225 net436 net951 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__mux4_4
Xc326 net746 VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__buf_2
XFILLER_0_13_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc359 net154 net138 net120 VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__nand3b_1
Xc337 net260 net106 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__or2_1
Xc348 net265 net264 net270 net268 clknet_1_0__leaf_net939 net791 VGND VGND VPWR VPWR
+ net274 sky130_fd_sc_hd__mux4_1
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_99_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge803 net351 net319 net233 net349 VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__or4bb_1
XFILLER_0_95_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge814 clknet_1_0__leaf_net438 net900 net432 net247 net243 net244 VGND VGND VPWR
+ VPWR net675 sky130_fd_sc_hd__mux4_2
Xmerge836 clknet_4_12_0_clk net397 net398 VGND VGND VPWR VPWR net700 net699 sky130_fd_sc_hd__dfsbp_1
Xmerge825 clknet_4_3_0_clk net474 net485 VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__dfrtp_4
Xs942 net590 clknet_4_7_0_clk VGND VGND VPWR VPWR net818 net817 sky130_fd_sc_hd__dlxbn_2
Xmerge847 net583 net661 VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__nor2_1
Xmerge869 net272 net275 VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__nand2_2
XFILLER_0_36_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xs920 clknet_4_14_0_clk net296 VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__dfxtp_4
Xmerge858 net539 net718 VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__nor2_1
Xs931 net501 clknet_4_12_0_clk VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__dlxtp_1
XFILLER_0_82_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer6 net998 VGND VGND VPWR VPWR net999 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_63_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c386_S1 net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge825_Q net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output63_A net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout137 net961 VGND VGND VPWR VPWR net960 sky130_fd_sc_hd__buf_2
Xfanout148 net822 VGND VGND VPWR VPWR net971 sky130_fd_sc_hd__buf_4
XANTENNA_c251_B1 net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c476_B net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c264_Y net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc101 net18 net958 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__nor2_4
Xc112 net28 net16 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__nor2b_1
Xc123 net26 net49 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__and2b_2
Xc134 net64 net824 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__nor2b_4
Xc145 net73 net70 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__and2_2
Xc178 net92 net881 net84 net900 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__or4bb_1
Xc156 net854 net81 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__or2b_1
Xc167 net96 net973 net89 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__nor3b_4
Xc189 net87 net112 net2 net115 net969 net864 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__mux4_1
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc301_23 clknet_1_0__leaf_net776 VGND VGND VPWR VPWR net997 sky130_fd_sc_hd__clkinv_1
XFILLER_0_59_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc690 clknet_4_4_0_clk clknet_1_1__leaf_net363 net549 net547 net542 VGND VGND VPWR
+ VPWR net571 sky130_fd_sc_hd__sedfxtp_4
XPHY_EDGE_ROW_3_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c586_A net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c754_S1 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c131_A3 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c437_C1 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c71_D1 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input62_A in9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_76_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net813 clknet_0_net813 VGND VGND VPWR VPWR clknet_1_1__leaf_net813
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c567_SET_B net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge892_Q net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_85_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c181_C net689 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c279_C net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c590_S0 net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge809_A2 net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c341_B net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout135_X net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c596_Y net499 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c704_B1 clknet_1_1__leaf_net584 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c765_S0 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c589_X net892 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc72 net9 net972 net879 VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__nor3b_1
Xc83 net18 net959 net961 VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__nand3_1
Xc94 net866 net29 VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__or2_4
XFILLER_0_85_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge796_S1 net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge905_Q net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net643 clknet_0_net643 VGND VGND VPWR VPWR clknet_1_1__leaf_net643
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c243_A1 net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c354_D_N net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c556_B net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net899 net899 VGND VGND VPWR VPWR clknet_0_net899 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_91_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input25_A in30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c328_A1 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output93_A net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c584_D_N clknet_1_1__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net440 clknet_0_net440 VGND VGND VPWR VPWR clknet_1_1__leaf_net440
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_1_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c144_C net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c137_B net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c311_C net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c673_B net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c454_X net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c310_C_N net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput63 net886 VGND VGND VPWR VPWR out0 sky130_fd_sc_hd__clkbuf_4
Xoutput85 net908 VGND VGND VPWR VPWR out31 sky130_fd_sc_hd__buf_2
Xoutput74 net897 VGND VGND VPWR VPWR out2 sky130_fd_sc_hd__buf_2
XFILLER_0_101_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput96 net919 VGND VGND VPWR VPWR out42 sky130_fd_sc_hd__buf_2
XFILLER_0_37_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input28_X net851 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold33_A net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
.ends
