* NGSPICE file created from netlist_0.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_4 abstract view
.subckt sky130_fd_sc_hd__a41oi_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfbbn_1 abstract view
.subckt sky130_fd_sc_hd__dfbbn_1 CLK_N D RESET_B SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbp_1 CLK D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q
+ Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_2 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_2 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbp_1 abstract view
.subckt sky130_fd_sc_hd__dlxbp_1 D GATE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_1 abstract view
.subckt sky130_fd_sc_hd__dlclkp_1 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_1 abstract view
.subckt sky130_fd_sc_hd__dfxbp_1 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_1 abstract view
.subckt sky130_fd_sc_hd__dlxtn_1 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_2 abstract view
.subckt sky130_fd_sc_hd__dlclkp_2 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_4 abstract view
.subckt sky130_fd_sc_hd__a41o_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_4 abstract view
.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfbbp_1 abstract view
.subckt sky130_fd_sc_hd__dfbbp_1 CLK D RESET_B SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_2 abstract view
.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfxtp_1 abstract view
.subckt sky130_fd_sc_hd__sdfxtp_1 CLK D SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_4 abstract view
.subckt sky130_fd_sc_hd__mux4_4 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_1 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_4 abstract view
.subckt sky130_fd_sc_hd__dlclkp_4 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfxtp_2 abstract view
.subckt sky130_fd_sc_hd__sdfxtp_2 CLK D SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_4 abstract view
.subckt sky130_fd_sc_hd__a21bo_4 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfxbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfxbp_1 CLK D SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_2 abstract view
.subckt sky130_fd_sc_hd__dlxtn_2 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_1 abstract view
.subckt sky130_fd_sc_hd__dlxbn_1 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_2 abstract view
.subckt sky130_fd_sc_hd__dfrbp_2 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrbp_2 abstract view
.subckt sky130_fd_sc_hd__sdfrbp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtp_1 abstract view
.subckt sky130_fd_sc_hd__dlxtp_1 D GATE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_1 abstract view
.subckt sky130_fd_sc_hd__dlrtp_1 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_1 abstract view
.subckt sky130_fd_sc_hd__a41oi_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_2 abstract view
.subckt sky130_fd_sc_hd__a41o_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_4 abstract view
.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__lpflow_inputisolatch_1 abstract view
.subckt sky130_fd_sc_hd__lpflow_inputisolatch_1 D SLEEP_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfsbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfsbp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_2 abstract view
.subckt sky130_fd_sc_hd__a41oi_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_2 abstract view
.subckt sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxtp_1 abstract view
.subckt sky130_fd_sc_hd__sedfxtp_1 CLK D DE SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_1 abstract view
.subckt sky130_fd_sc_hd__dlrtn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxtp_4 abstract view
.subckt sky130_fd_sc_hd__sedfxtp_4 CLK D DE SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfrbp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtn_1 abstract view
.subckt sky130_fd_sc_hd__dfrtn_1 CLK_N D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxbp_2 abstract view
.subckt sky130_fd_sc_hd__sedfxbp_2 CLK D DE SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_8 abstract view
.subckt sky130_fd_sc_hd__mux2_8 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_2 abstract view
.subckt sky130_fd_sc_hd__dfsbp_2 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbp_1 abstract view
.subckt sky130_fd_sc_hd__dlrbp_1 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_1 abstract view
.subckt sky130_fd_sc_hd__dfsbp_1 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_4 abstract view
.subckt sky130_fd_sc_hd__dfstp_4 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxbp_1 abstract view
.subckt sky130_fd_sc_hd__sedfxbp_1 CLK D DE SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtn_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtn_1 CLK_N D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_1 abstract view
.subckt sky130_fd_sc_hd__dlrbn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_4 abstract view
.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfxtp_4 abstract view
.subckt sky130_fd_sc_hd__sdfxtp_4 CLK D SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfstp_1 abstract view
.subckt sky130_fd_sc_hd__sdfstp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfxbp_2 abstract view
.subckt sky130_fd_sc_hd__sdfxbp_2 CLK D SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_2 abstract view
.subckt sky130_fd_sc_hd__dlrtn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_2 abstract view
.subckt sky130_fd_sc_hd__dlxbn_2 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s4s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s4s_1 A VGND VNB VPB VPWR X
.ends

.subckt netlist_0 VGND VPWR clk in0 in1 in10 in11 in12 in13 in14 in15 in16 in17 in18
+ in19 in2 in20 in21 in22 in23 in24 in25 in26 in27 in28 in29 in3 in30 in31 in32 in33
+ in34 in35 in36 in37 in38 in39 in4 in40 in41 in42 in43 in44 in45 in46 in47 in48 in49
+ in5 in50 in51 in52 in53 in54 in55 in56 in57 in58 in59 in6 in60 in61 in7 in8 in9
+ out0 out1 out10 out11 out12 out13 out14 out15 out16 out17 out18 out19 out2 out20
+ out21 out22 out23 out24 out25 out26 out27 out28 out29 out3 out30 out31 out32 out33
+ out34 out35 out36 out37 out38 out39 out4 out40 out41 out42 out43 out44 out45 out46
+ out47 out48 out49 out5 out50 out51 out52 out53 out54 out55 out56 out57 out58 out59
+ out6 out60 out61 out7 out8 out9 rst
XFILLER_0_94_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout162_A net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c249_B1 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc327 net782 net262 net784 net838 net260 net675 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__mux4_2
Xc305 net247 net783 net787 net243 clknet_1_0__leaf_net245 VGND VGND VPWR VPWR net249
+ sky130_fd_sc_hd__a41oi_4
Xc316 net232 net898 net907 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__mux2_2
XFILLER_0_60_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc338 net40 net827 net174 net903 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__a31o_1
Xc349 clknet_leaf_24_clk net291 net9 net282 VGND VGND VPWR VPWR net293 net292 sky130_fd_sc_hd__dfbbn_1
XANTENNA_c676_Y net580 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c275_SET_B net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net493 net493 VGND VGND VPWR VPWR clknet_0_net493 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_11_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer7 net595 VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_23_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c516_A1 net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout149 net77 VGND VGND VPWR VPWR net891 sky130_fd_sc_hd__buf_12
XFILLER_0_49_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net860 clknet_0_net860 VGND VGND VPWR VPWR clknet_1_0__leaf_net860
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc102 clknet_leaf_31_clk net29 net38 net26 net22 net945 VGND VGND VPWR VPWR net43
+ net42 sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_60_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc124 net47 net64 net62 net66 net52 net60 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__mux4_1
Xc113 net46 net771 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__xor2_1
Xc135 net886 net73 net75 net901 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__a31oi_4
Xc157 clknet_leaf_39_clk net86 net99 net89 net899 net934 VGND VGND VPWR VPWR net102
+ net101 sky130_fd_sc_hd__sdfbbn_2
Xc168 net803 net884 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__xor2_4
Xc146 net895 net933 net87 net922 net934 net899 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__mux4_2
Xc179 net121 net783 net877 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__o21a_1
XANTENNA_clkbuf_leaf_31_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c234_SCE net651 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c708_Q net618 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs751 net180 clknet_leaf_29_clk VGND VGND VPWR VPWR net839 net658 sky130_fd_sc_hd__dlxbp_1
XTAP_TAPCELL_ROW_24_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs762 clknet_leaf_2_clk net235 VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__dlclkp_1
Xs773 clknet_leaf_25_clk net288 VGND VGND VPWR VPWR net680 net679 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_36_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs784 net349 clknet_leaf_4_clk VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_55_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net290 net290 VGND VGND VPWR VPWR clknet_0_net290 sky130_fd_sc_hd__clkbuf_16
Xs795 clknet_leaf_23_clk net390 VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__dlclkp_2
XFILLER_0_24_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c473_SCE net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc691 net478 net593 net919 clknet_1_1__leaf_net669 net724 VGND VGND VPWR VPWR net598
+ sky130_fd_sc_hd__a41o_4
Xc680 clknet_leaf_11_clk clknet_1_1__leaf_net577 clknet_1_1__leaf_net805 clknet_1_0__leaf_net582
+ clknet_1_1__leaf_net252 net720 VGND VGND VPWR VPWR net584 net583 sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_75_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net145 clknet_0_net145 VGND VGND VPWR VPWR clknet_1_0__leaf_net145
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c65_A net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input55_A in58 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input10_X net752 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c446_SCE net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_531 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c142_A3 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc84 net893 net752 VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__xor2_4
Xc73 net8 net9 net7 VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__o21bai_4
Xc62 net798 net782 net794 net783 net791 net803 VGND VGND VPWR VPWR net0 sky130_fd_sc_hd__mux4_2
Xc95 net26 net30 VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_26_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c333_A2 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap138_A net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_6_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net834 net834 VGND VGND VPWR VPWR clknet_0_net834 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net845 net845 VGND VGND VPWR VPWR clknet_0_net845 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c504_Y net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c715_A0 net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c434_A1 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold41 net554 VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 net682 VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 net699 VGND VGND VPWR VPWR net964 sky130_fd_sc_hd__dlygate4sd3_1
Xhold63 net418 VGND VGND VPWR VPWR net975 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input18_A in24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c519_SET_B net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c344_A1 net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c443_RESET_B net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer17 clknet_0_net615 VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_83_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net485 clknet_0_net485 VGND VGND VPWR VPWR clknet_1_1__leaf_net485
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_65_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc509 clknet_leaf_7_clk net206 net315 net416 VGND VGND VPWR VPWR net419 net418 sky130_fd_sc_hd__dfbbp_1
XTAP_TAPCELL_ROW_77_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c701_A2 net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c328_SCD clknet_1_0__leaf_net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c447_X net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c429_A1 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net653 net653 VGND VGND VPWR VPWR clknet_0_net653 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput64 net806 VGND VGND VPWR VPWR out1 sky130_fd_sc_hd__buf_2
Xoutput75 net817 VGND VGND VPWR VPWR out21 sky130_fd_sc_hd__clkbuf_1
Xoutput86 net828 VGND VGND VPWR VPWR out31 sky130_fd_sc_hd__buf_2
Xoutput97 net839 VGND VGND VPWR VPWR out42 sky130_fd_sc_hd__buf_2
XANTENNA_c567_SCD clknet_1_0__leaf_net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c339_A1 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net271 clknet_0_net271 VGND VGND VPWR VPWR clknet_1_1__leaf_net271
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c275_Q_N net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc317 net798 net898 clknet_1_0__leaf_net152 VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__a21bo_2
Xc306 clknet_1_0__leaf_net245 net909 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__xnor2_2
XFILLER_0_13_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc328 clknet_leaf_33_clk net892 clknet_1_0__leaf_net131 net981 VGND VGND VPWR VPWR
+ net270 sky130_fd_sc_hd__sdfxtp_1
Xc339 net876 net883 net866 net674 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__a31oi_4
XANTENNA_s802_Q net709 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c712_A1 net815 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer8 net919 VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_leaf_5_clk_A clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c325_A3 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input40_X net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_1_0__f_net464_X clknet_1_0__leaf_net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c516_A2 net417 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c651_B1_N net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c703_SCD net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c707_A1 net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc103 net22 net39 net648 VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__a21o_2
Xc125 net62 net49 net61 net863 net53 net828 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__mux4_4
Xc114 clknet_leaf_30_clk net49 net30 net53 net868 net852 VGND VGND VPWR VPWR net55
+ net54 sky130_fd_sc_hd__sdfbbn_1
Xc136 net78 net75 net743 net886 net899 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__a41o_4
Xc158 net102 net761 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__xor2_1
Xc169 net747 net758 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__xor2_4
Xc147 net87 net756 net900 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_44_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs741 clknet_leaf_31_clk net41 VGND VGND VPWR VPWR net648 net647 sky130_fd_sc_hd__dfxbp_1
Xs752 net183 clknet_leaf_27_clk VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_55_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs763 clknet_leaf_2_clk net236 VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__dlclkp_2
Xs774 clknet_leaf_25_clk net295 VGND VGND VPWR VPWR net681 s774/Q_N sky130_fd_sc_hd__dfxbp_1
Xs785 net362 clknet_leaf_3_clk VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__dlxtn_1
XTAP_TAPCELL_ROW_52_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net280 net280 VGND VGND VPWR VPWR clknet_0_net280 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs796 clknet_leaf_26_clk net409 VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_63_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap168_A net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc670 net562 net568 net569 net555 net565 net531 VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__mux4_4
Xc681 clknet_leaf_12_clk net461 net575 clknet_1_0__leaf_net465 clknet_1_0__leaf_net805
+ net962 VGND VGND VPWR VPWR net586 net585 sky130_fd_sc_hd__sdfbbn_1
Xc692 net586 net596 net532 clknet_1_0__leaf_net805 net920 net583 VGND VGND VPWR VPWR
+ net599 sky130_fd_sc_hd__mux4_2
XFILLER_0_78_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c262_A1 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c65_B net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input48_A in51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net859 clknet_0_net859 VGND VGND VPWR VPWR clknet_1_1__leaf_net859
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_29_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c689_S0 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c347_A1 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_71_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c341_D net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_30_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c704_A2 net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc85 net912 net18 VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__xnor2_1
Xc74 net10 net11 net798 net7 net912 VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__a41o_1
Xc63 net796 net912 VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__xor2_2
XFILLER_0_97_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc96 net25 net27 net869 VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_26_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c333_A3 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c540_A1 net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_9_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net824 net824 VGND VGND VPWR VPWR clknet_0_net824 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net813 net813 VGND VGND VPWR VPWR clknet_0_net813 sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout140_X net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c418_A3 net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net835 net835 VGND VGND VPWR VPWR clknet_0_net835 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c715_A1 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c434_A2 net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold31 net560 VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 net828 VGND VGND VPWR VPWR net976 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 net816 VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 net278 VGND VGND VPWR VPWR net965 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c178_B1 net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net464 clknet_0_net464 VGND VGND VPWR VPWR clknet_1_1__leaf_net464
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c207_S0 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer18 net88 VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_88_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c304_D net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c596_S1 net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c551_A0 net415 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c701_A3 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c182_Y net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net632 net632 VGND VGND VPWR VPWR clknet_0_net632 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net654 net654 VGND VGND VPWR VPWR clknet_0_net654 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput65 clknet_1_1__leaf_net807 VGND VGND VPWR VPWR out10 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_101_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput76 clknet_1_0__leaf_net818 VGND VGND VPWR VPWR out22 sky130_fd_sc_hd__clkbuf_1
Xoutput98 net840 VGND VGND VPWR VPWR out43 sky130_fd_sc_hd__buf_2
Xoutput87 net829 VGND VGND VPWR VPWR out32 sky130_fd_sc_hd__buf_2
XANTENNA_input30_A in35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c567_SCE net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output117_A clknet_1_0__leaf_net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c339_A2 net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c537_RESET_B net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net250 clknet_0_net250 VGND VGND VPWR VPWR clknet_1_1__leaf_net250
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c254_D net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c249_A2 net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_99_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout148_A net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc318 clknet_leaf_36_clk clknet_1_1__leaf_net145 net759 clknet_1_0__leaf_net131 VGND
+ VGND VPWR VPWR net261 sky130_fd_sc_hd__sdfxtp_2
Xc307 net244 clknet_1_0__leaf_net250 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__xor2_4
XFILLER_0_60_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc329 clknet_1_0__leaf_net268 net270 net17 net144 clknet_1_0__leaf_net267 net907 VGND
+ VGND VPWR VPWR net271 sky130_fd_sc_hd__mux4_2
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c159_A2 net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c95_B net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c88_A net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c74_B1 net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net473 net473 VGND VGND VPWR VPWR clknet_0_net473 sky130_fd_sc_hd__clkbuf_16
Xrebuffer9 net919 VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c175_A1 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c310_S0 clknet_1_0__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c606_A3 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c220_S0 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_74_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout129 net200 VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_85_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net862 clknet_0_net862 VGND VGND VPWR VPWR clknet_1_0__leaf_net862
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c703_SCE net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s745_Q net651 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc104 net37 net876 net33 net793 net26 net647 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__mux4_4
Xc115 net55 net43 net50 VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__a21oi_2
Xc126 net743 net804 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__xor2_4
XFILLER_0_20_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc137 net79 net886 net917 net899 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__a31oi_4
Xc159 net103 net756 net101 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__a21bo_4
Xc148 clknet_leaf_38_clk net760 net89 net752 VGND VGND VPWR VPWR net92 net91 sky130_fd_sc_hd__sdfxbp_1
XANTENNA_c161_A3 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs742 clknet_leaf_31_clk net44 VGND VGND VPWR VPWR net852 net649 sky130_fd_sc_hd__dfxbp_1
XANTENNA_c232_RESET_B net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs753 net187 clknet_leaf_29_clk VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__dlxtn_1
XANTENNA_c186_B1 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs764 clknet_leaf_35_clk net254 VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__dlclkp_4
Xs775 clknet_leaf_26_clk net297 VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_52_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs786 net363 clknet_leaf_3_clk VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__dlxtn_2
Xs797 net410 clknet_leaf_19_clk VGND VGND VPWR VPWR net843 net702 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_24_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc671 net557 net570 net572 clknet_1_0__leaf_net553 net568 net719 VGND VGND VPWR VPWR
+ net574 sky130_fd_sc_hd__mux4_4
Xc682 clknet_leaf_11_clk net569 clknet_1_1__leaf_net464 net547 net911 net904 VGND
+ VGND VPWR VPWR net588 net587 sky130_fd_sc_hd__sdfbbn_1
Xc660 clknet_leaf_9_clk net460 net546 net961 net559 net551 VGND VGND VPWR VPWR net561
+ net560 sky130_fd_sc_hd__sdfbbp_1
Xc693 net548 clknet_1_1__leaf_net493 net903 net867 clknet_1_1__leaf_net464 net905
+ VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__mux4_1
XFILLER_0_75_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c105_B net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c262_A2 net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c262_Y net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_leaf_4_clk_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c634_A net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout170_X net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net670 clknet_0_net670 VGND VGND VPWR VPWR clknet_1_0__leaf_net670
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c718_A1 net618 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_36_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_94_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c453_A1 net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net805 clknet_0_net805 VGND VGND VPWR VPWR clknet_1_1__leaf_net805
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_45_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_54_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_63_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_72_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout130_A net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_81_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc64 net795 net750 net912 net782 VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__a31o_2
Xc75 net780 net11 net12 net5 net4 net782 VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__mux4_2
Xc86 net793 net20 VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__xor2_4
Xc97 clknet_leaf_32_clk net28 net29 VGND VGND VPWR VPWR net36 net35 sky130_fd_sc_hd__dfrbp_2
XTAP_TAPCELL_ROW_26_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_90_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c167_A2 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c464_B1 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input60_A in7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net635 clknet_0_net635 VGND VGND VPWR VPWR clknet_1_1__leaf_net635
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c540_A2 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c549_B1 net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c715_A2 net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold32 net714 VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 net612 VGND VGND VPWR VPWR net977 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 net680 VGND VGND VPWR VPWR net955 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 net425 VGND VGND VPWR VPWR net966 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c178_A1 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c313_S0 net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net465 clknet_0_net465 VGND VGND VPWR VPWR clknet_1_1__leaf_net465
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer19 net930 VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_65_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c429_A3 net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c726_A1 clknet_1_0__leaf_net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput66 net808 VGND VGND VPWR VPWR out11 sky130_fd_sc_hd__buf_2
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c461_A1 clknet_1_0__leaf_net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput99 net841 VGND VGND VPWR VPWR out44 sky130_fd_sc_hd__buf_2
Xoutput77 net819 VGND VGND VPWR VPWR out23 sky130_fd_sc_hd__clkbuf_1
Xoutput88 clknet_1_1__leaf_net830 VGND VGND VPWR VPWR out33 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c308_S0 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input23_A in29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c339_A3 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c652_B1 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c227_RESET_B net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net273 clknet_0_net273 VGND VGND VPWR VPWR clknet_1_1__leaf_net273
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net251 clknet_0_net251 VGND VGND VPWR VPWR clknet_1_1__leaf_net251
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c247_D net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc308 net909 net875 clknet_1_0__leaf_net245 net212 net877 clknet_1_1__leaf_net251
+ VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__mux4_1
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc319 net261 net750 net260 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__a21oi_4
XFILLER_0_40_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net485 net485 VGND VGND VPWR VPWR clknet_0_net485 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c590_S net714 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input26_X net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c516_A4 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c128_B1_N net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c400_SCE net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net830 clknet_0_net830 VGND VGND VPWR VPWR clknet_1_0__leaf_net830
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc105 net36 net25 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__xor2_2
Xc116 clknet_leaf_30_clk net52 net963 net868 VGND VGND VPWR VPWR net57 net56 sky130_fd_sc_hd__dfbbn_1
Xc127 net755 net744 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_96_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c723_A2 net566 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc149 clknet_leaf_38_clk net89 net946 net763 net888 VGND VGND VPWR VPWR net94 net93
+ sky130_fd_sc_hd__sdfrbp_2
Xc138 net922 net754 net895 net79 net747 net76 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__mux4_2
XANTENNA_c161_A4 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs743 clknet_leaf_29_clk net67 VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_99_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs754 net191 clknet_leaf_29_clk VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__dlxtn_1
XTAP_TAPCELL_ROW_24_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs776 clknet_leaf_27_clk net301 VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__dfxtp_1
Xs765 net257 clknet_leaf_3_clk VGND VGND VPWR VPWR net672 net671 sky130_fd_sc_hd__dlxbn_1
XTAP_TAPCELL_ROW_52_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net271 net271 VGND VGND VPWR VPWR clknet_0_net271 sky130_fd_sc_hd__clkbuf_16
Xs787 net365 clknet_leaf_3_clk VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__dlxtp_1
Xs798 net411 clknet_leaf_20_clk VGND VGND VPWR VPWR net704 net703 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_63_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc661 net549 clknet_leaf_9_clk net552 VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__dlrtp_1
Xc650 net529 net541 net538 net534 net548 VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__a41o_1
Xc672 clknet_leaf_10_clk net980 net534 clknet_1_0__leaf_net553 VGND VGND VPWR VPWR
+ net575 sky130_fd_sc_hd__sdfxtp_1
Xc694 net593 clknet_1_0__leaf_net598 net567 net911 VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__a31o_1
Xc683 net877 net578 clknet_1_0__leaf_net581 net584 clknet_1_1__leaf_net252 VGND VGND
+ VPWR VPWR net589 sky130_fd_sc_hd__a41oi_1
XFILLER_0_75_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout163_X net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c718_A2 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c71_A2 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c453_A2 net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_100_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c274_Q net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_334 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc480 net914 clknet_1_1__leaf_net403 net298 net771 clknet_1_0__leaf_net830 clknet_1_1__leaf_net833
+ VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__mux4_4
XFILLER_0_19_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c215_B net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout123_A net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c704_A4 net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c570_A0 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc76 net8 net9 VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__xnor2_4
Xc65 net756 net776 VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__xnor2_4
Xc98 net32 net36 net26 net756 net784 net869 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__mux4_1
Xc87 net21 net16 net893 net912 net784 VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__a41o_2
XFILLER_0_97_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A1 net618 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c167_A3 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c301_S net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_rebuffer26_A net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c183_A2 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input53_A in56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net669 clknet_0_net669 VGND VGND VPWR VPWR clknet_1_1__leaf_net669
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_leaf_3_clk_A clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c540_A3 net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net859 net859 VGND VGND VPWR VPWR clknet_0_net859 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_31_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c715_A3 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold33 net647 VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 net686 VGND VGND VPWR VPWR net956 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 net688 VGND VGND VPWR VPWR net967 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold66 net144 VGND VGND VPWR VPWR net978 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c178_A2 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input56_X net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold61_A net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c680_RESET_B clknet_1_1__leaf_net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c230_X net174 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput67 net809 VGND VGND VPWR VPWR out12 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c461_A2 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput78 net820 VGND VGND VPWR VPWR out24 sky130_fd_sc_hd__clkbuf_4
Xoutput89 net878 VGND VGND VPWR VPWR out34 sky130_fd_sc_hd__buf_2
XFILLER_0_98_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input16_A in22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_2_0__f_clk_X clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c355_A3 net174 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output84_A net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap139_X net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net252 clknet_0_net252 VGND VGND VPWR VPWR clknet_1_1__leaf_net252
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net263 clknet_0_net263 VGND VGND VPWR VPWR clknet_1_1__leaf_net263
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net296 clknet_0_net296 VGND VGND VPWR VPWR clknet_1_1__leaf_net296
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_43_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc309 clknet_1_0__leaf_net252 clknet_1_0__leaf_net251 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__xor2_2
XFILLER_0_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input8_A in15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net464 net464 VGND VGND VPWR VPWR clknet_0_net464 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_11_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c423_Q_N net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_85_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_30_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_30_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_33_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c573_B1 net417 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc106 net3 net771 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__xor2_2
Xc117 net53 net25 net848 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__mux2_1
XANTENNA_c292_A1 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_96_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c723_A3 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc139 net80 net922 net934 net69 net79 net899 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__mux4_2
Xc128 net745 net754 net70 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__a21boi_4
XFILLER_0_68_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_416 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs755 net192 clknet_leaf_29_clk VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__dlxtp_1
Xs744 clknet_leaf_30_clk net68 VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_24_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs766 net258 clknet_leaf_34_clk VGND VGND VPWR VPWR net674 net673 sky130_fd_sc_hd__dlxbn_1
Xclkbuf_0_net250 net250 VGND VGND VPWR VPWR clknet_0_net250 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_52_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs799 net438 clknet_leaf_7_clk VGND VGND VPWR VPWR net706 net705 sky130_fd_sc_hd__dlxbp_1
Xs777 clknet_leaf_27_clk net302 VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xs788 net368 clknet_leaf_3_clk VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__lpflow_inputisolatch_1
XFILLER_0_51_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_21_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_21_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_63_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_rebuffer11_X net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc640 net426 clknet_leaf_8_clk net534 VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__dlrtp_1
Xc651 net531 net432 net904 VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__o21ba_1
Xc673 net544 net563 net882 net877 net904 VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__a41o_1
Xc662 clknet_leaf_10_clk net953 net979 net450 net943 VGND VGND VPWR VPWR net564 net563
+ sky130_fd_sc_hd__sdfsbp_1
Xc695 clknet_1_1__leaf_net598 net911 net752 VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__a21boi_1
Xc684 net203 net588 net584 net532 clknet_1_1__leaf_net252 VGND VGND VPWR VPWR net590
+ sky130_fd_sc_hd__a41oi_1
XFILLER_0_75_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net127 clknet_0_net127 VGND VGND VPWR VPWR clknet_1_0__leaf_net127
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c377_A1 net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_12_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_12_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_15_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c686_SET_B net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c474_D clknet_1_1__leaf_net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout156_X net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net683 clknet_0_net683 VGND VGND VPWR VPWR clknet_1_0__leaf_net683
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c734_A2 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net807 clknet_0_net807 VGND VGND VPWR VPWR clknet_1_1__leaf_net807
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net818 clknet_0_net818 VGND VGND VPWR VPWR clknet_1_1__leaf_net818
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_29_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_max_cap166_A net815 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c473_RESET_B net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc470 clknet_1_1__leaf_net250 net171 net771 VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__a21bo_1
Xc481 net400 net405 net870 net173 clknet_1_0__leaf_net835 net843 VGND VGND VPWR VPWR
+ net411 sky130_fd_sc_hd__mux4_2
Xclkbuf_leaf_1_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_1_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_87_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_93_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc66 net792 net769 net3 VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__mux2_2
XFILLER_0_97_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc88 net764 net19 VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__xor2_4
Xc99 net34 net36 net869 net25 net9 VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__a41o_1
Xc77 net893 net5 net13 net9 net762 net10 VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__mux4_2
XFILLER_0_97_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A2 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net480 clknet_0_net480 VGND VGND VPWR VPWR clknet_1_0__leaf_net480
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_34_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c82_A2 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire137 net83 VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__buf_12
XANTENNA_c464_A2 net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c63_B net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c183_A3 net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c560_B1_N net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input46_A in5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net615 net929 VGND VGND VPWR VPWR clknet_1_1__leaf_net615 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c549_A2 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net805 net805 VGND VGND VPWR VPWR clknet_0_net805 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c565_A1 net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c583_B1_N net714 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c581_A0 net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold34 net760 VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 net343 VGND VGND VPWR VPWR net968 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 net829 VGND VGND VPWR VPWR net957 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 net556 VGND VGND VPWR VPWR net979 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c459_A2 clknet_1_1__leaf_net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c178_A3 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net401 clknet_0_net401 VGND VGND VPWR VPWR clknet_1_1__leaf_net401
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net412 clknet_0_net412 VGND VGND VPWR VPWR clknet_1_1__leaf_net412
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_83_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c456_B1_N net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_90_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c551_A3 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_69_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net635 net635 VGND VGND VPWR VPWR clknet_0_net635 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput79 clknet_1_1__leaf_net821 VGND VGND VPWR VPWR out25 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_101_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput68 net810 VGND VGND VPWR VPWR out13 sky130_fd_sc_hd__buf_2
XFILLER_0_98_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_2_clk_A clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c652_A2 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net253 clknet_0_net253 VGND VGND VPWR VPWR clknet_1_1__leaf_net253
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net264 clknet_0_net264 VGND VGND VPWR VPWR clknet_1_1__leaf_net264
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net242 clknet_0_net242 VGND VGND VPWR VPWR clknet_1_1__leaf_net242
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c546_A3 net665 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c173_X net117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c74_A3 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net465 net465 VGND VGND VPWR VPWR clknet_0_net465 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c472_A2 net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c519_RESET_B net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c191_A3 net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c99_B1 net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c229_S1 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c245_S0 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net821 clknet_0_net821 VGND VGND VPWR VPWR clknet_1_0__leaf_net821
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_54_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout146_A net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c573_A1 net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc107 net21 net35 net46 VGND VGND VPWR VPWR net863 sky130_fd_sc_hd__a21oi_2
Xc118 net58 net57 net863 VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__a21boi_4
XFILLER_0_41_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc129 net754 net901 net744 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__a21boi_4
XANTENNA_c388_X net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c93_B net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs745 clknet_leaf_38_clk net95 VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__dfxtp_4
Xs767 net265 clknet_leaf_35_clk VGND VGND VPWR VPWR net855 net675 sky130_fd_sc_hd__dlxbp_1
XTAP_TAPCELL_ROW_24_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xs756 net199 clknet_leaf_6_clk VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__lpflow_inputisolatch_1
XTAP_TAPCELL_ROW_52_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs778 clknet_leaf_27_clk net303 VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__dlclkp_1
Xclkbuf_0_net273 net273 VGND VGND VPWR VPWR clknet_0_net273 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net251 net251 VGND VGND VPWR VPWR clknet_0_net251 sky130_fd_sc_hd__clkbuf_16
Xs789 clknet_leaf_3_clk net369 VGND VGND VPWR VPWR net694 s789/Q_N sky130_fd_sc_hd__dfxbp_1
Xc630 net748 net882 VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__xor2_4
Xc652 net432 net881 net531 net867 VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__a31o_1
Xc663 net556 net459 net546 net894 net563 VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__a41oi_4
Xc641 net423 net536 VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__xor2_4
Xc696 clknet_leaf_17_clk net601 net906 net904 net726 VGND VGND VPWR VPWR net603 c696/Q_N
+ sky130_fd_sc_hd__sdfsbp_1
Xc674 net576 net572 net891 net882 clknet_1_1__leaf_net669 VGND VGND VPWR VPWR net577
+ sky130_fd_sc_hd__a41oi_2
Xc685 net584 net894 net93 VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__a21boi_1
XFILLER_0_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c674_B1 clknet_1_1__leaf_net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout149_X net891 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c453_A4 net684 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c96_A1 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_14_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c96_Y net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_23_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc460 net376 clknet_1_1__leaf_net366 net752 net384 net905 clknet_1_0__leaf_net833
+ VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__mux4_1
Xc471 clknet_1_1__leaf_net290 net393 net398 VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__a21boi_4
Xc482 net405 net406 clknet_1_0__leaf_net862 net776 net702 net703 VGND VGND VPWR VPWR
+ net412 sky130_fd_sc_hd__mux4_4
XFILLER_0_35_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_32_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c388_A1 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc67 net790 net4 VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_50_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc78 net772 net8 net15 net12 net14 net9 VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__mux4_2
Xc89 net23 net804 VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__xnor2_4
XFILLER_0_78_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A3 net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c433_S0 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net470 clknet_0_net470 VGND VGND VPWR VPWR clknet_1_0__leaf_net470
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c518_X net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c464_A3 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input39_A in43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc290 net229 net875 net209 net90 net666 net667 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__mux4_1
XFILLER_0_46_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c517_Q_N net428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold46 net279 VGND VGND VPWR VPWR net958 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 net692 VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__dlygate4sd3_1
Xhold68 net564 VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 net667 VGND VGND VPWR VPWR net969 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c77_A3 net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_39_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c635_X net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c163_S0 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c178_A4 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net402 clknet_0_net402 VGND VGND VPWR VPWR clknet_1_1__leaf_net402
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c248_S0 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c562_SET_B clknet_1_0__leaf_net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c430_SCE net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c170_B net758 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c550_B1_N net709 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c576_A1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c295_A2 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net669 net669 VGND VGND VPWR VPWR clknet_0_net669 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c592_B1 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput69 net811 VGND VGND VPWR VPWR out14 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_98_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c340_S1 net855 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_42_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c71_X net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input61_X net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap141_A net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_6_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c677_B1 net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c166_X net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c74_A4 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c99_A1 net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input21_A in27 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c351_S0 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_74_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_97_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c245_S1 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net833 clknet_0_net833 VGND VGND VPWR VPWR clknet_1_0__leaf_net833
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_54_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c469_B1_N net858 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c300_B net789 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c573_A2 net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_2_1__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc108 net863 net9 net3 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_96_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc119 net868 net848 net822 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__o21a_1
XANTENNA_clkbuf_leaf_1_clk_A clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c110_B1 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c86_B net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs746 clknet_leaf_38_clk net111 VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__dlclkp_1
XTAP_TAPCELL_ROW_24_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs757 clknet_leaf_5_clk net201 VGND VGND VPWR VPWR net662 net661 sky130_fd_sc_hd__dfxbp_1
XTAP_TAPCELL_ROW_52_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs768 net272 clknet_leaf_34_clk VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__dlxtn_1
Xs779 clknet_leaf_27_clk net304 VGND VGND VPWR VPWR net819 sky130_fd_sc_hd__dlclkp_2
Xclkbuf_0_net263 net263 VGND VGND VPWR VPWR clknet_0_net263 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net252 net252 VGND VGND VPWR VPWR clknet_0_net252 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net296 net296 VGND VGND VPWR VPWR clknet_0_net296 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc631 net799 net706 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__xnor2_4
Xc653 net546 net543 net534 VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__o21ai_2
Xc642 net534 net540 net537 VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__o21bai_2
Xc664 net565 net564 VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__xnor2_2
Xc686 clknet_leaf_11_clk clknet_1_1__leaf_net252 clknet_1_1__leaf_net805 clknet_1_1__leaf_net553
+ net567 net882 VGND VGND VPWR VPWR net593 net592 sky130_fd_sc_hd__sdfbbp_1
Xc675 clknet_leaf_10_clk net532 net544 clknet_1_1__leaf_net252 net534 net569 VGND
+ VGND VPWR VPWR net579 net578 sky130_fd_sc_hd__sdfbbn_1
Xc697 net547 net491 net548 net592 net905 VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__a41o_1
XFILLER_0_99_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net129 clknet_0_net129 VGND VGND VPWR VPWR clknet_1_0__leaf_net129
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c377_A3 net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c256_S0 net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net652 clknet_0_net652 VGND VGND VPWR VPWR clknet_1_0__leaf_net652
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c287_A3 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_334 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc450 net360 clknet_1_1__leaf_net271 VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__xnor2_2
Xc461 net384 clknet_1_0__leaf_net862 net905 net699 clknet_1_0__leaf_net833 net700
+ VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__mux4_1
Xc472 clknet_1_0__leaf_net396 net874 net776 VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__o21ba_2
XFILLER_0_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c298_B net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc79 net11 net14 VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__xor2_4
Xc68 net762 net1 net4 VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__a21boi_1
XANTENNA_c579_A1 net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout161_X net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c433_S1 clknet_1_0__leaf_net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net493 clknet_0_net493 VGND VGND VPWR VPWR clknet_1_0__leaf_net493
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_34_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c464_A4 net752 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c480_A3 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c608_S1 clknet_1_0__leaf_net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc280 clknet_leaf_0_clk net204 net80 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dfstp_1
Xc291 net232 net866 VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__xor2_4
XFILLER_0_46_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net807 net807 VGND VGND VPWR VPWR clknet_0_net807 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net818 net818 VGND VGND VPWR VPWR clknet_0_net818 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c565_A3 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_31_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c581_A2 clknet_1_0__leaf_net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c100_SET_B net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold47 net292 VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 net698 VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__dlygate4sd3_1
Xhold69 net855 VGND VGND VPWR VPWR net981 sky130_fd_sc_hd__dlygate4sd3_1
Xhold58 net447 VGND VGND VPWR VPWR net970 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c444_S0 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net290 clknet_0_net290 VGND VGND VPWR VPWR clknet_1_0__leaf_net290
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input51_A in54 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net403 clknet_0_net403 VGND VGND VPWR VPWR clknet_1_1__leaf_net403
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c666_A2 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c248_S1 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c264_S0 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout169_A net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net615 net615 VGND VGND VPWR VPWR clknet_0_net615 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c576_A2 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c209_X net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c439_S0 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_70_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net255 clknet_0_net255 VGND VGND VPWR VPWR clknet_1_1__leaf_net255
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c693_A0 net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c259_S0 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c392_D net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c706_S1 net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c722_S0 net714 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c159_X net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_33_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_33_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_36_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net401 net401 VGND VGND VPWR VPWR clknet_0_net401 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net412 net412 VGND VGND VPWR VPWR clknet_0_net412 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input14_A in20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c351_S1 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_24_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_24_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c561_SET_B net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c688_A0 net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net834 clknet_0_net834 VGND VGND VPWR VPWR clknet_1_0__leaf_net834
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net845 clknet_0_net845 VGND VGND VPWR VPWR clknet_1_0__leaf_net845
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_15_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_15_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_72_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c126_B net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c573_A3 net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc109 net45 net42 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net805_X clknet_1_1__leaf_net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input6_A in13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_B1 net714 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs747 clknet_leaf_36_clk net132 VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__dlclkp_2
Xs758 clknet_leaf_6_clk net205 VGND VGND VPWR VPWR net664 net663 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_91_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net253 net253 VGND VGND VPWR VPWR clknet_0_net253 sky130_fd_sc_hd__clkbuf_16
Xs769 net274 clknet_leaf_35_clk VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__dlxtn_2
Xclkbuf_0_net242 net242 VGND VGND VPWR VPWR clknet_0_net242 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net264 net264 VGND VGND VPWR VPWR clknet_0_net264 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc643 net539 net540 net531 net541 VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__a31o_2
Xc632 net530 net706 VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__xnor2_4
Xc654 net894 net536 net752 net552 clknet_1_1__leaf_net669 VGND VGND VPWR VPWR net553
+ sky130_fd_sc_hd__a41o_1
Xc676 clknet_1_1__leaf_net669 net720 net721 VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__o21bai_4
Xc698 clknet_leaf_12_clk net603 clknet_1_1__leaf_net589 net566 clknet_1_1__leaf_net553
+ net548 VGND VGND VPWR VPWR net606 net605 sky130_fd_sc_hd__sdfbbn_2
Xc687 net558 net572 net591 net587 net583 net551 VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__mux4_1
Xc665 clknet_leaf_10_clk net457 net561 net894 VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__sdfxtp_2
XFILLER_0_99_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input17_X net759 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c301_A0 net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c303_SCE net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_4_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_4_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_net653 clknet_0_net653 VGND VGND VPWR VPWR clknet_1_0__leaf_net653
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c468_SET_B net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c508_B net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c304_RESET_B net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc451 net12 net372 clknet_1_0__leaf_net264 net277 clknet_1_1__leaf_net271 net15 VGND
+ VGND VPWR VPWR net381 sky130_fd_sc_hd__mux4_1
Xc473 clknet_leaf_25_clk net299 net871 net393 net898 clknet_1_0__leaf_net300 VGND
+ VGND VPWR VPWR net405 net404 sky130_fd_sc_hd__sdfbbn_1
Xc440 net367 net358 net870 net691 net693 net694 VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__mux4_1
Xc462 net379 net116 VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__xor2_1
XFILLER_0_99_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_leaf_0_clk_A clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c253_RESET_B net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c714_S1 net567 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc69 net769 net771 VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__xor2_4
XFILLER_0_78_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_rebuffer4_A net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c708_RESET_B net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net629 clknet_0_net629 VGND VGND VPWR VPWR clknet_1_1__leaf_net629
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_2_3__f_clk_X clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc281 clknet_leaf_0_clk net770 net104 net204 net875 VGND VGND VPWR VPWR net225 net224
+ sky130_fd_sc_hd__sdfsbp_1
Xc270 net753 net931 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__xor2_2
Xc292 net227 net232 net233 net221 net812 net665 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__mux4_4
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c581_A3 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c709_S1 net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_363 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c725_S0 net714 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold37 net497 VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 net143 VGND VGND VPWR VPWR net960 sky130_fd_sc_hd__dlygate4sd3_1
Xhold59 net65 VGND VGND VPWR VPWR net971 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c62_S1 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c356_X net849 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c460_S0 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net280 clknet_0_net280 VGND VGND VPWR VPWR clknet_1_0__leaf_net280
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c672_SCD net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input44_A in48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c156_B net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c576_A3 net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_38_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c295_A4 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c455_S0 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input47_X net789 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net245 clknet_0_net245 VGND VGND VPWR VPWR clknet_1_1__leaf_net245
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net267 clknet_0_net267 VGND VGND VPWR VPWR clknet_1_1__leaf_net267
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net256 clknet_0_net256 VGND VGND VPWR VPWR clknet_1_1__leaf_net256
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c114_SET_B net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c259_S1 net660 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net805_X clknet_1_0__leaf_net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s759_Q net665 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net402 net402 VGND VGND VPWR VPWR clknet_0_net402 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output75_A net817 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net824 clknet_0_net824 VGND VGND VPWR VPWR clknet_1_0__leaf_net824
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net835 clknet_0_net835 VGND VGND VPWR VPWR clknet_1_0__leaf_net835
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net813 clknet_0_net813 VGND VGND VPWR VPWR clknet_1_0__leaf_net813
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_0_net580_A net580 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c698_SET_B net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c383_A net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_A1 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c269_X net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs748 clknet_leaf_33_clk net151 VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__dlclkp_4
XTAP_TAPCELL_ROW_52_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs759 clknet_leaf_1_clk net226 VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__dfxtp_4
XFILLER_0_91_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc600 net517 net820 net511 net512 net964 VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__a41oi_1
Xc644 net542 net529 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__xor2_2
Xc655 clknet_leaf_9_clk net450 net548 net552 net531 VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__sdfrtp_1
Xc633 net213 net305 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__xor2_4
Xc677 net550 clknet_1_1__leaf_net464 net534 net815 net904 VGND VGND VPWR VPWR net581
+ sky130_fd_sc_hd__a41oi_1
Xc666 net453 net881 net533 VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__a21boi_1
Xc688 net413 net536 net532 net585 net583 net592 VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__mux4_2
Xc699 net606 net547 net491 net93 net905 VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__a41oi_1
XFILLER_0_99_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output113_A net855 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c674_A3 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c699_B1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net632 clknet_0_net632 VGND VGND VPWR VPWR clknet_1_0__leaf_net632
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net654 clknet_0_net654 VGND VGND VPWR VPWR clknet_1_0__leaf_net654
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c131_A net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c728_S0 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_442 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc430 clknet_leaf_35_clk net354 net356 net359 net898 VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__sedfxtp_1
XFILLER_0_20_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc463 clknet_leaf_24_clk clknet_1_0__leaf_net300 net34 clknet_1_0__leaf_net377 VGND
+ VGND VPWR VPWR net393 sky130_fd_sc_hd__sdfxtp_1
Xc441 clknet_1_1__leaf_net152 net318 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__xnor2_2
Xc452 net359 clknet_leaf_22_clk net784 VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__dlrtn_1
XFILLER_0_20_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc474 clknet_leaf_22_clk clknet_1_1__leaf_net131 net405 clknet_1_1__leaf_net300 VGND
+ VGND VPWR VPWR net407 net406 sky130_fd_sc_hd__dfbbn_1
XFILLER_0_99_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_82_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_93_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_10_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c222_A0 net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c465_D net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c579_A3 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net473 clknet_0_net473 VGND VGND VPWR VPWR clknet_1_0__leaf_net473
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c134_X net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout147_X net889 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net619 clknet_0_net619 VGND VGND VPWR VPWR clknet_1_1__leaf_net619
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc271 net210 net889 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__xnor2_4
Xc260 net212 net198 net197 net195 net875 net871 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__mux4_1
Xc293 net759 net825 net80 net218 net907 net668 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__mux4_4
Xc282 net225 net799 net222 net221 net216 net901 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__mux4_1
XFILLER_0_47_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c681_SCE clknet_1_0__leaf_net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold27 net940 VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 net498 VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__dlygate4sd3_1
Xhold49 net558 VGND VGND VPWR VPWR net961 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c630_A net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c188_S0 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input37_A in41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c203_A2 net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c309_A clknet_1_0__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c455_S1 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c410_A0 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c633_X net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c235_S net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net268 clknet_0_net268 VGND VGND VPWR VPWR clknet_1_1__leaf_net268
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c320_B1 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c677_A3 net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c693_A2 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold45_A net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net403 net403 VGND VGND VPWR VPWR clknet_0_net403 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c324_SCD clknet_1_0__leaf_net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c108_A2 net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_2_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c405_A0 net332 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c99_A4 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_57_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c315_B1 net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c376_S0 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c688_A2 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_66_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_75_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c286_S0 net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_84_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c383_B net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_93_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs749 net161 clknet_leaf_34_clk VGND VGND VPWR VPWR net655 s749/Q_N sky130_fd_sc_hd__dlxbn_1
XFILLER_0_64_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net255 net255 VGND VGND VPWR VPWR clknet_0_net255 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_52_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc601 clknet_leaf_15_clk net870 net519 clknet_1_0__leaf_net818 clknet_1_0__leaf_net401
+ net511 VGND VGND VPWR VPWR net520 c601/Q_N sky130_fd_sc_hd__sdfbbp_1
Xc634 net306 net529 VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__xnor2_2
Xc645 net537 net539 VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc689 net239 net593 net919 net587 net927 net719 VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__mux4_1
Xc678 clknet_1_1__leaf_net581 net894 clknet_1_0__leaf_net577 VGND VGND VPWR VPWR net582
+ sky130_fd_sc_hd__o21bai_2
Xc656 clknet_leaf_10_clk net535 net551 net448 VGND VGND VPWR VPWR net556 net555 sky130_fd_sc_hd__sdfxbp_1
Xc667 net559 net561 net882 net535 net562 VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__a41o_1
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c288_Q net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_2_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_67_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c674_A4 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_max_cap142_X net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c527_SCD net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c131_B net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c402_A1 net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c84_B net752 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc420 net215 net909 net907 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__o21ai_2
XFILLER_0_20_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc442 net965 clknet_leaf_23_clk net865 VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__dlrtn_1
Xc464 clknet_1_1__leaf_net391 net34 net777 net752 net838 VGND VGND VPWR VPWR net817
+ sky130_fd_sc_hd__a41o_4
Xc431 clknet_leaf_3_clk net968 net318 net356 clknet_1_1__leaf_net256 VGND VGND VPWR
+ VPWR net361 sky130_fd_sc_hd__sedfxtp_4
Xc453 net358 net318 net379 net684 net695 VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__a41o_1
XFILLER_0_19_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc475 net407 clknet_1_1__leaf_net402 net298 VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__a21o_2
XANTENNA_c572_Q net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c682_SET_B net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input22_X net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c373_S1 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c564_S0 net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net485 clknet_0_net485 VGND VGND VPWR VPWR clknet_1_0__leaf_net485
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_34_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c458_S1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c132_A1 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clone15_X net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc250 net189 net182 net838 net868 net658 net659 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc272 net206 net879 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__xor2_4
Xc261 net871 net193 net928 net901 net660 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__a41oi_4
Xc294 net746 net789 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__xnor2_4
Xc283 net223 net216 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__xor2_2
XFILLER_0_99_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c217_A1 net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c289_A net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold28 net713 VGND VGND VPWR VPWR net940 sky130_fd_sc_hd__dlygate4sd3_1
Xhold39 net420 VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c630_B net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net271 clknet_0_net271 VGND VGND VPWR VPWR clknet_1_0__leaf_net271
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output98_A net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_90_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net629 net629 VGND VGND VPWR VPWR clknet_0_net629 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_16_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c240_RESET_B net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_leaf_36_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_36_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_39_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c677_A4 net815 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_leaf_27_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_27_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_43_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c442_RESET_B net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c693_A3 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_18_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_18_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout167_A net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c572_SCE net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c154_A net759 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c466_S1 net684 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c140_A1 net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c62_X net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_rebuffer25_X net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c315_A1 net759 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net859 clknet_0_net859 VGND VGND VPWR VPWR clknet_1_0__leaf_net859
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c554_SCE net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_7_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_7_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_0_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c241_A0 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c271_A net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_A3 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net245 net245 VGND VGND VPWR VPWR clknet_0_net245 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net256 net256 VGND VGND VPWR VPWR clknet_0_net256 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_52_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net267 net267 VGND VGND VPWR VPWR clknet_0_net267 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc602 clknet_1_1__leaf_net401 net520 clknet_1_0__leaf_net510 net144 net511 VGND VGND
+ VPWR VPWR net521 sky130_fd_sc_hd__a41o_2
Xc646 net541 net540 VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__xor2_2
Xc635 net435 net705 VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__xor2_4
Xc679 clknet_1_1__leaf_net582 net799 net720 VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__a21bo_4
Xc657 clknet_leaf_9_clk net552 net533 net549 VGND VGND VPWR VPWR net557 c657/Q_N sky130_fd_sc_hd__sdfxbp_1
Xc668 clknet_leaf_9_clk net439 net549 net534 net535 net567 VGND VGND VPWR VPWR net571
+ net570 sky130_fd_sc_hd__sdfbbn_1
XANTENNA_input12_A in19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c699_A2 net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c236_B1 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c297_S0 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c463_SCD net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input4_A in11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c379_Y net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc421 net768 net350 net889 VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__o21bai_1
Xc410 net208 net234 net330 net878 net217 net215 VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__mux4_4
Xc432 net356 net358 net359 net228 net912 clknet_1_1__leaf_net653 VGND VGND VPWR VPWR
+ net362 sky130_fd_sc_hd__mux4_4
Xc443 clknet_leaf_23_clk clknet_1_0__leaf_net366 net148 net144 net938 VGND VGND VPWR
+ VPWR net373 c443/Q_N sky130_fd_sc_hd__sdfrbp_1
XANTENNA_c454_SCD net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc454 clknet_leaf_22_clk clknet_1_1__leaf_net375 net785 clknet_1_0__leaf_net381 VGND
+ VGND VPWR VPWR net384 sky130_fd_sc_hd__sdfxtp_1
XFILLER_0_20_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc476 clknet_leaf_20_clk clknet_1_1__leaf_net381 net404 clknet_1_0__leaf_net824 VGND
+ VGND VPWR VPWR net836 net408 sky130_fd_sc_hd__dfbbn_1
Xc465 clknet_leaf_22_clk net776 net299 clknet_1_0__leaf_net835 net831 net957 VGND
+ VGND VPWR VPWR net395 net394 sky130_fd_sc_hd__sdfbbn_1
XANTENNA_c206_SCD net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c312_A2 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net464 clknet_0_net464 VGND VGND VPWR VPWR clknet_1_0__leaf_net464
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_34_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c127_Y net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c506_B net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c425_S net665 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc251 net7 net47 net63 net190 net117 net659 VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__mux4_2
Xc240 clknet_leaf_28_clk net178 net880 net846 VGND VGND VPWR VPWR net847 net181 sky130_fd_sc_hd__dfbbn_1
Xc262 net85 net871 net662 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__o21bai_4
XFILLER_0_20_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc273 net202 net82 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__xnor2_1
Xc295 net219 net774 net237 net878 clknet_1_0__leaf_net653 VGND VGND VPWR VPWR net238
+ sky130_fd_sc_hd__a41oi_1
XANTENNA_c323_A1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc284 clknet_leaf_1_clk net221 net227 net972 VGND VGND VPWR VPWR net229 net228 sky130_fd_sc_hd__sdfxbp_1
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c472_B1_N net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c575_S0 net417 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold29 net188 VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c289_B net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c568_D net417 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net250 clknet_0_net250 VGND VGND VPWR VPWR clknet_1_0__leaf_net250
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_78_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_rebuffer2_A net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c143_A1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_wire165_A net660 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net619 net619 VGND VGND VPWR VPWR clknet_0_net619 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c640_RESET_B net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c98_S0 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input42_A in46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c230_A2 net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c154_B net651 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c421_A1 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c315_A2 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input45_X net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net805 clknet_0_net805 VGND VGND VPWR VPWR clknet_1_0__leaf_net805
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_18_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c209_A3 net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c271_B net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c598_A4 net709 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c317_X net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net268 net268 VGND VGND VPWR VPWR clknet_0_net268 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc603 net475 clknet_1_1__leaf_net412 clknet_1_0__leaf_net862 VGND VGND VPWR VPWR net522
+ sky130_fd_sc_hd__a21oi_2
Xc636 net879 net705 VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__xor2_4
XFILLER_0_32_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc669 net571 net535 VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__xor2_2
Xc647 net538 net545 net540 VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__o21a_2
Xc658 clknet_leaf_9_clk net318 net544 net439 VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__sdfxtp_1
XFILLER_0_39_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c326_A1 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output73_A net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c342_A0 net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_max_cap128_X net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net635 clknet_0_net635 VGND VGND VPWR VPWR clknet_1_0__leaf_net635
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c267_X net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc400 clknet_leaf_1_clk net233 net872 net193 net825 net684 VGND VGND VPWR VPWR net329
+ c400/Q_N sky130_fd_sc_hd__sdfbbp_1
Xc411 net752 net956 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__xor2_1
Xc422 net351 net831 net350 net911 clknet_1_1__leaf_net653 VGND VGND VPWR VPWR net352
+ sky130_fd_sc_hd__a41oi_2
Xc433 net789 clknet_1_1__leaf_net256 net358 clknet_1_0__leaf_net352 net909 clknet_1_0__leaf_net669
+ VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__mux4_4
Xc455 net380 net217 net384 net777 net259 net907 VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__mux4_1
Xc444 net373 net229 net346 clknet_1_0__leaf_net352 net774 clknet_1_1__leaf_net152
+ VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__mux4_2
XPHY_EDGE_ROW_8_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc477 clknet_1_0__leaf_net402 net827 clknet_1_1__leaf_net290 net298 net393 VGND VGND
+ VPWR VPWR net830 sky130_fd_sc_hd__a41oi_1
Xc466 net874 net392 net173 clknet_1_1__leaf_net264 net394 net684 VGND VGND VPWR VPWR
+ net396 sky130_fd_sc_hd__mux4_2
XANTENNA_c206_SCE net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c312_A3 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c398_S0 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c222_A3 net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net465 clknet_0_net465 VGND VGND VPWR VPWR clknet_1_0__leaf_net465
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c281_SET_B net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c296_SET_B net758 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c675_SCE net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc230 net135 net141 net173 net924 net163 net171 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__mux4_2
Xc241 net816 net822 net54 net181 net650 net839 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__mux4_2
Xc252 clknet_leaf_0_clk net930 net211 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__dfrtn_1
Xc263 net194 net206 net203 net932 net867 net661 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__mux4_2
Xc296 clknet_leaf_36_clk net130 net758 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__dfstp_1
Xc274 clknet_leaf_39_clk net110 net210 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dfrtp_4
Xc285 net209 net197 net227 net225 net104 net665 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__mux4_1
XANTENNA_c323_A2 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge740 clknet_leaf_37_clk net133 net135 net136 net2 net139 VGND VGND VPWR VPWR
+ net646 net645 sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_83_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c575_S1 net714 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c591_S0 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c449_B net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net251 clknet_0_net251 VGND VGND VPWR VPWR clknet_1_0__leaf_net251
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net273 clknet_0_net273 VGND VGND VPWR VPWR clknet_1_0__leaf_net273
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c584_RESET_B net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c408_A2 net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c424_A1 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_98_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c593_SCD net752 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c423_Q net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c334_A1 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c336_SCD net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c228_A2 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c525_A0 net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c260_A0 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c410_A3 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input35_A in4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net238 clknet_0_net238 VGND VGND VPWR VPWR clknet_1_1__leaf_net238
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net249 clknet_0_net249 VGND VGND VPWR VPWR clknet_1_1__leaf_net249
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_97_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c318_SCD net759 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c426_D net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c255_B1 net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c405_A3 net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c464_X net817 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c548_SCD net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c165_B1 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_44_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net580 clknet_0_net580 VGND VGND VPWR VPWR clknet_1_1__leaf_net580
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c710_D net15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_62_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c416_A2 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc604 clknet_leaf_21_clk net513 net511 clknet_1_0__leaf_net818 net506 net243 VGND
+ VGND VPWR VPWR net523 c604/Q_N sky130_fd_sc_hd__sdfbbn_1
Xc637 net530 net881 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__xor2_4
XFILLER_0_4_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc659 net543 net555 net547 net882 VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__a31o_1
Xc648 net536 net432 net542 net535 net705 VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__a41o_2
XTAP_TAPCELL_ROW_73_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c432_A1 net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_80_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c326_A2 net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output66_A net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c342_A1 net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c699_A4 net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net669 clknet_0_net669 VGND VGND VPWR VPWR clknet_1_0__leaf_net669
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c236_A2 net174 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_S0 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_net669_A net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c427_X net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc412 clknet_leaf_5_clk net340 net336 net308 net330 net956 VGND VGND VPWR VPWR net342
+ net341 sky130_fd_sc_hd__sdfbbn_1
Xc401 net321 net315 net327 net829 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__a31oi_4
Xc423 clknet_leaf_3_clk net350 clknet_1_1__leaf_net256 clknet_1_0__leaf_net352 net967
+ VGND VGND VPWR VPWR net354 net353 sky130_fd_sc_hd__sedfxbp_2
Xc445 net266 clknet_1_0__leaf_net371 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__xnor2_4
Xc434 net785 net832 net361 net671 net687 net691 VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__mux4_2
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc467 clknet_1_1__leaf_net264 clknet_1_0__leaf_net391 net937 VGND VGND VPWR VPWR net397
+ sky130_fd_sc_hd__mux2_8
Xc478 net393 clknet_1_0__leaf_net403 net298 clknet_1_0__leaf_net402 clknet_1_1__leaf_net818
+ net404 VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__mux4_1
Xc456 net382 net384 net905 VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__o21bai_1
XANTENNA_c162_A1 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output104_A net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c353_A0 clknet_1_1__leaf_net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c528_B1 net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout135_A net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c649_Y net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc220 net30 net32 net158 net764 net777 net156 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__mux4_2
Xc242 net168 net838 net846 net182 net62 net181 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__mux4_1
Xc231 net55 net771 net9 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__o21ai_1
Xc253 clknet_leaf_0_clk net208 net211 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__dfrtp_1
Xc286 net222 net227 net215 net216 net871 net214 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__mux4_4
Xc297 net878 net911 net759 net912 net907 net666 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__mux4_1
Xc275 clknet_leaf_1_clk net108 net209 VGND VGND VPWR VPWR net217 net216 sky130_fd_sc_hd__dfsbp_2
Xc264 net213 net204 net885 net203 net74 net744 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_5_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c341_SET_B net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c233_A3 net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput1 in0 VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_67_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net263 clknet_0_net263 VGND VGND VPWR VPWR clknet_1_0__leaf_net263
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net252 clknet_0_net252 VGND VGND VPWR VPWR clknet_1_0__leaf_net252
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net296 clknet_0_net296 VGND VGND VPWR VPWR clknet_1_0__leaf_net296
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c511_B net415 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c504_A net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c274_RESET_B net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c424_A2 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c721_A0 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c143_A3 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c440_A1 net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_leaf_39_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_39_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_96_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c593_SCE net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c345_SCE clknet_1_0__leaf_net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c334_A2 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_90_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c281_SCD net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c336_SCE net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c280_SET_B net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c294_B net789 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c199_Q net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c451_A0 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input28_A in33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_97_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_87_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c318_SCE clknet_1_0__leaf_net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c329_A2 net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output96_A net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c557_SCE clknet_1_0__leaf_net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c239_A2 clknet_1_0__leaf_net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c64_B1 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_leaf_19_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c181_A0 net117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net807 clknet_0_net807 VGND VGND VPWR VPWR clknet_1_0__leaf_net807
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_18_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net818 clknet_0_net818 VGND VGND VPWR VPWR clknet_1_0__leaf_net818
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_97_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net581 clknet_0_net581 VGND VGND VPWR VPWR clknet_1_1__leaf_net581
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c257_B net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c152_A net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc605 net518 net475 clknet_1_0__leaf_net807 net704 net904 VGND VGND VPWR VPWR net524
+ sky130_fd_sc_hd__a41o_2
Xc649 net545 net542 net543 net540 VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__a31oi_4
XTAP_TAPCELL_ROW_73_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc638 net74 net534 VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c326_A3 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c342_A2 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net615 clknet_0_net615 VGND VGND VPWR VPWR clknet_1_0__leaf_net615
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c205_S0 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c696_SCD net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c533_A1 net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c427_A2 net752 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc402 net210 net330 net667 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__a21bo_1
XFILLER_0_20_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc446 clknet_leaf_23_clk net370 clknet_1_1__leaf_net152 net776 VGND VGND VPWR VPWR
+ net376 sky130_fd_sc_hd__sdfxtp_1
Xc435 net333 clknet_1_0__leaf_net250 net359 net831 net350 net358 VGND VGND VPWR VPWR
+ net365 sky130_fd_sc_hd__mux4_1
Xc413 net334 clknet_leaf_3_clk net774 VGND VGND VPWR VPWR net343 c413/Q_N sky130_fd_sc_hd__dlrbp_1
Xc424 net797 net215 clknet_1_0__leaf_net252 net873 VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__a31oi_4
Xc468 clknet_leaf_23_clk net397 clknet_1_1__leaf_net250 net784 clknet_1_0__leaf_net834
+ net906 VGND VGND VPWR VPWR net399 net398 sky130_fd_sc_hd__sdfbbp_1
Xc479 net898 net299 clknet_1_1__leaf_net834 net393 net408 net701 VGND VGND VPWR VPWR
+ net813 sky130_fd_sc_hd__mux4_4
Xc457 net384 net353 clknet_1_0__leaf_net375 clknet_1_0__leaf_net371 net696 net905
+ VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__mux4_1
XANTENNA_input10_A in17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c337_A2 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_max_cap133_X net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net412 clknet_0_net412 VGND VGND VPWR VPWR clknet_1_0__leaf_net412
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net401 clknet_0_net401 VGND VGND VPWR VPWR clknet_1_0__leaf_net401
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c234_D net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c263_A1 net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input2_A in1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc221 clknet_leaf_31_clk net162 net865 VGND VGND VPWR VPWR net166 net165 sky130_fd_sc_hd__dfrbp_1
Xc210 net105 net40 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__xor2_1
XFILLER_0_60_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input58_A in60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc243 clknet_leaf_28_clk net166 net25 net182 VGND VGND VPWR VPWR net184 c243/Q_N sky130_fd_sc_hd__dfbbn_1
Xc232 clknet_leaf_28_clk net43 net173 net25 clknet_1_1__leaf_net818 net804 VGND VGND
+ VPWR VPWR net810 net176 sky130_fd_sc_hd__sdfbbn_1
Xc254 clknet_leaf_0_clk net211 net208 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__dfrtp_2
Xc276 net106 net767 net887 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__o21ai_1
Xc265 net69 net895 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__xnor2_4
Xc287 net97 net227 net223 net208 net759 net889 VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__mux4_2
Xc298 net801 net909 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_5_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput2 in1 VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__buf_8
XANTENNA_c530_A2 net417 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net242 clknet_0_net242 VGND VGND VPWR VPWR clknet_1_0__leaf_net242
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c193_B1_N net760 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net253 clknet_0_net253 VGND VGND VPWR VPWR clknet_1_0__leaf_net253
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net264 clknet_0_net264 VGND VGND VPWR VPWR clknet_1_0__leaf_net264
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c258_A1 net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c424_A3 clknet_1_0__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c440_A2 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c184_B1 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold66_A net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c525_A2 net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c235_X net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c732_A0 net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c179_B1 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c329_A3 net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_output89_A net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c239_A3 net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c536_A1 net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput60 in7 VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_rebuffer3_X net915 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c114_RESET_B net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c165_A2 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input40_A in44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net252_X clknet_1_0__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c522_A3 net417 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c232_SET_B net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net582 clknet_0_net582 VGND VGND VPWR VPWR clknet_1_1__leaf_net582
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c152_B net760 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net238 net238 VGND VGND VPWR VPWR clknet_0_net238 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net249 net249 VGND VGND VPWR VPWR clknet_0_net249 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_71_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc606 net523 net514 net876 clknet_1_0__leaf_net524 net858 VGND VGND VPWR VPWR net525
+ sky130_fd_sc_hd__a41oi_4
XANTENNA_c713_A2 net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc639 net533 net305 VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_73_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c574_Y net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c311_S0 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c593_Q net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input43_X net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c205_S1 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c696_SCE net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c155_Y net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_leaf_18_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c315_X net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c427_A3 net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc403 net766 net750 net758 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__mux2_1
Xc425 net350 net873 net665 VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__mux2_2
Xc436 net789 net358 net799 clknet_1_1__leaf_net670 net691 VGND VGND VPWR VPWR net366
+ sky130_fd_sc_hd__a41oi_2
Xc414 net328 net342 net873 VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__a21oi_1
Xc447 clknet_1_0__leaf_net152 net690 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__xor2_4
Xc458 net372 net370 net358 net827 net384 net905 VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__mux4_1
Xc469 net399 net776 net858 VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__a21boi_1
XFILLER_0_87_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c341_Q net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net580 net580 VGND VGND VPWR VPWR clknet_0_net580 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c650_B1 net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net402 clknet_0_net402 VGND VGND VPWR VPWR clknet_1_0__leaf_net402
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c528_A2 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c263_A2 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c438_A2 net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc211 net143 net649 net651 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__mux2_2
Xc200 net134 net140 clknet_1_0__leaf_net652 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__a21boi_2
XFILLER_0_20_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_68_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc233 net984 net822 net804 net976 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__a31oi_1
Xc244 clknet_leaf_28_clk net182 net868 net954 VGND VGND VPWR VPWR net186 net185 sky130_fd_sc_hd__dfbbp_1
Xc222 net20 net163 net155 net804 net158 net655 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__mux4_1
XFILLER_0_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc266 net76 net895 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__xor2_4
Xc277 clknet_leaf_39_clk net218 net214 VGND VGND VPWR VPWR net220 net219 sky130_fd_sc_hd__dfsbp_1
Xc288 clknet_leaf_39_clk net214 net221 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__dfstp_4
Xc255 net194 net213 net889 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__o21ai_1
Xc299 net783 net878 clknet_1_0__leaf_net669 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__o21bai_1
XFILLER_0_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c348_A2 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput3 in10 VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_39_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout140_A net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c721_A2 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c375_A0 net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c228_X net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c285_A0 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c435_A3 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c732_A1 net567 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c314_S0 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c83_X net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_max_cap153_A net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c642_A1 net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c224_S0 clknet_1_1__leaf_net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput61 in8 VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__buf_4
Xinput50 in53 VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c400_SET_B net684 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c705_SCD net566 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c727_A1 net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c64_A2 net750 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c181_A2 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input33_A in38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c653_B1 net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c372_A1 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc607 clknet_leaf_19_clk clknet_1_1__leaf_net522 clknet_1_1__leaf_net525 net173 clknet_1_0__leaf_net818
+ net717 VGND VGND VPWR VPWR net527 net526 sky130_fd_sc_hd__sdfbbn_1
XTAP_TAPCELL_ROW_73_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c282_A1 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_40_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c457_A1 net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c176_A2 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c311_S1 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_leaf_20_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_20_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c91_B1 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input36_X net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_11_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_11_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_5_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout170_A net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net391 clknet_0_net391 VGND VGND VPWR VPWR clknet_1_1__leaf_net391
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c293_A0 net759 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc426 clknet_leaf_3_clk net211 net784 net356 clknet_1_0__leaf_net670 VGND VGND VPWR
+ VPWR net357 c426/Q_N sky130_fd_sc_hd__sedfxbp_1
Xc404 net193 net327 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__xor2_1
Xc415 net344 net873 net341 net685 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__a31oi_1
Xc437 clknet_leaf_3_clk clknet_1_0__leaf_net355 net361 net909 net691 VGND VGND VPWR
+ VPWR net367 sky130_fd_sc_hd__sedfxtp_1
Xc459 net386 net384 clknet_1_1__leaf_net131 clknet_1_1__leaf_net371 net905 net699
+ VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__mux4_1
Xc448 clknet_1_1__leaf_net371 net870 VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__xor2_4
XFILLER_0_99_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c322_S0 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net581 net581 VGND VGND VPWR VPWR clknet_0_net581 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_50_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_0_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_net403 clknet_0_net403 VGND VGND VPWR VPWR clknet_1_0__leaf_net403
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_0_net834_A net834 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c265_Y net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c438_A3 net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc201 clknet_leaf_37_clk net139 net133 clknet_1_0__leaf_net145 net142 VGND VGND VPWR
+ VPWR net147 net146 sky130_fd_sc_hd__sdfrbp_1
Xc212 net0 net903 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc245 net186 net847 net182 net149 net7 net816 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__mux4_1
Xc223 net164 net155 net158 net159 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__a31oi_4
Xc234 clknet_leaf_28_clk net827 net62 net25 net651 VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__sdfrtp_1
Xc278 net220 net82 net90 net80 net973 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__a41o_1
Xc267 net885 net743 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__xor2_4
Xc256 net80 net213 net194 net196 net70 net88 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__mux4_2
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc289 net104 net232 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_5_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output102_A net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c348_A3 net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_17_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput4 in11 VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_2_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net255 clknet_0_net255 VGND VGND VPWR VPWR clknet_1_0__leaf_net255
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c218_A net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_30_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_5_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c290_A1 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c375_A1 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c391_A0 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c541_A3 net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_87_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c168_A net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout136_X net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c179_A2 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c330_S0 net665 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_hold71_A net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c536_A3 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput40 in44 VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__buf_2
XFILLER_0_44_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput62 in9 VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__buf_8
Xinput51 in54 VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_12_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c571_D net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c64_A3 net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c150_S0 net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c181_A3 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c599_SET_B net714 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input26_A in31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c356_A3 net174 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c372_A2 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c547_A2 net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c406_RESET_B net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc608 net517 net516 clknet_1_0__leaf_net525 clknet_1_0__leaf_net522 net526 clknet_1_0__leaf_net818
+ VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__mux4_4
XFILLER_0_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c145_S0 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c75_A2 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone10 net74 net72 net754 net901 VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__a31oi_4
XFILLER_0_47_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_95_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input29_X net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net629 clknet_0_net629 VGND VGND VPWR VPWR clknet_1_0__leaf_net629
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold34_A net760 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net381 clknet_0_net381 VGND VGND VPWR VPWR clknet_1_1__leaf_net381
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout163_A net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c724_A3 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c203_X net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c293_A1 net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc427 net357 net752 net874 net356 VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__a31o_2
Xc405 net332 net330 net333 net889 net228 clknet_1_0__leaf_net669 VGND VGND VPWR VPWR
+ net334 sky130_fd_sc_hd__mux4_2
Xc416 net345 net328 net215 net330 net872 net686 VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__mux4_2
Xc438 net367 clknet_1_1__leaf_net355 net361 net902 net691 net692 VGND VGND VPWR VPWR
+ net368 sky130_fd_sc_hd__mux4_4
Xc449 net364 net354 VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_28_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c322_S1 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net582 net582 VGND VGND VPWR VPWR clknet_0_net582 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c659_B1 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c637_B net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c160_Y net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c569_A0 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c719_A3 net566 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c303_RESET_B net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc202 clknet_leaf_37_clk net138 net136 net142 clknet_1_0__leaf_net145 VGND VGND VPWR
+ VPWR net148 sky130_fd_sc_hd__sdfrtn_1
Xc235 net804 net63 net7 VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__mux2_2
Xc224 net157 net37 net144 net865 clknet_1_1__leaf_net818 net159 VGND VGND VPWR VPWR
+ net169 sky130_fd_sc_hd__mux4_1
Xc213 net154 net155 net912 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__mux2_1
XFILLER_0_20_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc246 clknet_leaf_29_clk net59 net848 net847 VGND VGND VPWR VPWR net189 net188 sky130_fd_sc_hd__sdfxbp_1
Xc279 net767 net215 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__xnor2_1
Xc257 net195 net212 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__xnor2_1
Xc268 net788 net753 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__xor2_4
XANTENNA_c470_A2 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c479_A0 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput5 in12 VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__buf_2
XFILLER_0_36_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c252_RESET_B net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net267 clknet_0_net267 VGND VGND VPWR VPWR clknet_1_0__leaf_net267
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net245 clknet_0_net245 VGND VGND VPWR VPWR clknet_1_0__leaf_net245
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net256 clknet_0_net256 VGND VGND VPWR VPWR clknet_1_0__leaf_net256
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_52 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c290_A2 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c270_X net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input56_A in59 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c168_B net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_35_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout129_X net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c78_A2 net15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_2_0__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_16_clk_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c330_S1 net855 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c69_X net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c431_DE net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput30 in35 VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput52 in55 VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__buf_1
Xinput41 in45 VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__buf_2
XFILLER_0_52_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c150_S1 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input19_A in25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c426_DE net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c372_A3 clknet_1_1__leaf_net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output87_A net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c251_S0 net117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer1_X net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone22 net888 VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_23_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c378_SCD net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net619 clknet_0_net619 VGND VGND VPWR VPWR clknet_1_0__leaf_net619
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net371 clknet_0_net371 VGND VGND VPWR VPWR clknet_1_1__leaf_net371
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout156_A net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c574_A1 clknet_1_0__leaf_net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c293_A2 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c521_SET_B net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc406 net234 clknet_leaf_2_clk net768 VGND VGND VPWR VPWR net335 c406/Q_N sky130_fd_sc_hd__dlrbn_1
Xc417 net342 net337 VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__xnor2_1
Xc428 net356 clknet_1_0__leaf_net252 net353 VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__a21oi_1
XFILLER_0_13_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc439 net354 net367 clknet_1_0__leaf_net366 net359 net911 net693 VGND VGND VPWR VPWR
+ net369 sky130_fd_sc_hd__mux4_4
XANTENNA_c590_A0 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input41_X net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_19_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c569_A1 clknet_1_0__leaf_net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_28_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc203 net141 net10 net144 net147 net884 net878 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_79_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc214 net923 net31 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__xnor2_4
Xc236 net57 net174 net838 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__o21ai_1
Xc225 net155 net40 net163 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__o21ba_2
XTAP_TAPCELL_ROW_92_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc247 clknet_leaf_29_clk net149 net941 net182 net185 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__sdfrtp_1
Xc269 net748 net207 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__xor2_4
Xc258 net751 net210 net194 net885 net197 net928 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_69_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs830 net640 clknet_leaf_18_clk VGND VGND VPWR VPWR net739 s830/Q_N sky130_fd_sc_hd__dlxbn_1
XFILLER_0_24_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net391 net391 VGND VGND VPWR VPWR clknet_0_net391 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_max_cap124_X net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput6 in13 VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_74_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net268 clknet_0_net268 VGND VGND VPWR VPWR clknet_1_0__leaf_net268
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_52_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c113_B net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c290_A3 net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c299_A1 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c481_A2 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input49_A in52 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c554_Q net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c391_A2 net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c682_Q_N net587 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c566_A2 net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c78_A3 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c708_SCD net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput20 in26 VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__buf_1
Xinput31 in36 VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput53 in56 VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__clkbuf_1
Xinput42 in46 VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__buf_4
XFILLER_0_101_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c557_D net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c577_A1 net861 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_32_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_32_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_35_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c226_X net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_23_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_23_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c517_Q net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net553 clknet_0_net553 VGND VGND VPWR VPWR clknet_1_1__leaf_net553
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c148_SCE net752 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c397_A1 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_14_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_14_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_56_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_73_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_leaf_15_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c243_RESET_B net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_84_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input31_A in36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c378_SCE net660 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_45 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c437_DE net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_3_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_3_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_clkbuf_2_2__f_clk_X clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c558_A3 net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout149_A net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c574_A2 net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc407 net329 net330 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__xor2_1
Xc418 net330 net347 net336 net210 net233 net685 VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__mux4_4
XFILLER_0_13_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap150 net14 VGND VGND VPWR VPWR net892 sky130_fd_sc_hd__buf_4
Xc429 net212 net356 net358 net873 net877 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__a41o_1
XANTENNA_c590_A1 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c650_A4 net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c347_S0 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input34_X net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c569_A2 net665 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c720_S0 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_79_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc215 net869 net149 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__xor2_4
Xc204 net140 net139 net146 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__a21boi_2
Xc226 net163 net166 net17 net657 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__a31o_4
XFILLER_0_60_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc237 clknet_leaf_28_clk net177 net971 net168 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__sdfxtp_1
Xc248 net190 net117 net182 net816 net876 net846 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__mux4_1
Xc259 net193 net928 net198 net212 net875 net660 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__mux4_2
XANTENNA_c167_S0 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xs820 net623 clknet_leaf_17_clk VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xs831 net641 clknet_leaf_18_clk VGND VGND VPWR VPWR net741 net740 sky130_fd_sc_hd__dlxbp_1
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net381 net381 VGND VGND VPWR VPWR clknet_0_net381 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput7 in14 VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c540_S0 net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c106_B net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c299_A2 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c596_A0 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c481_A3 net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc590 net171 net259 net714 VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__mux2_1
XFILLER_0_47_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_35_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_363 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c566_A3 net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout131_A net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c216_A net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_65_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c373_X net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_74_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c708_SCE net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c176_B1_N net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input61_A in8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_92_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput10 in17 VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__buf_8
XANTENNA_c683_A1 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput21 in27 VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__buf_1
Xinput32 in37 VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__clkbuf_4
Xinput43 in47 VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__clkbuf_2
Xinput54 in57 VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c173_B net651 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout134_X net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c81_Y net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c74_X net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net510 clknet_0_net510 VGND VGND VPWR VPWR clknet_1_1__leaf_net510
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net598 clknet_0_net598 VGND VGND VPWR VPWR clknet_1_1__leaf_net598
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c397_A2 net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c694_B1 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c563_A4 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c707_S1 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c723_S0 net915 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input24_A in3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c689_A0 net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c558_A4 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc408 net335 net902 net873 VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__a21oi_1
Xc419 net331 net338 net347 net872 net832 net685 VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__mux4_1
XANTENNA_c718_S0 net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap151 net6 VGND VGND VPWR VPWR net893 sky130_fd_sc_hd__buf_4
XFILLER_0_40_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net862_A net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c89_B net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c659_A3 net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_leaf_14_clk_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_29_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold32_A net714 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net131_X clknet_1_1__leaf_net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c569_A3 net858 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout161_A net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c585_A2 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c703_SET_B net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc205 net1 net147 net138 net149 net898 net865 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__mux4_1
Xc227 clknet_leaf_31_clk net159 net7 net165 net168 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__sdfrtp_1
XFILLER_0_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc216 net804 clknet_1_1__leaf_net652 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__xor2_4
XFILLER_0_60_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc238 net179 net158 net846 VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__a21o_2
Xc249 net167 net756 net840 VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__o21a_1
XANTENNA_c167_S1 net651 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c183_S0 net789 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs821 clknet_leaf_17_clk net624 VGND VGND VPWR VPWR net730 net729 sky130_fd_sc_hd__dfxbp_1
Xs832 net642 clknet_leaf_18_clk VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__dlxtn_1
Xs810 clknet_leaf_15_clk net501 VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__dlclkp_1
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net371 net371 VGND VGND VPWR VPWR clknet_0_net371 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput8 in15 VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_78_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c540_S1 net665 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c151_X net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout164_X net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c596_A1 net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c416_X net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c275_Q net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc591 net173 net243 net820 net876 net171 clknet_1_1__leaf_net401 VGND VGND VPWR VPWR
+ net510 sky130_fd_sc_hd__mux4_4
Xc580 clknet_leaf_15_clk clknet_1_0__leaf_net493 net950 net361 net200 VGND VGND VPWR
+ VPWR net500 sky130_fd_sc_hd__sdfrtp_1
XFILLER_0_37_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c697_B1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_35_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c551_S0 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput120 clknet_1_1__leaf_net862 VGND VGND VPWR VPWR out8 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_87_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input54_A in57 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c355_S1 net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net736 clknet_0_net736 VGND VGND VPWR VPWR clknet_1_1__leaf_net736
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c667_A3 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c580_SCD net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput22 in28 VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_40_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput11 in18 VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__buf_2
Xinput44 in48 VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__clkbuf_2
Xinput33 in38 VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput55 in58 VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c220_A0 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c571_SCD net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input57_X net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net522 clknet_0_net522 VGND VGND VPWR VPWR clknet_1_1__leaf_net522
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net577 clknet_0_net577 VGND VGND VPWR VPWR clknet_1_1__leaf_net577
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_223 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c283_B net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c723_S1 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c588_A2 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s769_Q net858 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_51_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c467_S net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input17_A in23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output85_A net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net131_X clknet_1_0__leaf_net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net352 clknet_0_net352 VGND VGND VPWR VPWR clknet_1_1__leaf_net352
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net396 clknet_0_net396 VGND VGND VPWR VPWR clknet_1_1__leaf_net396
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_71_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc409 net336 clknet_leaf_4_clk clknet_1_1__leaf_net683 VGND VGND VPWR VPWR net338
+ c409/Q_N sky130_fd_sc_hd__dlrbp_1
XFILLER_0_4_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap141 net884 VGND VGND VPWR VPWR net883 sky130_fd_sc_hd__buf_4
XFILLER_0_40_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input9_A in16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net553 net553 VGND VGND VPWR VPWR clknet_0_net553 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c686_RESET_B clknet_1_1__leaf_net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc206 clknet_leaf_36_clk clknet_1_1__leaf_net127 net148 net865 VGND VGND VPWR VPWR
+ net838 sky130_fd_sc_hd__sdfxtp_4
Xc217 net156 net756 net159 net155 clknet_1_1__leaf_net131 net158 VGND VGND VPWR VPWR
+ net161 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_92_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc239 net158 net47 clknet_1_0__leaf_net859 net756 net172 net816 VGND VGND VPWR VPWR
+ net180 sky130_fd_sc_hd__mux4_2
XFILLER_0_13_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc228 net163 net30 net158 net656 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__a31o_2
XTAP_TAPCELL_ROW_5_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs800 net440 clknet_leaf_4_clk VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__dlxtn_1
XTAP_TAPCELL_ROW_101_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs822 clknet_leaf_17_clk net628 VGND VGND VPWR VPWR net731 s822/Q_N sky130_fd_sc_hd__dfxbp_1
XFILLER_0_36_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_2_3__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs811 clknet_leaf_21_clk net515 VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__dlclkp_2
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c318_Q net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c374_S0 net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput9 in16 VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net238 clknet_0_net238 VGND VGND VPWR VPWR clknet_1_0__leaf_net238
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net249 clknet_0_net249 VGND VGND VPWR VPWR clknet_1_0__leaf_net249
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_30_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c189_A net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net818_A net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c596_A2 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c459_S0 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c117_A1 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_leaf_13_clk_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_leaf_28_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c308_A0 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc570 net217 clknet_1_0__leaf_net480 net491 VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__mux2_4
Xc581 net430 net497 clknet_1_0__leaf_net818 net216 net361 net715 VGND VGND VPWR VPWR
+ net501 sky130_fd_sc_hd__mux4_2
Xc592 net978 net508 net506 net906 VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__a31oi_4
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c697_A1 net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_35_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c551_S1 clknet_1_0__leaf_net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c350_SCE net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_43_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput110 net852 VGND VGND VPWR VPWR out54 sky130_fd_sc_hd__buf_2
XFILLER_0_42_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput121 net863 VGND VGND VPWR VPWR out9 sky130_fd_sc_hd__buf_2
XFILLER_0_2_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_35_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_35_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_92_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net580 clknet_0_net580 VGND VGND VPWR VPWR clknet_1_0__leaf_net580
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input47_A in50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c310_A1 net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_leaf_26_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_26_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c580_SCE net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput12 in19 VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_40_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput34 in39 VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__clkbuf_8
Xinput45 in49 VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__clkbuf_2
Xinput23 in29 VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__buf_1
XFILLER_0_12_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput56 in59 VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__buf_2
XFILLER_0_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_17_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_17_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_90_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c588_B1_N net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net589 clknet_0_net589 VGND VGND VPWR VPWR clknet_1_1__leaf_net589
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_6_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_6_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c171_A net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c231_B1 net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c269_A net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c292_S0 net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclone15 net77 VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c232_SCD net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c316_A0 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_output78_A net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net375 clknet_0_net375 VGND VGND VPWR VPWR clknet_1_1__leaf_net375
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_71_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmax_cap142 net78 VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c287_S0 net759 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap153 net74 VGND VGND VPWR VPWR net895 sky130_fd_sc_hd__buf_4
XFILLER_0_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c174_X net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s781_Q net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net510 net510 VGND VGND VPWR VPWR clknet_0_net510 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net598 net598 VGND VGND VPWR VPWR clknet_0_net598 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output116_A net858 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_81_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c253_D net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout147_A net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc207 net4 net137 net120 net2 net782 clknet_1_0__leaf_net654 VGND VGND VPWR VPWR net152
+ sky130_fd_sc_hd__mux4_4
XFILLER_0_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc218 net126 net159 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_92_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc229 net160 net158 net159 net171 net170 net30 VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__mux4_2
XANTENNA_c291_X net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c403_A1 net750 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs823 clknet_leaf_15_clk net630 VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__dfxtp_1
Xs812 clknet_leaf_18_clk net528 VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__dlclkp_4
Xs801 net441 clknet_leaf_4_clk VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__dlxtn_1
XTAP_TAPCELL_ROW_101_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc730 net618 net786 clknet_1_1__leaf_net635 clknet_1_1__leaf_net632 clknet_1_1__leaf_net736
+ net739 VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__mux4_4
XANTENNA_input32_X net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c313_A1 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c565_S0 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c596_A3 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c308_A1 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc571 clknet_leaf_14_clk net875 net430 net948 VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__sdfxtp_2
Xc582 clknet_leaf_15_clk net499 clknet_1_1__leaf_net480 net939 VGND VGND VPWR VPWR
+ net502 c582/Q_N sky130_fd_sc_hd__dfbbn_1
Xc560 net469 net442 net882 VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__o21bai_1
Xc593 clknet_leaf_20_clk clknet_1_0__leaf_net813 clknet_1_0__leaf_net807 net752 net865
+ net939 VGND VGND VPWR VPWR net808 net512 sky130_fd_sc_hd__sdfbbn_1
XPHY_EDGE_ROW_16_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput100 net842 VGND VGND VPWR VPWR out45 sky130_fd_sc_hd__buf_2
XFILLER_0_42_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput111 net853 VGND VGND VPWR VPWR out55 sky130_fd_sc_hd__buf_2
XFILLER_0_10_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_43_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net581 clknet_0_net581 VGND VGND VPWR VPWR clknet_1_0__leaf_net581
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c378_Q net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_61_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput13 in2 VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_40_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput35 in4 VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput46 in5 VGND VGND VPWR VPWR net788 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput24 in3 VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__clkbuf_1
Xinput57 in6 VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__buf_12
XFILLER_0_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc390 net309 net310 net872 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__a21bo_4
XTAP_TAPCELL_ROW_48_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_leaf_12_clk_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c214_A net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_27_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_2_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
XANTENNA_c130_A2 net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c139_A0 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c305_A2 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net524 clknet_0_net524 VGND VGND VPWR VPWR clknet_1_1__leaf_net524
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c694_A3 net567 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c221_RESET_B net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c171_B net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c292_S1 net665 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net736 net736 VGND VGND VPWR VPWR clknet_0_net736 sky130_fd_sc_hd__clkbuf_16
Xclone16 net83 VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__clkbuf_1
XANTENNA_fanout132_X net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c232_SCE clknet_1_1__leaf_net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input62_X net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c316_A1 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c689_A3 net587 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap143 net207 VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__buf_4
XANTENNA_c287_S1 net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap154 net73 VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__buf_2
XANTENNA_s781_Q_N net684 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net522 net522 VGND VGND VPWR VPWR clknet_0_net522 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net577 net577 VGND VGND VPWR VPWR clknet_0_net577 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c478_S0 clknet_1_1__leaf_net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input22_A in28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c327_A0 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c691_A4 clknet_1_1__leaf_net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c388_S0 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output90_A net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_53_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc208 net838 net94 clknet_1_0__leaf_net654 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__o21ba_2
XFILLER_0_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc219 net838 net648 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_5_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c700_B1 net677 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs813 net573 clknet_leaf_11_clk VGND VGND VPWR VPWR net720 net719 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_83_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs824 clknet_leaf_17_clk net633 VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_76_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xs802 net455 clknet_leaf_13_clk VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__dlxtn_1
XTAP_TAPCELL_ROW_101_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net352 net352 VGND VGND VPWR VPWR clknet_0_net352 sky130_fd_sc_hd__clkbuf_16
XANTENNA_clone15_A net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net396 net396 VGND VGND VPWR VPWR clknet_0_net396 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c206_Q net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc731 net507 clknet_1_0__leaf_net635 clknet_1_1__leaf_net629 clknet_1_0__leaf_net736
+ net738 net741 VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__mux4_2
Xc720 clknet_1_0__leaf_net629 clknet_1_1__leaf_net510 net617 net526 net799 net730
+ VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__mux4_2
XANTENNA_c313_A2 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_78_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c581_S0 net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c137_Y net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c411_A net752 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c605_B1 net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc572 clknet_leaf_16_clk net970 clknet_1_0__leaf_net493 net430 VGND VGND VPWR VPWR
+ net811 sky130_fd_sc_hd__sdfxtp_1
Xc561 clknet_leaf_13_clk net479 clknet_1_0__leaf_net480 clknet_1_0__leaf_net473 net428
+ net353 VGND VGND VPWR VPWR net483 net482 sky130_fd_sc_hd__sdfbbn_1
Xc550 net758 net467 net709 VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__o21bai_2
Xc583 net463 net353 net714 VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__a21boi_2
Xc594 net784 net509 net400 net243 net908 net511 VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__mux4_1
XANTENNA_c340_A0 net174 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c697_A3 net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput101 net843 VGND VGND VPWR VPWR out46 sky130_fd_sc_hd__buf_2
XFILLER_0_88_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput112 net854 VGND VGND VPWR VPWR out56 sky130_fd_sc_hd__buf_2
XANTENNA_c576_S0 net428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout162_X net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net582 clknet_0_net582 VGND VGND VPWR VPWR clknet_1_0__leaf_net582
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c144_A1 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c160_B1 net651 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c319_A1 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput36 in40 VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__clkbuf_4
Xinput14 in20 VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__clkbuf_8
Xinput25 in30 VGND VGND VPWR VPWR net767 sky130_fd_sc_hd__buf_1
Xinput58 in60 VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__clkbuf_1
Xinput47 in50 VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__buf_4
XFILLER_0_52_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc380 net885 net73 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__xor2_4
Xc391 net85 net309 net316 net315 net910 net872 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__mux4_1
XFILLER_0_35_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c220_A3 net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout122_A net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c130_A3 net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c531_X net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input52_A in55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c305_A3 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c240_SET_B net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net525 clknet_0_net525 VGND VGND VPWR VPWR clknet_1_1__leaf_net525
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c231_A2 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c141_A2 net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input55_X net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net300 clknet_0_net300 VGND VGND VPWR VPWR clknet_1_1__leaf_net300
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net355 clknet_0_net355 VGND VGND VPWR VPWR clknet_1_1__leaf_net355
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_clkbuf_leaf_11_clk_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net366 clknet_0_net366 VGND VGND VPWR VPWR clknet_1_1__leaf_net366
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net377 clknet_0_net377 VGND VGND VPWR VPWR clknet_1_1__leaf_net377
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_71_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_26_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap133 net196 VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__buf_4
Xmax_cap155 net72 VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__buf_4
XFILLER_0_40_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap166 net815 VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__buf_4
XFILLER_0_96_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c242_A1 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c379_B net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c658_D net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s767_Q net855 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c327_X net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net589 net589 VGND VGND VPWR VPWR clknet_0_net589 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c433_A0 net789 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input15_A in21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_output83_A net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap138_X net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net152 clknet_0_net152 VGND VGND VPWR VPWR clknet_1_1__leaf_net152
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc209 net153 net139 clknet_1_0__leaf_net152 net144 net140 clknet_1_1__leaf_net654
+ VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_92_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c695_B1_N net752 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input7_A in14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c700_A1 net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs814 net574 clknet_leaf_11_clk VGND VGND VPWR VPWR net721 s814/Q_N sky130_fd_sc_hd__dlxbn_1
Xs825 clknet_leaf_18_clk net634 VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__dfxtp_1
Xs803 net456 clknet_leaf_4_clk VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__dlxtp_1
XTAP_TAPCELL_ROW_101_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c428_B1 net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net375 net375 VGND VGND VPWR VPWR clknet_0_net375 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c213_S net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc721 net777 clknet_1_0__leaf_net580 net876 net617 net722 net731 VGND VGND VPWR VPWR
+ net632 sky130_fd_sc_hd__mux4_2
Xc710 clknet_leaf_16_clk net15 clknet_1_0__leaf_net619 net977 net93 net608 VGND VGND
+ VPWR VPWR net621 net620 sky130_fd_sc_hd__sdfbbn_1
Xc732 net786 net567 net620 net503 clknet_1_0__leaf_net736 net740 VGND VGND VPWR VPWR
+ net643 sky130_fd_sc_hd__mux4_2
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input18_X net760 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c338_B1 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_38_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_38_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c149_Q net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c308_A3 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc540 net315 net96 net777 net316 net346 net665 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__mux4_4
Xc562 clknet_leaf_13_clk clknet_1_0__leaf_net480 net481 net864 net482 clknet_1_0__leaf_net669
+ VGND VGND VPWR VPWR net484 c562/Q_N sky130_fd_sc_hd__sdfbbp_1
Xc573 net429 net361 net354 net417 VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__a31oi_1
Xc551 net415 net462 net894 net446 net882 clknet_1_0__leaf_net464 VGND VGND VPWR VPWR
+ net470 sky130_fd_sc_hd__mux4_2
Xc595 clknet_leaf_22_clk net383 clknet_1_1__leaf_net396 net511 clknet_1_0__leaf_net821
+ VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__sdfrtp_1
Xc584 clknet_leaf_14_clk net500 net354 net499 VGND VGND VPWR VPWR net504 c584/Q_N
+ sky130_fd_sc_hd__dfbbn_1
XANTENNA_c340_A1 net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_leaf_29_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_29_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_86_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c576_S1 net714 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput113 net855 VGND VGND VPWR VPWR out57 sky130_fd_sc_hd__buf_2
XFILLER_0_2_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput102 net844 VGND VGND VPWR VPWR out47 sky130_fd_sc_hd__buf_2
XFILLER_0_10_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c142_X net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_98_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c144_A2 net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c319_A2 net750 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput15 in21 VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__buf_1
Xinput37 in41 VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_40_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput26 in31 VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput59 in61 VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__clkbuf_2
Xinput48 in51 VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_24_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c396_S1 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc381 net744 net916 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__xor2_4
Xc392 clknet_leaf_4_clk net316 net872 net927 clknet_1_0__leaf_net683 VGND VGND VPWR
+ VPWR net320 sky130_fd_sc_hd__sdfstp_1
XTAP_TAPCELL_ROW_48_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c556_SCE net758 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c526_A0 net428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_leaf_9_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_9_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_61_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c261_B1 net660 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s797_Q net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net391 clknet_0_net391 VGND VGND VPWR VPWR clknet_1_0__leaf_net391
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c305_A4 net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input45_A in49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout170 net785 VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__buf_4
XFILLER_0_88_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c710_SCE net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap168_X net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_84_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_1_1__f_net669_X clknet_1_1__leaf_net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c256_A0 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c422_A2 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c141_A3 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_49_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_58_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c690_S0 net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net378 clknet_0_net378 VGND VGND VPWR VPWR clknet_1_1__leaf_net378
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_71_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c226_A3 net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c523_A1 net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c242_A2 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c441_B net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net524 net524 VGND VGND VPWR VPWR clknet_0_net524 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c327_A2 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output76_A clknet_1_0__leaf_net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c601_SCD clknet_1_0__leaf_net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net131 clknet_0_net131 VGND VGND VPWR VPWR clknet_1_1__leaf_net131
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c668_SCD net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c579_S1 net714 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_92_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_69_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c172_X net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs815 net594 clknet_leaf_17_clk VGND VGND VPWR VPWR net723 net722 sky130_fd_sc_hd__dlxbp_1
Xs804 net458 clknet_leaf_10_clk VGND VGND VPWR VPWR net809 sky130_fd_sc_hd__lpflow_inputisolatch_1
XTAP_TAPCELL_ROW_101_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs826 clknet_leaf_18_clk net636 VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__dlclkp_1
XFILLER_0_91_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c147_A2 net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_leaf_10_clk_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c62_A0 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc711 clknet_leaf_11_clk clknet_1_1__leaf_net553 net614 clknet_1_1__leaf_net615 clknet_1_1__leaf_net619
+ net982 VGND VGND VPWR VPWR net622 c711/Q_N sky130_fd_sc_hd__sdfbbn_1
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc722 net631 net503 net621 net171 net714 net715 VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__mux4_4
Xc700 net148 net606 net871 net93 net677 VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__a41oi_4
Xc733 net527 net503 net906 net735 clknet_1_1__leaf_net736 net737 VGND VGND VPWR VPWR
+ net644 sky130_fd_sc_hd__mux4_2
XANTENNA_c163_A1 net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c296_Q net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_leaf_25_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output114_A net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_78_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c248_A1 net117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c439_A0 net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c85_A net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c605_A2 net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc530 net444 net417 net421 net708 VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__a31o_1
Xc563 net476 net484 net481 net446 clknet_1_0__leaf_net480 VGND VGND VPWR VPWR net485
+ sky130_fd_sc_hd__a41o_4
Xc552 clknet_leaf_13_clk clknet_1_1__leaf_net470 net864 net466 clknet_1_1__leaf_net352
+ VGND VGND VPWR VPWR net472 net471 sky130_fd_sc_hd__sdfrbp_1
Xc541 net454 net445 net444 net447 net708 net710 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__mux4_1
Xc574 clknet_1_0__leaf_net464 net447 net811 VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__o21bai_1
Xc585 net502 net903 net497 VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__o21ba_1
Xc596 net259 net94 net446 net865 clknet_1_0__leaf_net401 net474 VGND VGND VPWR VPWR
+ net515 sky130_fd_sc_hd__mux4_2
XFILLER_0_47_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c340_A2 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c203_S0 net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c685_B1_N net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput114 net856 VGND VGND VPWR VPWR out58 sky130_fd_sc_hd__buf_2
Xoutput103 clknet_1_1__leaf_net845 VGND VGND VPWR VPWR out48 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net377_A net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c668_SET_B net567 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c250_A2 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout148_X net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s742_Q net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_12_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_98_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c160_A2 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_30_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c88_X net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput16 in22 VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_12_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput27 in32 VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_24_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput49 in52 VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput38 in42 VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc382 net309 net663 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__xor2_2
XANTENNA_c351_A1 net174 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc393 net308 net309 net315 net872 net664 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__a41oi_4
XFILLER_0_74_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c229_A3 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_0__f_net669_X clknet_1_0__leaf_net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c261_A1 net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c631_A net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c545_SET_B net709 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net381 clknet_0_net381 VGND VGND VPWR VPWR clknet_1_0__leaf_net381
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c717_A0 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c436_A1 net789 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c155_A2 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input38_A in42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout160 net71 VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__buf_12
XFILLER_0_88_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c346_A1 net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc190 net115 net126 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__xnor2_4
XFILLER_0_85_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c212_A net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c465_SCE net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone1 net755 net744 VGND VGND VPWR VPWR net985 sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c403_S net758 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_50_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_72_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c690_S1 net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap124 net202 VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_40_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap168 net70 VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__buf_4
XANTENNA_c523_A2 net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net525 net525 VGND VGND VPWR VPWR clknet_0_net525 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c686_SCE net567 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c433_A2 net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c730_A0 net618 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c299_B1_N clknet_1_0__leaf_net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c327_A3 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output69_A net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c518_A2 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c700_A3 net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_77_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs816 net597 clknet_leaf_12_clk VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__dlxtn_1
Xs805 clknet_leaf_14_clk net486 VGND VGND VPWR VPWR net711 s805/Q_N sky130_fd_sc_hd__dfxbp_1
XTAP_TAPCELL_ROW_101_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs827 clknet_leaf_17_clk net637 VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__dlclkp_2
Xclkbuf_0_net300 net300 VGND VGND VPWR VPWR clknet_0_net300 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net366 net366 VGND VGND VPWR VPWR clknet_0_net366 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c428_A2 clknet_1_0__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net355 net355 VGND VGND VPWR VPWR clknet_0_net355 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net377 net377 VGND VGND VPWR VPWR clknet_0_net377 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c62_A1 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc712 net602 net815 net605 clknet_1_1__leaf_net615 clknet_1_1__leaf_net619 net727
+ VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__mux4_4
XPHY_EDGE_ROW_86_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc701 net608 net548 net903 net605 net595 VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__a41oi_2
Xc734 net643 net644 net908 net734 clknet_1_0__leaf_net736 net742 VGND VGND VPWR VPWR
+ net837 sky130_fd_sc_hd__mux4_2
Xc723 net627 net579 net566 net867 net915 net876 VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__mux4_1
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input20_A in26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_95_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output107_A net849 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c338_A2 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_504 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c509_D net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c316_S net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net152 net152 VGND VGND VPWR VPWR clknet_0_net152 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_64_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc520 clknet_leaf_8_clk net426 net425 net423 VGND VGND VPWR VPWR net434 net433 sky130_fd_sc_hd__sdfxbp_1
XFILLER_0_20_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc531 net431 net661 net708 VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__a21o_2
Xc564 net483 net346 clknet_1_0__leaf_net485 clknet_1_1__leaf_net352 net474 net692
+ VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__mux4_4
Xc553 net421 net469 clknet_1_0__leaf_net470 net891 VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__a31oi_2
Xc542 net449 net457 net894 net447 net708 net710 VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__mux4_1
Xc586 net811 net903 net716 VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__a21bo_2
Xc575 net269 net784 net490 net870 net417 net714 VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__mux4_4
Xc597 clknet_1_1__leaf_net377 clknet_1_0__leaf_net412 net870 clknet_1_1__leaf_net401
+ net709 VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__a41o_2
XANTENNA_c568_SCD net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c203_S1 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput104 net846 VGND VGND VPWR VPWR out49 sky130_fd_sc_hd__buf_2
Xoutput115 net857 VGND VGND VPWR VPWR out59 sky130_fd_sc_hd__buf_2
XFILLER_0_100_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_leaf_24_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c706_A2 net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_39_clk_A clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c160_A3 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput17 in23 VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_40_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput28 in33 VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput39 in43 VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc372 net66 net771 net816 clknet_1_1__leaf_net818 net822 net846 VGND VGND VPWR VPWR
+ net301 sky130_fd_sc_hd__mux4_4
Xc350 clknet_leaf_25_clk net282 net959 clknet_1_0__leaf_net860 net865 net679 VGND
+ VGND VPWR VPWR net294 c350/Q_N sky130_fd_sc_hd__sdfbbn_1
XANTENNA_c693_S1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc394 net310 net320 net872 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__a21oi_2
Xc383 net306 net209 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__xor2_4
XANTENNA_c351_A2 net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c655_RESET_B net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c526_A2 net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c245_A3 net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout160_X net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net371 clknet_0_net371 VGND VGND VPWR VPWR clknet_1_0__leaf_net371
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c717_A1 net566 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_587 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c436_A2 net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c155_A3 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c602_A4 net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout161 net913 VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__buf_4
XFILLER_0_88_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c346_A2 net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output99_A net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc180 net119 net791 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__xor2_1
Xc191 net124 net133 net880 net892 net935 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__a41oi_2
XFILLER_0_85_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c349_RESET_B net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c212_B net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c553_B1 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c422_A4 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone2 net902 net910 VGND VGND VPWR VPWR net986 sky130_fd_sc_hd__xnor2_1
XFILLER_0_81_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_50_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_rebuffer23_A net890 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input50_A in53 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c392_SCE net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_10_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_10_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_13_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap125 net202 VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__buf_4
XFILLER_0_52_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout123_X net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c714_A2 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c730_A1 net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c234_Q net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c312_S0 net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c550_A1 net758 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c272_A net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c700_A4 net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c709_A2 net618 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs806 clknet_leaf_14_clk net487 VGND VGND VPWR VPWR net712 s806/Q_N sky130_fd_sc_hd__dfxbp_1
XTAP_TAPCELL_ROW_101_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs828 clknet_leaf_18_clk net638 VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__dlclkp_4
Xs817 net599 clknet_leaf_12_clk VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_48_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net378 net378 VGND VGND VPWR VPWR clknet_0_net378 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc713 net622 clknet_1_1__leaf_net615 net547 clknet_1_0__leaf_net619 net697 net728
+ VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__mux4_1
Xc702 clknet_leaf_16_clk net590 net608 clknet_1_0__leaf_net589 net944 VGND VGND VPWR
+ VPWR net610 sky130_fd_sc_hd__sdfstp_1
XANTENNA_c444_A2 net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc724 net527 clknet_1_0__leaf_net632 clknet_1_1__leaf_net510 net826 net715 net732
+ VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__mux4_1
XFILLER_0_98_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input13_A in2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c338_A3 net174 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_26 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c217_S0 clknet_1_1__leaf_net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c529_A2 net415 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net859_X clknet_1_0__leaf_net859 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c248_A3 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input5_A in12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net131 net131 VGND VGND VPWR VPWR clknet_0_net131 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_64_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c211_S net651 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c455_A1 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc510 clknet_leaf_7_clk net415 net975 net416 VGND VGND VPWR VPWR net421 net420 sky130_fd_sc_hd__sdfxbp_2
Xc521 clknet_leaf_8_clk net434 net966 net427 net311 net430 VGND VGND VPWR VPWR net436
+ net435 sky130_fd_sc_hd__sdfbbn_2
Xc543 clknet_leaf_10_clk net416 net449 net710 VGND VGND VPWR VPWR net460 net459 sky130_fd_sc_hd__dfbbn_1
XTAP_TAPCELL_ROW_9_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_496 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc532 clknet_leaf_7_clk net308 net864 net443 VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__sdfxtp_2
Xc554 clknet_leaf_12_clk net472 clknet_1_1__leaf_net465 net864 net94 net469 VGND VGND
+ VPWR VPWR net475 net474 sky130_fd_sc_hd__sdfbbn_2
Xc565 clknet_1_1__leaf_net485 net316 net482 net908 net216 net711 VGND VGND VPWR VPWR
+ net487 sky130_fd_sc_hd__mux4_1
Xc587 clknet_leaf_15_clk net505 net504 clknet_1_0__leaf_net378 VGND VGND VPWR VPWR
+ net820 net506 sky130_fd_sc_hd__dfbbp_1
Xc598 net446 net489 net906 net709 net714 VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__a41o_1
Xc576 clknet_1_1__leaf_net378 net811 net446 net144 net428 net714 VGND VGND VPWR VPWR
+ net496 sky130_fd_sc_hd__mux4_2
XANTENNA_c568_SCE net709 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input16_X net758 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c599_RESET_B net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput105 net847 VGND VGND VPWR VPWR out5 sky130_fd_sc_hd__buf_2
Xoutput116 net858 VGND VGND VPWR VPWR out6 sky130_fd_sc_hd__buf_2
XFILLER_0_56_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net553 clknet_0_net553 VGND VGND VPWR VPWR clknet_1_0__leaf_net553
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_500 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c410_S0 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c664_Y net566 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input8_X net750 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c466_A0 net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput18 in24 VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_40_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput29 in34 VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_24_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc373 net184 net173 net822 net903 net828 net840 VGND VGND VPWR VPWR net856 sky130_fd_sc_hd__mux4_2
Xc340 net174 net871 net784 clknet_1_1__leaf_net859 net673 net855 VGND VGND VPWR VPWR
+ net283 sky130_fd_sc_hd__mux4_2
Xc351 net294 net174 net825 net170 net261 net903 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc384 net198 net310 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__xor2_1
Xc395 net320 net311 net321 net312 net313 net314 VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__mux4_2
XFILLER_0_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_hold69_A net855 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c526_A3 net660 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_97_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c238_X net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c717_A2 net567 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c436_A3 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c468_SCD net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout140 net413 VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__clkbuf_8
Xfanout162 net809 VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_17_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c431_Q net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c196_B1 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c93_X net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc170 net112 net758 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__xor2_4
Xc181 net117 net119 net898 net798 net0 net877 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__mux4_2
Xc192 net107 net134 net936 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__o21ai_2
XFILLER_0_18_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_23_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_leaf_38_clk_A clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c698_SCD net566 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclone3 net71 VGND VGND VPWR VPWR net987 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c166_A3 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_18_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c182_A2 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input43_A in47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c654_B1 clknet_1_1__leaf_net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c373_A1 net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap166_X net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c149_Q_N net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c604_SCD clknet_1_0__leaf_net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net860 clknet_0_net860 VGND VGND VPWR VPWR clknet_1_1__leaf_net860
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c601_D net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c714_A3 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c103_X net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s808_Q net714 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c73_B1_N net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c312_S1 clknet_1_0__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c92_B1 net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c604_SET_B net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c193_A1 net750 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net145 clknet_0_net145 VGND VGND VPWR VPWR clknet_1_1__leaf_net145
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c518_A4 net415 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c272_B net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c559_B1 net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs807 clknet_leaf_14_clk net488 VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_101_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs818 net600 clknet_leaf_17_clk VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__dlxtn_1
Xs829 net639 clknet_leaf_18_clk VGND VGND VPWR VPWR net738 s829/Q_N sky130_fd_sc_hd__dlxbn_1
XFILLER_0_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c62_A3 net783 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc703 clknet_leaf_12_clk net604 clknet_1_1__leaf_net465 net318 net93 net547 VGND VGND
+ VPWR VPWR net612 net611 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc725 net626 net621 clknet_1_0__leaf_net635 net587 net714 net732 VGND VGND VPWR VPWR
+ net636 sky130_fd_sc_hd__mux4_2
Xc714 net621 clknet_1_1__leaf_net524 net876 net908 clknet_1_0__leaf_net510 net567
+ VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__mux4_2
XANTENNA_c460_A2 net752 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c87_B1 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c323_S0 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output74_A net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c529_A3 net758 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_clk_X clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c264_A3 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c599_D net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c268_X net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c73_A2 net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc522 net436 net433 net417 net897 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__a31o_1
Xc511 net195 net415 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_9_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc533 net902 net707 net708 VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__a21oi_1
Xc555 clknet_leaf_13_clk net864 net882 net974 clknet_1_0__leaf_net470 net947 VGND
+ VGND VPWR VPWR net476 c555/Q_N sky130_fd_sc_hd__sdfbbp_1
Xc544 net419 net451 net454 VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__a21boi_1
Xc577 net861 net948 net939 VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__o21ai_1
Xc566 clknet_1_1__leaf_net473 net483 net475 net316 net909 net712 VGND VGND VPWR VPWR
+ net488 sky130_fd_sc_hd__mux4_1
Xc588 net490 net259 net171 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__o21ba_1
Xc599 clknet_leaf_22_clk net150 net243 net383 net400 net714 VGND VGND VPWR VPWR net518
+ c599/Q_N sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_99_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_71_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput106 net848 VGND VGND VPWR VPWR out50 sky130_fd_sc_hd__buf_2
Xoutput117 clknet_1_0__leaf_net859 VGND VGND VPWR VPWR out60 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net510 clknet_0_net510 VGND VGND VPWR VPWR clknet_1_0__leaf_net510
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c341_RESET_B net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c259_A3 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net598 clknet_0_net598 VGND VGND VPWR VPWR clknet_1_0__leaf_net598
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c410_S1 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c722_A3 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c90_B net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput19 in25 VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_40_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc330 net270 net136 net269 clknet_1_0__leaf_net267 net665 net855 VGND VGND VPWR VPWR
+ net272 sky130_fd_sc_hd__mux4_2
XFILLER_0_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc341 clknet_leaf_24_clk net261 net911 net282 clknet_1_1__leaf_net859 net883 VGND
+ VGND VPWR VPWR net844 net284 sky130_fd_sc_hd__sdfbbn_1
Xc352 net289 net293 clknet_1_0__leaf_net290 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__a21o_4
Xc374 net175 net48 net176 net248 net852 net823 VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__mux4_2
Xc396 net313 net314 net322 net872 net308 net891 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__mux4_1
Xc385 net308 net897 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__xor2_4
XFILLER_0_99_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c376_A1 net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c230_S1 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c542_A3 net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c405_S1 clknet_1_0__leaf_net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_net807_A net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c512_A net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c717_A3 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c733_A2 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout130 net874 VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c421_B1_N net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout163 net697 VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__clkbuf_4
Xfanout152 net448 VGND VGND VPWR VPWR net894 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_17_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c331_S0 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc160 net92 net104 net803 net651 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__a31oi_4
Xc171 net799 net764 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__xnor2_4
Xc182 net123 net877 net125 net880 net112 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__a41oi_4
Xc193 net750 net774 net760 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__o21ba_2
XFILLER_0_18_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclone4 net83 VGND VGND VPWR VPWR net988 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c728_A2 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c297_A0 net878 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c151_S0 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_72_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input36_A in40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap138 net832 VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__buf_4
Xmax_cap127 net23 VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__buf_4
XFILLER_0_0_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c210_A net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c564_A1 net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c458_A2 net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c177_A3 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_leaf_22_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c193_A2 net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_leaf_37_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_2_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_57_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_0_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_37_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_101_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs819 net616 clknet_leaf_17_clk VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__dlxtp_1
XFILLER_0_76_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_46_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs808 clknet_leaf_14_clk net492 VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__dfxtp_4
XANTENNA_c575_A0 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c725_A3 net587 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc704 net591 net148 net612 net318 net605 VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__a41o_1
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc726 clknet_1_1__leaf_net580 clknet_1_0__leaf_net805 net620 clknet_1_1__leaf_net635
+ net729 net733 VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__mux4_1
Xc715 net94 net927 net786 net906 net723 net729 VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__mux4_2
XFILLER_0_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_55_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c188_A2 clknet_1_0__leaf_net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_64_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_78_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_73_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output67_A net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net736 clknet_0_net736 VGND VGND VPWR VPWR clknet_1_0__leaf_net736
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_42_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_91_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer20 net930 VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_83_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s770_Q net677 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c455_A3 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc512 net307 net421 VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_9_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc534 clknet_leaf_4_clk net419 net864 net689 VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__sdfxtp_1
Xc545 clknet_leaf_13_clk net460 net461 net709 VGND VGND VPWR VPWR net463 net462 sky130_fd_sc_hd__dfbbp_1
Xc523 net437 net430 net429 net422 net195 net423 VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__mux4_1
Xc556 clknet_leaf_13_clk net468 net471 net469 net758 net864 VGND VGND VPWR VPWR net478
+ net477 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc589 net395 net861 net94 net908 net906 VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__a41oi_4
Xc567 clknet_leaf_14_clk net983 clknet_1_0__leaf_net464 net430 VGND VGND VPWR VPWR
+ net490 net489 sky130_fd_sc_hd__sdfxbp_1
Xc578 net494 net475 net949 VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_63_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput107 net849 VGND VGND VPWR VPWR out51 sky130_fd_sc_hd__buf_2
XFILLER_0_10_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput118 clknet_1_1__leaf_net860 VGND VGND VPWR VPWR out61 sky130_fd_sc_hd__clkbuf_1
XANTENNA_max_cap141_X net883 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net522 clknet_0_net522 VGND VGND VPWR VPWR clknet_1_0__leaf_net522
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net577 clknet_0_net577 VGND VGND VPWR VPWR clknet_1_0__leaf_net577
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout136_A net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c419_S0 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c466_A2 net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c202_Q net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc320 clknet_1_1__leaf_net245 net260 net262 net911 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__a31o_2
XTAP_TAPCELL_ROW_75_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc331 clknet_1_0__leaf_net271 clknet_1_1__leaf_net268 clknet_1_0__leaf_net267 net270
+ net269 net260 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__mux4_1
Xc342 net20 net871 net865 clknet_1_1__leaf_net250 net284 net903 VGND VGND VPWR VPWR
+ net285 sky130_fd_sc_hd__mux4_4
Xc353 clknet_1_1__leaf_net818 net292 clknet_1_0__leaf_net290 clknet_1_1__leaf_net296
+ net680 net681 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__mux4_1
Xc375 net856 net846 clknet_1_1__leaf_net860 net850 net857 net823 VGND VGND VPWR VPWR
+ net302 sky130_fd_sc_hd__mux4_2
Xc386 net312 net766 net311 net308 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__a31o_2
Xc397 net324 net85 net306 net315 net314 net313 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__mux4_1
XANTENNA_c571_Q net861 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c376_A2 net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c673_B1 net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net352 clknet_0_net352 VGND VGND VPWR VPWR clknet_1_0__leaf_net352
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c286_A2 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net396 clknet_0_net396 VGND VGND VPWR VPWR clknet_1_0__leaf_net396
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_31_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_31_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_46_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c300_Y net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_2_1__f_clk_X clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s763_GCLK net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout131 net874 VGND VGND VPWR VPWR net873 sky130_fd_sc_hd__buf_2
Xfanout164 net677 VGND VGND VPWR VPWR net906 sky130_fd_sc_hd__buf_4
XFILLER_0_96_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_22_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_22_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c79_X net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc150 net761 net80 net89 net87 net93 net778 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__mux4_1
Xc172 net113 net102 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__xor2_4
Xc161 net100 net926 net768 net832 net934 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__a41o_1
XFILLER_0_85_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc194 net646 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__clkbuf_2
Xc183 net124 net122 net782 net0 net789 clknet_1_0__leaf_net652 VGND VGND VPWR VPWR
+ net127 sky130_fd_sc_hd__mux4_1
XFILLER_0_34_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_13_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_13_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_70_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c462_B net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone5 net77 VGND VGND VPWR VPWR net989 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_91_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c297_A1 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c432_S0 net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c728_A3 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c182_A4 net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input29_A in34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c373_A3 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap128 net322 VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__buf_4
Xmax_cap139 net313 VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__buf_4
XFILLER_0_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_2_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_2_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_net862 clknet_0_net862 VGND VGND VPWR VPWR clknet_1_1__leaf_net862
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c398_A0 net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c162_S0 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c458_A3 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c177_A4 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net670 clknet_0_net670 VGND VGND VPWR VPWR clknet_1_1__leaf_net670
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c153_A net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c278_A3 net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs809 clknet_leaf_15_clk net496 VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_101_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c575_A1 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c591_A0 net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc727 clknet_1_0__leaf_net632 net94 clknet_1_0__leaf_net635 net620 net904 clknet_1_1__leaf_net736
+ VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__mux4_4
Xc716 net588 net617 net626 net715 net724 net730 VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__mux4_4
Xc705 clknet_leaf_16_clk net609 net566 net608 net725 VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__sdfstp_1
XFILLER_0_97_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c469_A2 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c188_A3 net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net860 net860 VGND VGND VPWR VPWR clknet_0_net860 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_78_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_21_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer21 net88 VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_95_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout169_X net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_36_clk_A clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c323_X net834 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c428_Y net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net145 net145 VGND VGND VPWR VPWR clknet_0_net145 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_64_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc546 clknet_1_1__leaf_net352 net662 net665 net672 VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__a31oi_2
Xc513 net419 net323 net324 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__o21bai_1
Xc535 net445 net443 net444 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__a21boi_2
Xc524 net422 net437 net414 net431 net425 net706 VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__mux4_2
Xc557 clknet_leaf_4_clk net316 net952 net864 clknet_1_0__leaf_net464 VGND VGND VPWR
+ VPWR net815 sky130_fd_sc_hd__sdfrtn_1
Xc579 net495 net429 net494 net269 net489 net714 VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__mux4_1
Xc568 clknet_leaf_16_clk net417 net865 net709 VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__sdfxtp_1
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c334_S1 net858 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input11_A in18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput119 net861 VGND VGND VPWR VPWR out7 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput108 net850 VGND VGND VPWR VPWR out52 sky130_fd_sc_hd__buf_2
XFILLER_0_10_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput90 net880 VGND VGND VPWR VPWR out35 sky130_fd_sc_hd__buf_2
XFILLER_0_37_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire137_X net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net589 clknet_0_net589 VGND VGND VPWR VPWR clknet_1_0__leaf_net589
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c260_S0 net875 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout129_A net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_444 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input3_A in10 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c76_B net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc321 clknet_1_1__leaf_net249 clknet_1_0__leaf_net263 net262 VGND VGND VPWR VPWR net264
+ sky130_fd_sc_hd__o21a_1
XFILLER_0_32_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc310 net122 net883 clknet_1_0__leaf_net250 clknet_1_0__leaf_net249 clknet_1_0__leaf_net252
+ clknet_1_0__leaf_net253 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__mux4_2
XANTENNA_c482_A2 clknet_1_0__leaf_net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input59_A in61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c329_S1 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc343 clknet_leaf_34_clk net281 net282 net649 VGND VGND VPWR VPWR net287 net286 sky130_fd_sc_hd__dfbbn_1
Xc332 clknet_1_0__leaf_net273 clknet_1_0__leaf_net242 clknet_1_0__leaf_net834 clknet_1_1__leaf_net245
+ net262 net270 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__mux4_1
Xc354 clknet_leaf_25_clk clknet_1_1__leaf_net859 net955 net942 VGND VGND VPWR VPWR
+ net299 net298 sky130_fd_sc_hd__dfbbp_1
Xc376 net850 net200 net856 net841 net799 net806 VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__mux4_1
Xc387 net311 net314 net313 VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__a21oi_4
Xc398 net307 net870 net325 net208 net875 net320 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__mux4_1
XANTENNA_input14_X net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c376_A3 net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer1 net71 VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c239_S1 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net375 clknet_0_net375 VGND VGND VPWR VPWR clknet_1_0__leaf_net375
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c286_A3 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c390_X net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input6_X net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout132 net317 VGND VGND VPWR VPWR net874 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_17_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c477_A2 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc162 net98 net104 net82 net101 net80 net651 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__mux4_2
XFILLER_0_20_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc140 net76 net756 net79 net81 net886 net899 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__mux4_2
Xc151 net773 net86 net767 net757 net777 net887 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__mux4_2
Xc184 net775 clknet_1_0__leaf_net127 net121 net878 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__a31o_1
Xc195 net120 net2 net138 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__a21bo_1
Xc173 net99 net651 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__xor2_4
XFILLER_0_87_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c607_SCD net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c190_B net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone6 net213 net305 VGND VGND VPWR VPWR net990 sky130_fd_sc_hd__xor2_1
XANTENNA_c713_S0 net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c297_A2 net759 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c594_A0 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c508_Y net417 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c403_X net332 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_58_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_83_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c342_S1 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c654_A3 net752 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_531 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c554_Q_N net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net830 clknet_0_net830 VGND VGND VPWR VPWR clknet_1_1__leaf_net830
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c398_A1 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c148_D net760 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c589_B1 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c162_S1 net651 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input41_A in45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c263_S0 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c153_B net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c278_A4 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_101_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout159_A net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc706 net610 clknet_1_1__leaf_net464 net547 net611 net595 net697 VGND VGND VPWR VPWR
+ net615 sky130_fd_sc_hd__mux4_4
Xc717 net171 net566 net567 net903 net626 net715 VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__mux4_1
Xc728 net625 net503 net826 net867 net906 net730 VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__mux4_1
XFILLER_0_31_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c591_A1 net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c348_S0 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input44_X net786 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c676_A1 clknet_1_1__leaf_net669 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_55 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer11 net79 VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__buf_2
XFILLER_0_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c586_A1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s756_Q net660 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc525 net90 net439 net429 net864 net315 net665 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__mux4_1
Xc514 net424 clknet_leaf_7_clk net951 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__dlrtn_2
Xc536 net447 net894 net446 net707 VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__a31o_1
Xc558 clknet_1_0__leaf_net473 clknet_1_0__leaf_net352 net474 net875 net692 VGND VGND
+ VPWR VPWR net479 sky130_fd_sc_hd__a41o_2
Xc569 net908 clknet_1_0__leaf_net818 net665 net858 net905 net940 VGND VGND VPWR VPWR
+ net492 sky130_fd_sc_hd__mux4_1
Xc547 clknet_1_1__leaf_net352 net447 net692 VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__o21ai_1
XANTENNA_c574_B1_N net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput109 net851 VGND VGND VPWR VPWR out53 sky130_fd_sc_hd__buf_2
XFILLER_0_50_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput80 net822 VGND VGND VPWR VPWR out26 sky130_fd_sc_hd__buf_2
Xoutput91 clknet_1_1__leaf_net833 VGND VGND VPWR VPWR out36 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c525_S1 net665 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net524 clknet_0_net524 VGND VGND VPWR VPWR clknet_1_0__leaf_net524
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c260_S1 net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_14_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c435_S1 net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c597_B1 net709 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c69_B net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc311 clknet_1_0__leaf_net251 net243 net246 clknet_1_0__leaf_net245 net215 net909
+ VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__mux4_1
Xc300 net241 net789 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__xnor2_4
XANTENNA_c482_A3 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc322 net240 net259 clknet_1_1__leaf_net145 net262 net799 net232 VGND VGND VPWR VPWR
+ net265 sky130_fd_sc_hd__mux4_1
Xc333 clknet_1_0__leaf_net862 clknet_1_1__leaf_net273 net269 net259 clknet_1_1__leaf_net263
+ net676 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__mux4_4
Xc344 net778 net20 clknet_1_0__leaf_net834 net282 net286 net281 VGND VGND VPWR VPWR
+ net288 sky130_fd_sc_hd__mux4_2
Xc377 net64 net856 net857 net825 net806 clknet_1_0__leaf_net845 VGND VGND VPWR VPWR
+ net304 sky130_fd_sc_hd__mux4_2
Xc355 clknet_1_0__leaf_net296 net293 net170 net174 clknet_1_0__leaf_net860 net20 VGND
+ VGND VPWR VPWR net300 sky130_fd_sc_hd__mux4_1
Xc388 net312 net74 net314 net213 net203 net309 VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__mux4_2
Xc399 clknet_leaf_5_clk net325 net233 net872 VGND VGND VPWR VPWR net328 net327 sky130_fd_sc_hd__sdfxbp_1
XANTENNA_c557_Q net815 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output110_A net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer2 net913 VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_clkbuf_leaf_20_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_leaf_35_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_79_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_88_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c583_A2 net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout122 net346 VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__buf_2
Xfanout144 net888 VGND VGND VPWR VPWR net886 sky130_fd_sc_hd__buf_12
XANTENNA_c104_A1 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c648_X net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c181_S0 net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c81_A net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc163 net779 net764 net107 net100 net832 net888 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__mux4_1
Xc141 net82 net81 net70 net879 net900 net887 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__mux4_1
Xc152 net94 net760 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__xnor2_1
Xc130 net69 net748 net70 net899 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__a31oi_4
Xc185 net128 net113 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__xnor2_4
Xc196 net137 net138 net134 net911 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__a31oi_4
Xc174 net102 net114 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__xor2_4
XFILLER_0_18_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c684_A1 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs790 clknet_leaf_14_clk net374 VGND VGND VPWR VPWR net696 net695 sky130_fd_sc_hd__dfxbp_1
XANTENNA_c607_SCE clknet_1_0__leaf_net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclone7 net890 VGND VGND VPWR VPWR net991 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c448_B net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c578_A2 net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c297_A3 net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_2_2__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c101_A2 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c92_A4 net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input34_A in39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net127 clknet_0_net127 VGND VGND VPWR VPWR clknet_1_1__leaf_net127
+ sky130_fd_sc_hd__clkbuf_16
Xc90 net24 net778 VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__xor2_4
XFILLER_0_97_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net683 clknet_0_net683 VGND VGND VPWR VPWR clknet_1_1__leaf_net683
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_72_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c575_A3 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_15_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc729 clknet_1_1__leaf_net635 net618 net867 net904 net729 clknet_1_1__leaf_net736
+ VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__mux4_4
Xc707 net612 net547 net606 clknet_1_0__leaf_net615 clknet_1_1__leaf_net493 net906
+ VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__mux4_1
XANTENNA_c719_S0 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc718 net507 net618 net777 net626 net904 net718 VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__mux4_4
XANTENNA_c591_A2 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_68_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c87_A4 net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_33_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net862 net862 VGND VGND VPWR VPWR clknet_0_net862 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c587_Q net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_42_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c539_S0 net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_hold42_A net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_60_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer12 net923 VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer23 net890 VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net480 clknet_0_net480 VGND VGND VPWR VPWR clknet_1_1__leaf_net480
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_65_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c586_A2 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc515 net425 net323 VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__xor2_1
Xc537 clknet_leaf_7_clk net443 net812 net450 VGND VGND VPWR VPWR net453 net452 sky130_fd_sc_hd__dfbbn_1
XTAP_TAPCELL_ROW_9_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc526 net428 net418 net430 net660 net689 net707 VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__mux4_4
Xc504 net891 net896 VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__xnor2_2
Xc548 clknet_leaf_13_clk net864 net446 net672 VGND VGND VPWR VPWR net467 net466 sky130_fd_sc_hd__sdfxbp_1
Xc559 clknet_1_0__leaf_net465 clknet_1_1__leaf_net470 net361 VGND VGND VPWR VPWR net480
+ sky130_fd_sc_hd__a21o_1
XANTENNA_c98_A3 net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net670 net670 VGND VGND VPWR VPWR clknet_0_net670 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput70 net812 VGND VGND VPWR VPWR out17 sky130_fd_sc_hd__buf_2
Xoutput81 net823 VGND VGND VPWR VPWR out27 sky130_fd_sc_hd__buf_2
Xoutput92 clknet_1_1__leaf_net834 VGND VGND VPWR VPWR out37 sky130_fd_sc_hd__clkbuf_1
Xclkbuf_1_0__f_net525 clknet_0_net525 VGND VGND VPWR VPWR clknet_1_0__leaf_net525
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_leaf_9_clk_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_0_net835_A net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c638_A net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c259_X net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c451_S1 net15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_leaf_34_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_34_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_37_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc312 clknet_1_1__leaf_net238 net247 net909 net878 net883 clknet_1_0__leaf_net252
+ VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__mux4_4
Xc301 net243 net240 net212 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__mux2_2
XTAP_TAPCELL_ROW_75_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc323 net260 net777 net774 clknet_1_0__leaf_net264 net232 net675 VGND VGND VPWR VPWR
+ net834 sky130_fd_sc_hd__mux4_1
Xc334 clknet_1_1__leaf_net263 net875 net259 net270 clknet_1_1__leaf_net271 net858
+ VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__mux4_1
Xc345 clknet_leaf_24_clk net958 net287 clknet_1_0__leaf_net859 net282 VGND VGND VPWR
+ VPWR net289 sky130_fd_sc_hd__sdfstp_1
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc356 net293 net286 net170 net174 net299 net678 VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__mux4_2
Xc378 clknet_leaf_6_clk net197 net927 net660 VGND VGND VPWR VPWR net306 net305 sky130_fd_sc_hd__sdfxbp_2
Xc389 net314 net309 net664 VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__a21o_1
XFILLER_0_87_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_25_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_25_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_82_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c673_A3 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer3 net914 VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_51_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net300 clknet_0_net300 VGND VGND VPWR VPWR clknet_1_0__leaf_net300
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_16_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_16_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_19_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net366 clknet_0_net366 VGND VGND VPWR VPWR clknet_1_0__leaf_net366
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net355 clknet_0_net355 VGND VGND VPWR VPWR clknet_1_0__leaf_net355
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_clkbuf_1_0__f_net862_X clknet_1_0__leaf_net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net377 clknet_0_net377 VGND VGND VPWR VPWR clknet_1_0__leaf_net377
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout134_A net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c219_A net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c727_S0 net904 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout123 net150 VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__buf_4
Xfanout134 net826 VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__clkbuf_8
Xfanout156 net116 VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__buf_4
Xfanout145 net888 VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__clkbuf_2
Xfanout167 net239 VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__clkbuf_8
XANTENNA_c401_B1 net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c181_S1 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c561_SCE net428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_7_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc120 clknet_leaf_30_clk net16 net21 net868 net59 net46 VGND VGND VPWR VPWR net61
+ net60 sky130_fd_sc_hd__sdfbbn_1
Xc131 net902 net910 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__xnor2_4
Xc153 net96 net771 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__xnor2_1
Xc142 net749 net84 net80 net879 net887 net900 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__mux4_2
Xc175 net800 net923 net775 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__mux2_1
Xc164 net765 net106 net91 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__a21boi_1
Xc186 clknet_1_0__leaf_net129 clknet_1_0__leaf_net127 net776 VGND VGND VPWR VPWR net130
+ sky130_fd_sc_hd__o21ai_1
Xc197 net645 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_16_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_99_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs791 clknet_leaf_23_clk net385 VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs780 clknet_leaf_4_clk net319 VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_3_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_5_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_5_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c282_S0 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net152 clknet_0_net152 VGND VGND VPWR VPWR clknet_1_0__leaf_net152
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c131_Y net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_58_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_leaf_34_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c77_X net15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net821 clknet_0_net821 VGND VGND VPWR VPWR clknet_1_1__leaf_net821
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c679_A2 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c398_A3 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c589_A2 net861 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c506_X net415 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input27_A in32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc80 net13 net16 VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__xor2_2
Xc91 net26 net27 net827 VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__a21oi_1
XFILLER_0_85_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c532_Q net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c443_SCD net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c306_B net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c682_SCD net547 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c719_S1 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc719 net521 net918 net626 net566 net799 net906 VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__mux4_4
Xc708 clknet_leaf_12_clk net607 net871 net547 net910 net609 VGND VGND VPWR VPWR net618
+ net617 sky130_fd_sc_hd__sdfbbp_1
XANTENNA_c591_A3 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_1__f_net818_X clknet_1_1__leaf_net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net830 net830 VGND VGND VPWR VPWR clknet_0_net830 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold70 net611 VGND VGND VPWR VPWR net982 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_89_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c692_A2 net532 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net470 clknet_0_net470 VGND VGND VPWR VPWR clknet_1_1__leaf_net470
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_1_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer13 net81 VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer24 net935 VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout164_A net677 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc527 clknet_leaf_4_clk net416 net90 net969 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__sdfxtp_1
Xc516 net910 net417 net425 net882 net897 VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__a41oi_2
Xc505 net311 net74 net322 VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__mux2_1
Xc538 net444 net451 net667 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__a21oi_1
Xc549 net467 net216 net904 VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__a21o_1
XFILLER_0_99_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c470_B1_N net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput82 clknet_1_1__leaf_net824 VGND VGND VPWR VPWR out28 sky130_fd_sc_hd__clkbuf_1
Xoutput71 clknet_1_1__leaf_net813 VGND VGND VPWR VPWR out18 sky130_fd_sc_hd__clkbuf_1
Xoutput93 clknet_1_1__leaf_net835 VGND VGND VPWR VPWR out38 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_62_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c208_A1 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c285_S0 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c638_B net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout167_X net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc302 net237 clknet_1_0__leaf_net653 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__xor2_4
XFILLER_0_32_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_75_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc335 clknet_leaf_35_clk net276 clknet_1_0__leaf_net271 clknet_1_1__leaf_net267 net676
+ VGND VGND VPWR VPWR net278 net277 sky130_fd_sc_hd__sdfsbp_1
Xc313 clknet_1_0__leaf_net256 net217 net866 clknet_1_1__leaf_net255 net912 clknet_1_0__leaf_net670
+ VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__mux4_1
Xc324 clknet_leaf_35_clk clknet_1_1__leaf_net242 clknet_1_0__leaf_net131 clknet_1_0__leaf_net264
+ VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__sdfxtp_1
Xc346 net17 net883 clknet_1_0__leaf_net264 net286 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__a31o_2
Xc379 net743 net206 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__xnor2_4
XFILLER_0_87_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c673_A4 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer4 net70 VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_63_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c413_RESET_B net774 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net378 clknet_0_net378 VGND VGND VPWR VPWR clknet_1_0__leaf_net378
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_13_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout135 net118 VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__buf_4
Xfanout146 net889 VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__buf_8
Xfanout157 net900 VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__buf_12
XANTENNA_input1_A in0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc110 net45 net868 net25 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__o21ai_1
XFILLER_0_60_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc154 net759 net651 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__xnor2_4
Xc121 net51 net863 net56 net868 net822 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__a41o_2
Xc143 net934 net777 net81 net879 net899 net922 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__mux4_2
Xc132 net72 net74 net754 net901 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__a31oi_4
XANTENNA_input57_A in6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc176 net791 net898 net877 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__a21boi_1
Xc187 net115 net123 clknet_1_1__leaf_net129 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__a21bo_1
Xc165 net107 net80 net900 net104 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__a31oi_1
Xc198 clknet_leaf_36_clk net114 net136 net137 VGND VGND VPWR VPWR net143 net142 sky130_fd_sc_hd__sdfxbp_1
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_8_clk_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c372_S1 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c311_A1 net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs770 net275 clknet_leaf_23_clk VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_50_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs781 net326 clknet_leaf_5_clk VGND VGND VPWR VPWR net829 net684 sky130_fd_sc_hd__dlxbn_2
Xs792 clknet_leaf_14_clk net387 VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c169_B net758 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net131 clknet_0_net131 VGND VGND VPWR VPWR clknet_1_0__leaf_net131
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_A3 net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c75_S1 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c457_S1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net833 clknet_0_net833 VGND VGND VPWR VPWR clknet_1_1__leaf_net833
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c695_A2 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net818_X clknet_1_0__leaf_net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c293_S0 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c589_A3 net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net129 clknet_0_net129 VGND VGND VPWR VPWR clknet_1_1__leaf_net129
+ sky130_fd_sc_hd__clkbuf_16
Xc92 net18 net26 net24 net804 net756 VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__a41o_1
Xc70 net3 net790 VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__xor2_4
Xc81 net9 net893 VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__xnor2_4
XFILLER_0_15_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net652 clknet_0_net652 VGND VGND VPWR VPWR clknet_1_1__leaf_net652
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_72_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc709 net491 net613 net618 clknet_1_0__leaf_net615 net611 net786 VGND VGND VPWR VPWR
+ net619 sky130_fd_sc_hd__mux4_4
XANTENNA_c682_SCE net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_leaf_33_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s791_Q net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_rebuffer12_A net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold60 net224 VGND VGND VPWR VPWR net972 sky130_fd_sc_hd__dlygate4sd3_1
Xhold71 net361 VGND VGND VPWR VPWR net983 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_89_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c692_A3 clknet_1_0__leaf_net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_wire165_X net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer25 net935 VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer14 net925 VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__dlymetal6s4s_1
XTAP_TAPCELL_ROW_37_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net493 clknet_0_net493 VGND VGND VPWR VPWR clknet_1_1__leaf_net493
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c430_D net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net127 net127 VGND VGND VPWR VPWR clknet_0_net127 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_57_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c204_Y net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc506 net896 net881 VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__xor2_4
Xc517 clknet_leaf_7_clk net324 net966 net424 net420 net311 VGND VGND VPWR VPWR net429
+ net428 sky130_fd_sc_hd__sdfbbn_2
Xc528 net442 net881 net812 VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__a21o_1
XANTENNA_s804_Q net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc539 net451 net450 net452 net454 net447 net894 VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__mux4_1
XANTENNA_c420_B1 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_net683 net683 VGND VGND VPWR VPWR clknet_0_net683 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input42_X net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput72 net814 VGND VGND VPWR VPWR out19 sky130_fd_sc_hd__buf_2
Xoutput83 net825 VGND VGND VPWR VPWR out29 sky130_fd_sc_hd__buf_2
Xoutput94 net836 VGND VGND VPWR VPWR out39 sky130_fd_sc_hd__buf_2
XANTENNA_c391_S0 net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c687_A3 net587 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_62_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c208_A2 net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c566_S0 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c285_S1 net665 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net290 clknet_0_net290 VGND VGND VPWR VPWR clknet_1_1__leaf_net290
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c597_A3 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c147_X net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s754_Q net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c78_S1 net9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc303 clknet_leaf_36_clk net125 net877 net244 net825 clknet_1_0__leaf_net238 VGND
+ VGND VPWR VPWR net247 net246 sky130_fd_sc_hd__sdfbbp_1
Xc314 clknet_1_0__leaf_net255 net241 clknet_1_0__leaf_net250 clknet_1_0__leaf_net256
+ net909 clknet_1_0__leaf_net249 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__mux4_2
Xc325 net262 clknet_1_1__leaf_net245 net898 clknet_1_0__leaf_net263 VGND VGND VPWR
+ VPWR net267 sky130_fd_sc_hd__a31o_4
Xc336 clknet_leaf_24_clk clknet_1_1__leaf_net253 net871 net912 net876 VGND VGND VPWR
+ VPWR net279 sky130_fd_sc_hd__sdfstp_1
XFILLER_0_60_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc347 net287 net844 clknet_1_1__leaf_net264 net170 net778 clknet_1_0__leaf_net280
+ VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__mux4_2
XFILLER_0_99_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer5 net75 VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_11_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net480 net480 VGND VGND VPWR VPWR clknet_0_net480 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_97_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_39_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output70_A net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap125_X net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clone10_A1 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c235_A0 net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout136 net831 VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__buf_4
Xfanout147 net890 VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__buf_12
Xfanout169 net786 VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__clkbuf_8
Xfanout158 net901 VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__buf_6
XANTENNA_c271_Y net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc100 clknet_leaf_32_clk net38 net37 net28 net21 net784 VGND VGND VPWR VPWR net40
+ net39 sky130_fd_sc_hd__sdfbbn_1
Xc111 clknet_leaf_30_clk net49 net16 net868 VGND VGND VPWR VPWR net51 net50 sky130_fd_sc_hd__dfbbn_1
Xc122 clknet_leaf_30_clk net52 net62 net45 VGND VGND VPWR VPWR net64 net63 sky130_fd_sc_hd__dfbbp_1
Xc133 net75 net743 net899 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__a21bo_4
Xc144 net84 net85 net748 net86 net900 net887 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__mux4_2
Xc166 net757 net102 net747 net80 net899 net886 VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__mux4_2
Xc155 net763 net776 net923 net775 net888 VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__a41oi_4
Xc177 net114 net113 net923 net798 net101 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__a41oi_2
Xc188 net781 net119 clknet_1_0__leaf_net131 net884 net798 net101 VGND VGND VPWR VPWR
+ net132 sky130_fd_sc_hd__mux4_4
Xc199 clknet_leaf_33_clk net136 net960 net141 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__sdfxtp_4
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c684_A4 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs760 clknet_leaf_1_clk net230 VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs771 net283 clknet_leaf_32_clk VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__dlxtp_1
Xs793 clknet_leaf_23_clk net388 VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs782 net339 clknet_leaf_5_clk VGND VGND VPWR VPWR net686 net685 sky130_fd_sc_hd__dlxbn_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c205_A3 net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c254_RESET_B net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c510_D net415 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c519_SCD net428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c603_B1 clknet_1_0__leaf_net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c322_A1 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net845 clknet_0_net845 VGND VGND VPWR VPWR clknet_1_1__leaf_net845
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net834 clknet_0_net834 VGND VGND VPWR VPWR clknet_1_1__leaf_net834
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_443 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_hold58_A net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c279_B net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c589_A4 net908 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_7_clk_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc82 net18 net827 net2 VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__a21oi_4
Xc71 net5 net911 net6 net796 net1 VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__a41o_4
Xc93 net27 net7 VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__xor2_4
XFILLER_0_85_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c317_A1 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c333_A0 clknet_1_0__leaf_net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net653 clknet_0_net653 VGND VGND VPWR VPWR clknet_1_1__leaf_net653
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c569_S0 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c675_D net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c291_A net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net821 net821 VGND VGND VPWR VPWR clknet_0_net821 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold50 net477 VGND VGND VPWR VPWR net962 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input32_A in37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold72 net172 VGND VGND VPWR VPWR net984 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 net215 VGND VGND VPWR VPWR net973 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_11_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output119_A net861 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer26 net937 VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_37_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c238_B1 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc507 net323 net315 VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__xor2_2
XANTENNA_c555_RESET_B net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc518 net427 net203 net425 net415 net305 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__a41o_4
XTAP_TAPCELL_ROW_77_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc529 net443 net415 net758 net315 VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__a31o_1
XFILLER_0_99_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c420_A1 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_37_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_37_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c481_S1 net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput73 net908 VGND VGND VPWR VPWR out2 sky130_fd_sc_hd__clkbuf_4
Xoutput84 net876 VGND VGND VPWR VPWR out3 sky130_fd_sc_hd__buf_2
Xoutput95 net837 VGND VGND VPWR VPWR out4 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input35_X net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_28_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_28_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_58_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_62_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_32_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c505_A1 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c224_A2 net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net280 clknet_0_net280 VGND VGND VPWR VPWR clknet_1_1__leaf_net280
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_19_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_19_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc326 clknet_1_0__leaf_net267 net799 net20 net217 net262 net675 VGND VGND VPWR VPWR
+ net268 sky130_fd_sc_hd__mux4_2
Xc315 net759 net217 net9 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__a21o_2
Xc304 net787 clknet_leaf_27_clk net825 VGND VGND VPWR VPWR net853 net248 sky130_fd_sc_hd__dlrbn_1
Xc348 clknet_1_1__leaf_net280 net287 net898 net20 net261 net679 VGND VGND VPWR VPWR
+ net860 sky130_fd_sc_hd__mux4_4
Xc337 net170 net261 clknet_1_1__leaf_net264 net649 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__a31o_1
XANTENNA_c150_A1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net470 net470 VGND VGND VPWR VPWR clknet_0_net470 sky130_fd_sc_hd__clkbuf_16
Xrebuffer6 net595 VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c606_B1 net858 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output63_A clknet_1_1__leaf_net805 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_46 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_8_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_8_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_59_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout126 net48 VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__buf_2
XANTENNA_c251_A0 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout148 net891 VGND VGND VPWR VPWR net890 sky130_fd_sc_hd__buf_12
Xfanout159 net902 VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__buf_12
XANTENNA_c636_A net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc101 net33 net38 net30 net26 net35 net39 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__mux4_1
Xc123 clknet_leaf_30_clk net61 net55 net21 net59 net822 VGND VGND VPWR VPWR net66
+ net65 sky130_fd_sc_hd__sdfbbp_1
Xc112 net51 net21 net868 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__o21ai_1
Xc145 net928 net84 net87 net86 net803 net922 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__mux4_2
Xc134 net802 net76 net75 net900 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__a31o_4
XANTENNA_c452_RESET_B net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc167 net109 net110 net878 net104 net832 net651 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__mux4_1
Xc156 net925 net832 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__xnor2_1
Xc178 net877 net105 net878 net783 net890 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__a41oi_2
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc189 net774 net892 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__xor2_2
XANTENNA_c234_SCD net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output101_A net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xs750 net169 clknet_leaf_34_clk VGND VGND VPWR VPWR net657 net656 sky130_fd_sc_hd__dlxbn_1
XTAP_TAPCELL_ROW_24_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs761 clknet_leaf_0_clk net231 VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_50_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xs772 net285 clknet_leaf_24_clk VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xs794 clknet_leaf_22_clk net389 VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__dlclkp_1
Xs783 net348 clknet_leaf_3_clk VGND VGND VPWR VPWR net688 net687 sky130_fd_sc_hd__dlxbp_1
XFILLER_0_51_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc690 net551 net588 net584 net921 net548 net118 VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__mux4_4
XPHY_EDGE_ROW_3_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input62_A in9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_76_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c665_Q net567 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c603_A1 net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net824 clknet_0_net824 VGND VGND VPWR VPWR clknet_1_1__leaf_net824
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net813 clknet_0_net813 VGND VGND VPWR VPWR clknet_1_1__leaf_net813
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net835 clknet_0_net835 VGND VGND VPWR VPWR clknet_1_1__leaf_net835
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_85_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_55_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout135_X net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c437_SCD net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c142_A2 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc94 clknet_leaf_33_clk net28 net22 net29 net893 net869 VGND VGND VPWR VPWR net32
+ net31 sky130_fd_sc_hd__sdfbbn_2
Xc83 net19 net892 VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__xor2_4
Xc72 net794 net8 VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__xnor2_2
XFILLER_0_85_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c317_A2 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xwire165 net660 VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_41_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net632 clknet_0_net632 VGND VGND VPWR VPWR clknet_1_1__leaf_net632
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net654 clknet_0_net654 VGND VGND VPWR VPWR clknet_1_1__leaf_net654
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c291_B net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net833 net833 VGND VGND VPWR VPWR clknet_0_net833 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c434_A0 net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold40 net894 VGND VGND VPWR VPWR net952 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 net54 VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input25_A in30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold62 net466 VGND VGND VPWR VPWR net974 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c600_A2 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c344_A0 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_leaf_6_clk_A clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net473 clknet_0_net473 VGND VGND VPWR VPWR clknet_1_1__leaf_net473
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net129 net129 VGND VGND VPWR VPWR clknet_0_net129 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_72_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc508 net897 net307 VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__xnor2_4
Xc519 clknet_leaf_7_clk net414 net430 net428 net425 net927 VGND VGND VPWR VPWR net432
+ net431 sky130_fd_sc_hd__sdfbbp_1
XTAP_TAPCELL_ROW_77_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c287_X net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c336_SET_B net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c420_A2 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c429_B1 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net652 net652 VGND VGND VPWR VPWR clknet_0_net652 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput63 clknet_1_1__leaf_net805 VGND VGND VPWR VPWR out0 sky130_fd_sc_hd__clkbuf_1
Xoutput85 net827 VGND VGND VPWR VPWR out30 sky130_fd_sc_hd__buf_2
Xoutput74 net816 VGND VGND VPWR VPWR out20 sky130_fd_sc_hd__buf_2
XFILLER_0_101_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput96 net838 VGND VGND VPWR VPWR out40 sky130_fd_sc_hd__buf_2
XANTENNA_c330_A2 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c224_A3 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
.ends
