* NGSPICE file created from netlist_2.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_4 abstract view
.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_1 abstract view
.subckt sky130_fd_sc_hd__dlrtp_1 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_1 abstract view
.subckt sky130_fd_sc_hd__dfxbp_1 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbp_1 abstract view
.subckt sky130_fd_sc_hd__dlrbp_1 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_1 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_1 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_4 abstract view
.subckt sky130_fd_sc_hd__dlxtn_4 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_2 abstract view
.subckt sky130_fd_sc_hd__dlclkp_2 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_4 abstract view
.subckt sky130_fd_sc_hd__dlclkp_4 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_1 abstract view
.subckt sky130_fd_sc_hd__dlxtn_1 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_2 abstract view
.subckt sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_4 abstract view
.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_4 abstract view
.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_2 abstract view
.subckt sky130_fd_sc_hd__a41oi_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_1 abstract view
.subckt sky130_fd_sc_hd__a41oi_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_2 abstract view
.subckt sky130_fd_sc_hd__dlrtp_2 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_2 abstract view
.subckt sky130_fd_sc_hd__dfxbp_2 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_1 abstract view
.subckt sky130_fd_sc_hd__dlxbn_1 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_4 abstract view
.subckt sky130_fd_sc_hd__mux4_4 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_4 abstract view
.subckt sky130_fd_sc_hd__a41oi_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_1 abstract view
.subckt sky130_fd_sc_hd__dlrbn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_2 abstract view
.subckt sky130_fd_sc_hd__dlxbn_2 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_2 abstract view
.subckt sky130_fd_sc_hd__dlxtn_2 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtp_1 abstract view
.subckt sky130_fd_sc_hd__dlxtp_1 D GATE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_8 abstract view
.subckt sky130_fd_sc_hd__mux2_8 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxbp_1 abstract view
.subckt sky130_fd_sc_hd__edfxbp_1 CLK D DE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__lpflow_inputisolatch_1 abstract view
.subckt sky130_fd_sc_hd__lpflow_inputisolatch_1 D SLEEP_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbp_1 abstract view
.subckt sky130_fd_sc_hd__dlxbp_1 D GATE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_1 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_0 abstract view
.subckt sky130_fd_sc_hd__a21boi_0 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_2 abstract view
.subckt sky130_fd_sc_hd__dlrtn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_1 abstract view
.subckt sky130_fd_sc_hd__dlclkp_1 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_4 abstract view
.subckt sky130_fd_sc_hd__o21ba_4 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_4 abstract view
.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrbp_2 abstract view
.subckt sky130_fd_sc_hd__sdfrbp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbp_1 CLK D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q
+ Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_4 abstract view
.subckt sky130_fd_sc_hd__a41o_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_2 abstract view
.subckt sky130_fd_sc_hd__a41o_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtn_1 abstract view
.subckt sky130_fd_sc_hd__dfrtn_1 CLK_N D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_4 abstract view
.subckt sky130_fd_sc_hd__a21bo_4 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_1 abstract view
.subckt sky130_fd_sc_hd__dfsbp_1 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_2 abstract view
.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_2 abstract view
.subckt sky130_fd_sc_hd__dfsbp_2 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_12 abstract view
.subckt sky130_fd_sc_hd__inv_12 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_2 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_2 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_4 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_4 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfsbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfsbp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_2 abstract view
.subckt sky130_fd_sc_hd__dfstp_2 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_2 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_2 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_1 abstract view
.subckt sky130_fd_sc_hd__dlrtn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_4 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_4 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxtp_1 abstract view
.subckt sky130_fd_sc_hd__edfxtp_1 CLK D DE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_2 abstract view
.subckt sky130_fd_sc_hd__dfrbp_2 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtn_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtn_1 CLK_N D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

.subckt netlist_2 VGND VPWR clk in0 in1 in10 in11 in12 in13 in14 in15 in16 in17 in18
+ in19 in2 in20 in21 in22 in23 in24 in25 in26 in27 in28 in29 in3 in30 in31 in32 in33
+ in34 in35 in36 in37 in38 in39 in4 in40 in41 in42 in43 in44 in45 in46 in47 in48 in49
+ in5 in50 in51 in6 in7 in8 in9 out0 out1 out10 out11 out12 out13 out14 out15 out16
+ out17 out18 out19 out2 out20 out21 out22 out23 out24 out25 out26 out27 out28 out29
+ out3 out30 out31 out32 out33 out34 out35 out36 out37 out38 out39 out4 out40 out41
+ out42 out43 out44 out45 out46 out47 out48 out49 out5 out50 out51 out6 out7 out8
+ out9 rst
XFILLER_0_94_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net281 clknet_0_net281 VGND VGND VPWR VPWR clknet_1_1__leaf_net281
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c202_X net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc316 clknet_1_0__leaf_net248 net1018 net255 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__o21a_2
Xc305 net245 clknet_1_0__leaf_net251 clknet_1_0__leaf_net250 net1019 net1043 clknet_1_1__leaf_net813
+ VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__mux4_1
Xc327 clknet_1_1__leaf_net271 net1007 net778 clknet_1_0__leaf_net814 VGND VGND VPWR
+ VPWR net274 sky130_fd_sc_hd__a31o_4
XFILLER_0_60_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc349 clknet_1_0__leaf_net297 net106 net283 net285 net259 clknet_1_1__leaf_net295
+ VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__mux4_1
Xc338 net1048 net268 net1039 clknet_1_0__leaf_net271 net282 net760 VGND VGND VPWR
+ VPWR net287 sky130_fd_sc_hd__mux4_2
XANTENNA_c669_X net563 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c431_A1 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c150_A2 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge826 net140 clknet_4_2_0_clk merge826/RESET_B VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__dlrtp_1
Xmerge837 clknet_4_11_0_clk net677 net684 VGND VGND VPWR VPWR net1001 sky130_fd_sc_hd__dfrtp_1
XANTENNA_c159_A0 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge804 net277 net284 VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__xnor2_1
Xmerge815 net294 net293 VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__xor2_1
Xs910 clknet_4_1_0_clk net349 VGND VGND VPWR VPWR net826 net825 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_95_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge848 net524 clknet_4_13_0_clk net725 VGND VGND VPWR VPWR net755 net754 sky130_fd_sc_hd__dlrbp_1
Xmerge859 clknet_4_13_0_clk net715 net517 VGND VGND VPWR VPWR net987 sky130_fd_sc_hd__sdlclkp_1
Xs943 clknet_4_6_0_clk net521 VGND VGND VPWR VPWR net866 net865 sky130_fd_sc_hd__dfxbp_1
Xs921 net393 clknet_4_12_0_clk VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__dlxtn_4
Xs932 clknet_4_14_0_clk net430 VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__dlclkp_2
Xs965 clknet_4_7_0_clk net606 VGND VGND VPWR VPWR net893 sky130_fd_sc_hd__dlclkp_4
Xs954 net576 clknet_4_5_0_clk VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_36_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c606_A1 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_97_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c683_S0 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c341_A1 net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s965_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net304 clknet_0_net304 VGND VGND VPWR VPWR clknet_1_0__leaf_net304
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c219_A3 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c235_A2 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c593_S0 net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout116 net979 VGND VGND VPWR VPWR net1023 sky130_fd_sc_hd__buf_4
Xfanout138 net791 VGND VGND VPWR VPWR net1045 sky130_fd_sc_hd__clkbuf_8
Xfanout105 net334 VGND VGND VPWR VPWR net1012 sky130_fd_sc_hd__buf_4
Xfanout127 net1035 VGND VGND VPWR VPWR net1034 sky130_fd_sc_hd__clkbuf_4
Xfanout149 net948 VGND VGND VPWR VPWR net1056 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_49_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c531_A net732 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net871 clknet_0_net871 VGND VGND VPWR VPWR clknet_1_0__leaf_net871
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net893 clknet_0_net893 VGND VGND VPWR VPWR clknet_1_0__leaf_net893
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc102 net21 net41 net44 net1010 net46 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__a41o_1
Xc124 net51 net1026 net68 net62 net63 clknet_1_0__leaf_net765 VGND VGND VPWR VPWR
+ net72 sky130_fd_sc_hd__mux4_1
Xc113 net60 net59 net989 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__o21bai_2
Xc135 net1065 net141 net921 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__o21ba_2
Xc168 net1086 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__buf_4
Xc157 net1021 net928 net1022 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__o21bai_4
Xc146 net90 net83 net85 net1019 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__a31oi_4
Xc179 net126 net918 net1023 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__a21boi_4
XANTENNA_c442_B1 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c161_A1 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net290 net290 VGND VGND VPWR VPWR clknet_0_net290 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_11_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc680 net336 clknet_1_0__leaf_net570 clknet_1_0__leaf_net553 clknet_1_1__leaf_net872
+ net875 net877 VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__mux4_1
Xc691 net369 net465 net584 clknet_1_1__leaf_net553 net855 net882 VGND VGND VPWR VPWR
+ net585 sky130_fd_sc_hd__mux4_1
XANTENNA_c352_B1 net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c502_A3 net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c221_A4 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net156 clknet_0_net156 VGND VGND VPWR VPWR clknet_1_0__leaf_net156
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net178 clknet_0_net178 VGND VGND VPWR VPWR clknet_1_0__leaf_net178
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c588_S0 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_40_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c498_S0 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s955_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c603_A2 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c207_SCE net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net814 clknet_0_net814 VGND VGND VPWR VPWR clknet_1_1__leaf_net814
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input10_X net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c347_A0 net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c257_B1 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c423_A2 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input2_X net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c720_A0 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc62 net8 net6 net959 net9 net1 net1028 VGND VGND VPWR VPWR net979 sky130_fd_sc_hd__mux4_2
Xc73 net9 net923 net13 VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__a21o_4
Xc84 net23 net26 net27 net1048 net22 net28 VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__mux4_1
Xc95 net937 net35 net40 net26 net989 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__a41oi_2
XTAP_TAPCELL_ROW_26_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c406_Q net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c317_A3 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c333_A2 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net611 clknet_0_net611 VGND VGND VPWR VPWR clknet_1_1__leaf_net611
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net633 clknet_0_net633 VGND VGND VPWR VPWR clknet_1_1__leaf_net633
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c277_A net732 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c106_S0 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c153_A2 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input18_A in24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c600_A3 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge861_GATE net169 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output86_A clknet_1_1__leaf_net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c344_A1 clknet_1_1__leaf_net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c360_B1 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net474 clknet_0_net474 VGND VGND VPWR VPWR clknet_1_1__leaf_net474
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_83_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net463 clknet_0_net463 VGND VGND VPWR VPWR clknet_1_1__leaf_net463
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net496 clknet_0_net496 VGND VGND VPWR VPWR clknet_1_1__leaf_net496
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_65_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c337_SCD net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c596_S0 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c420_A3 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net620 net620 VGND VGND VPWR VPWR clknet_0_net620 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net631 net631 VGND VGND VPWR VPWR clknet_0_net631 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net653 net653 VGND VGND VPWR VPWR clknet_0_net653 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c164_A1 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput53 clknet_1_1__leaf_net960 VGND VGND VPWR VPWR out0 sky130_fd_sc_hd__clkbuf_1
Xoutput75 net982 VGND VGND VPWR VPWR out31 sky130_fd_sc_hd__buf_2
Xoutput64 net971 VGND VGND VPWR VPWR out21 sky130_fd_sc_hd__buf_2
Xoutput86 clknet_1_1__leaf_net993 VGND VGND VPWR VPWR out43 sky130_fd_sc_hd__clkbuf_1
Xoutput97 net1004 VGND VGND VPWR VPWR out7 sky130_fd_sc_hd__buf_2
XANTENNA_c180_B1 net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net271 clknet_0_net271 VGND VGND VPWR VPWR clknet_1_1__leaf_net271
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout155_A net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c103_S1 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_8_0_clk_X clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout110_X net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc317 net1016 clknet_1_0__leaf_net254 net1007 net752 net769 VGND VGND VPWR VPWR net264
+ sky130_fd_sc_hd__a41oi_1
Xc306 net233 net218 clknet_1_0__leaf_net250 net112 net1031 clknet_1_0__leaf_net252
+ VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__mux4_2
XFILLER_0_13_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc328 clknet_1_0__leaf_net269 net255 net1093 net744 clknet_1_0__leaf_net814 VGND VGND
+ VPWR VPWR net275 sky130_fd_sc_hd__a41oi_2
Xc339 clknet_1_1__leaf_net153 clknet_1_1__leaf_net263 clknet_1_0__leaf_net281 net1013
+ net1024 net285 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__mux4_2
XFILLER_0_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c712_A1 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c209_B1_N net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c58_A0 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge827 net670 clknet_4_5_0_clk net594 VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__dlrtp_2
XANTENNA_c159_A1 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs900 clknet_4_9_0_clk net273 VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__dlclkp_2
Xmerge816 net323 net438 VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__xor2_2
Xmerge805 net406 net411 VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__xor2_1
Xmerge849 net525 clknet_4_13_0_clk net655 VGND VGND VPWR VPWR net757 net756 sky130_fd_sc_hd__dlrbp_1
XFILLER_0_67_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xs922 net394 clknet_4_3_0_clk VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__dlxtn_4
Xs933 clknet_4_14_0_clk net433 VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__dlclkp_4
Xs911 clknet_4_4_0_clk net350 VGND VGND VPWR VPWR net828 net827 sky130_fd_sc_hd__dfxbp_2
Xmerge838 clknet_4_6_0_clk merge838/D net491 VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__dfrtp_1
Xs955 net578 clknet_4_5_0_clk VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__dlxtn_4
Xs966 net607 clknet_4_13_0_clk VGND VGND VPWR VPWR net895 net894 sky130_fd_sc_hd__dlxbn_1
Xs944 clknet_4_6_0_clk net523 VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__dfxtp_2
Xclkbuf_0_net450 net450 VGND VGND VPWR VPWR clknet_0_net450 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net461 net461 VGND VGND VPWR VPWR clknet_0_net461 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net472 net472 VGND VGND VPWR VPWR clknet_0_net472 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_11_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c606_A2 net760 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net494 net494 VGND VGND VPWR VPWR clknet_0_net494 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c175_A0 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c325_A3 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c622_A1 net388 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input40_X net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net305 clknet_0_net305 VGND VGND VPWR VPWR clknet_1_0__leaf_net305
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_47_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c335_SET_B net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c593_S1 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout106 net1014 VGND VGND VPWR VPWR net1013 sky130_fd_sc_hd__buf_4
Xfanout117 net1025 VGND VGND VPWR VPWR net1024 sky130_fd_sc_hd__buf_4
Xfanout128 net1036 VGND VGND VPWR VPWR net1035 sky130_fd_sc_hd__buf_4
XFILLER_0_59_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_85_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout158_X net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net850 clknet_0_net850 VGND VGND VPWR VPWR clknet_1_0__leaf_net850
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net872 clknet_0_net872 VGND VGND VPWR VPWR clknet_1_0__leaf_net872
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c707_A1 net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c426_A2 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc125 net66 net68 net57 net62 net60 clknet_1_0__leaf_net735 VGND VGND VPWR VPWR net73
+ sky130_fd_sc_hd__mux4_4
Xc114 net56 net58 net699 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__a21boi_2
Xc103 net40 net25 net950 net1026 net46 net1010 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c145_A3 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc136 net82 net913 net1065 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__a21oi_4
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc169 net111 net112 net113 net116 net1021 net105 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__mux4_1
Xc147 net1019 net95 net90 net1022 net956 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__a41oi_4
Xc158 net936 net100 net946 net1058 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__a31oi_4
XFILLER_0_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_A1 net388 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge770_B1 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge830_Q net732 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c694_S0 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s883_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc670 net708 VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__dlymetal6s2s_1
Xc681 net574 net562 net96 clknet_1_0__leaf_net872 net873 net875 VGND VGND VPWR VPWR
+ net575 sky130_fd_sc_hd__mux4_2
XANTENNA_c582_CLK_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c352_A1 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc692 net467 net1015 clknet_1_1__leaf_net372 net584 net881 net883 VGND VGND VPWR VPWR
+ net586 sky130_fd_sc_hd__mux4_2
XFILLER_0_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c246_A2 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout118_A net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net993_X clknet_1_1__leaf_net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c156_A2 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input48_A in51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net815 clknet_0_net815 VGND VGND VPWR VPWR clknet_1_1__leaf_net815
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge765_B1 net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge838_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net252_A net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge847_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c599_S0 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge829_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c407_A4 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc63 net6 net1053 net1067 net1023 net9 net1028 VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__mux4_1
Xc74 net17 net950 net945 net1059 VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__a31oi_4
Xc85 net31 net18 net28 net30 net22 net945 VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__mux4_1
Xc52 net926 net951 net959 net1053 net1055 VGND VGND VPWR VPWR net0 sky130_fd_sc_hd__a41oi_4
XFILLER_0_97_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc96 net39 net38 net23 net37 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__a31oi_4
XTAP_TAPCELL_ROW_26_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c167_A1 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c302_S0 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xwire134 net843 VGND VGND VPWR VPWR net1041 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c68_Y net15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c614_A2 clknet_1_1__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c333_A3 net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net601 clknet_0_net601 VGND VGND VPWR VPWR clknet_1_1__leaf_net601
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c630_A1 net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c358_B1 net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c540_A1 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_9_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout140_X net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net813 net813 VGND VGND VPWR VPWR clknet_0_net813 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c450_A1 clknet_1_0__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c366_CLK_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s936_GATE clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c609_A2 net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c625_A1 clknet_1_0__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c344_A2 net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output79_A net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c360_A1 clknet_1_1__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net420 clknet_0_net420 VGND VGND VPWR VPWR clknet_1_1__leaf_net420
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_65_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c596_S1 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout100_A net257 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_4_0_clk_X clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s895_Q_N net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c342_X net291 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c429_A2 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c726_A0 clknet_1_1__leaf_net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c63_A1 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c148_A3 net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c445_A1 clknet_1_1__leaf_net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput54 net1040 VGND VGND VPWR VPWR out1 sky130_fd_sc_hd__buf_2
Xoutput65 net972 VGND VGND VPWR VPWR out22 sky130_fd_sc_hd__buf_2
Xoutput76 net1044 VGND VGND VPWR VPWR out32 sky130_fd_sc_hd__buf_2
Xoutput87 net994 VGND VGND VPWR VPWR out44 sky130_fd_sc_hd__buf_2
Xoutput98 net1005 VGND VGND VPWR VPWR out8 sky130_fd_sc_hd__buf_2
XANTENNA_c180_A1 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge868_Q_N net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input30_A in35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s886_Q_N net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c611_A3 clknet_1_0__leaf_net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_42_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net250 clknet_0_net250 VGND VGND VPWR VPWR clknet_1_1__leaf_net250
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c249_A2 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_99_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc307 net244 clknet_1_0__leaf_net250 net1030 net710 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__a31o_2
Xc318 net237 clknet_1_1__leaf_net248 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__xor2_4
XFILLER_0_13_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout103_X net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc329 net262 clknet_1_0__leaf_net252 clknet_1_0__leaf_net275 net744 net778 clknet_1_0__leaf_net814
+ VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__mux4_2
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c671_A net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c431_A3 clknet_1_0__leaf_net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c58_A1 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c159_S net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge828 net635 net637 VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__xnor2_2
XFILLER_0_83_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge817 net543 net691 VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__xnor2_2
Xmerge806 net676 clknet_4_2_0_clk net139 VGND VGND VPWR VPWR net704 net703 sky130_fd_sc_hd__dlrbn_1
Xs901 clknet_4_9_0_clk net288 VGND VGND VPWR VPWR net815 sky130_fd_sc_hd__dlclkp_4
Xmerge839 clknet_4_13_0_clk net729 net696 VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_82_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs934 net456 clknet_4_5_0_clk VGND VGND VPWR VPWR net853 net852 sky130_fd_sc_hd__dlxbn_2
Xs912 clknet_4_4_0_clk net352 VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__dfxtp_2
Xs923 net396 clknet_4_6_0_clk VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__dlxtn_2
Xs967 net613 clknet_4_7_0_clk VGND VGND VPWR VPWR net897 net896 sky130_fd_sc_hd__dlxbn_1
Xs956 net579 clknet_4_5_0_clk VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__dlxtp_1
Xs945 clknet_4_6_0_clk net527 VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__dfxtp_1
XANTENNA_c88_A net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c74_B1 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c456_A0 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net462 net462 VGND VGND VPWR VPWR clknet_0_net462 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_11_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c109_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c175_A1 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s938_GATE_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c622_A2 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input33_X net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c341_A3 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_74_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout107 net216 VGND VGND VPWR VPWR net1014 sky130_fd_sc_hd__clkbuf_4
Xfanout118 net979 VGND VGND VPWR VPWR net1025 sky130_fd_sc_hd__clkbuf_4
Xfanout129 net354 VGND VGND VPWR VPWR net1036 sky130_fd_sc_hd__buf_4
XFILLER_0_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net993_X clknet_1_0__leaf_net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net851 clknet_0_net851 VGND VGND VPWR VPWR clknet_1_0__leaf_net851
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c707_A2 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c305_X net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc126 net67 net1026 net63 net62 net68 net764 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__mux4_1
Xc115 net59 net1002 net58 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__o21ba_2
Xc104 net21 net40 net699 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__o21ba_2
XANTENNA_c145_A4 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c60_A2 net1082 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc137 net84 net83 net910 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__o21a_4
Xc159 net934 net98 net939 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__mux2_2
Xc148 net85 net87 net95 net1065 net89 net1022 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__mux4_2
XANTENNA_c442_A2 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c578_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c305_S0 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c331_Q net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c617_A2 clknet_1_1__leaf_net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net281 net281 VGND VGND VPWR VPWR clknet_0_net281 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c336_A3 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc682 net465 clknet_1_0__leaf_net556 clknet_1_0__leaf_net573 clknet_1_1__leaf_net553
+ net877 net879 VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__mux4_2
Xc671 net728 VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__inv_2
Xc660 net85 clknet_1_0__leaf_net461 net86 VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__o21bai_1
XANTENNA_output61_A clknet_1_1__leaf_net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc693 net481 net564 net584 net1051 net671 net855 VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__mux4_2
XFILLER_0_75_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net147 clknet_0_net147 VGND VGND VPWR VPWR clknet_1_0__leaf_net147
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c449_SCD clknet_1_1__leaf_net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge792_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_36_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c71_A1 net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c453_A1 net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_45_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net849 clknet_0_net849 VGND VGND VPWR VPWR clknet_1_1__leaf_net849
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_29_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c689_S1 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c628_A1 clknet_1_1__leaf_net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_54_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_71_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc490 net378 net1060 net956 clknet_1_1__leaf_net765 net1041 net847 VGND VGND VPWR
+ VPWR net425 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_63_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c320_Q_N net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_72_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c599_S1 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout130_A net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c554_B1 net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c704_A3 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_81_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc64 net915 net10 net442 net1065 net1028 net1056 VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__mux4_2
Xc75 net21 net16 net20 VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__o21ba_2
Xc53 net929 net1058 net1055 net956 VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__a31o_4
Xc97 net40 net945 net39 net913 net1047 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__a41o_1
Xc86 net28 net944 net32 net22 net955 net1026 VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_26_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A0 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c66_A1 net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_90_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c167_A2 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c464_A0 clknet_1_1__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c333_A4 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c94_S net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net814 net814 VGND VGND VPWR VPWR clknet_0_net814 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_0_0_clk_X clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout133_X net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s888_GATE clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c52_A3 net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold10 net332 VGND VGND VPWR VPWR net1085 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c450_A2 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c328_A4 net744 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c625_A2 net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c344_A3 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c360_A2 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net487 clknet_0_net487 VGND VGND VPWR VPWR clknet_1_1__leaf_net487
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_65_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c223_S0 net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c254_A3 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c282_A net732 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c429_A3 clknet_1_0__leaf_net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net633 net633 VGND VGND VPWR VPWR clknet_0_net633 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net611 net611 VGND VGND VPWR VPWR clknet_0_net611 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c726_A1 net587 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c63_A2 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_s910_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c445_A2 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c164_A3 net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c742_A0 net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput55 net962 VGND VGND VPWR VPWR out10 sky130_fd_sc_hd__buf_2
Xoutput66 net973 VGND VGND VPWR VPWR out23 sky130_fd_sc_hd__buf_2
Xoutput88 net995 VGND VGND VPWR VPWR out45 sky130_fd_sc_hd__buf_2
Xoutput99 net1006 VGND VGND VPWR VPWR out9 sky130_fd_sc_hd__buf_2
Xoutput77 net984 VGND VGND VPWR VPWR out33 sky130_fd_sc_hd__buf_2
XANTENNA_input23_A in29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c339_A3 net1013 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c697_S1 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge853_Q net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c355_A2 clknet_1_0__leaf_net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s901_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c371_A1 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net251 clknet_0_net251 VGND VGND VPWR VPWR clknet_1_1__leaf_net251
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net295 clknet_0_net295 VGND VGND VPWR VPWR clknet_1_1__leaf_net295
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c249_A3 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc308 net210 net230 net1021 net236 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__a31o_2
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc319 net218 clknet_1_0__leaf_net265 net956 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__mux2_8
XFILLER_0_13_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c712_A3 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s959_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge807 net416 net642 VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__xnor2_1
Xmerge818 net435 net329 VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__xor2_2
Xs902 net289 clknet_4_9_0_clk VGND VGND VPWR VPWR net984 net816 sky130_fd_sc_hd__dlxbn_2
Xmerge829 clknet_4_11_0_clk net311 net326 VGND VGND VPWR VPWR net731 net730 sky130_fd_sc_hd__edfxbp_1
XFILLER_0_48_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs913 clknet_4_1_0_clk net365 VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__dfxtp_2
Xs924 net397 clknet_4_3_0_clk VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__dlxtp_1
Xs957 net582 clknet_4_5_0_clk VGND VGND VPWR VPWR net883 sky130_fd_sc_hd__lpflow_inputisolatch_1
XFILLER_0_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs968 net614 clknet_4_13_0_clk VGND VGND VPWR VPWR net899 net898 sky130_fd_sc_hd__dlxbp_1
XFILLER_0_75_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs946 clknet_4_13_0_clk net530 VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__dfxtp_1
Xs935 net457 clknet_4_4_0_clk VGND VGND VPWR VPWR net855 net854 sky130_fd_sc_hd__dlxbn_2
Xclkbuf_0_net474 net474 VGND VGND VPWR VPWR clknet_0_net474 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net463 net463 VGND VGND VPWR VPWR clknet_0_net463 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_11_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c319_S net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net496 net496 VGND VGND VPWR VPWR clknet_0_net496 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c175_A2 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c207_Q net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c191_A1 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input26_X net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge768_A1 net338 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c173_SCD net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout119 net14 VGND VGND VPWR VPWR net1026 sky130_fd_sc_hd__buf_4
Xfanout108 net1003 VGND VGND VPWR VPWR net1015 sky130_fd_sc_hd__buf_4
XFILLER_0_96_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout160_A net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c411_S0 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc105 net8 net50 net42 net30 net16 net29 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__mux4_2
Xc127 clknet_4_10_0_clk net68 net67 net47 net70 net63 VGND VGND VPWR VPWR net76 net75
+ sky130_fd_sc_hd__sdfbbn_1
Xc116 net61 net1002 net989 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__a21boi_0
XFILLER_0_20_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s905_Q net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_96_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc149 net1017 net95 net1016 net1019 net1052 net84 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__mux4_2
Xc138 net922 net931 net86 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__a21o_2
XANTENNA_c442_A3 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_A3 net738 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net271 net271 VGND VGND VPWR VPWR clknet_0_net271 sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge770_A2 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc672 net708 VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__clkbuf_2
Xc661 net1017 net1050 clknet_1_0__leaf_net553 VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__mux2_8
XANTENNA_c352_A3 net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc694 net228 clknet_1_1__leaf_net474 net587 net811 net828 net879 VGND VGND VPWR VPWR
+ net588 sky130_fd_sc_hd__mux4_4
Xc683 net465 net564 clknet_1_0__leaf_net556 clknet_1_1__leaf_net474 net831 net854
+ VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__mux4_2
XFILLER_0_75_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output54_A net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c215_S1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c246_A4 net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c449_SCE net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_442 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c55_A3 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c437_A3 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c71_A2 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c750_A0 clknet_1_1__leaf_net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_100_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c628_A2 clknet_1_0__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc491 net1067 net1025 net775 net818 net847 net848 VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__mux4_1
Xc480 clknet_1_1__leaf_net287 clknet_1_0__leaf_net985 clknet_1_0__leaf_net964 clknet_1_1__leaf_net414
+ net747 net846 VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__mux4_2
XFILLER_0_36_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout123_A net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c273_A2 net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c570_A0 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc54 net936 net924 net1053 net1055 net1058 VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__a41oi_2
Xc76 net22 net16 net1048 net9 net945 net944 VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__mux4_2
Xc65 net959 net944 net956 VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__a21boi_1
Xc87 net32 net16 net31 net28 net955 c87/S1 VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__mux4_1
Xc98 net942 net26 net42 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__o21a_1
XFILLER_0_97_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A1 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c66_A2 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net490 clknet_0_net490 VGND VGND VPWR VPWR clknet_1_0__leaf_net490
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c167_A3 net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s904_Q_N net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c630_A3 clknet_1_1__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c358_A2 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c390_A0 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net815 net815 VGND VGND VPWR VPWR clknet_0_net815 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c52_A4 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_A2 net1051 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold11 net724 VGND VGND VPWR VPWR net1086 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c93_B1 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c194_A1 net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c625_A3 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net455 clknet_0_net455 VGND VGND VPWR VPWR clknet_1_1__leaf_net455
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net488 clknet_0_net488 VGND VGND VPWR VPWR clknet_1_1__leaf_net488
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_65_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c223_S1 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c551_A2 net369 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_1__f_net794_X clknet_1_1__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net601 net601 VGND VGND VPWR VPWR clknet_0_net601 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c726_A2 net597 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c63_A3 net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c445_A3 clknet_1_0__leaf_net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput56 net963 VGND VGND VPWR VPWR out11 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c461_A2 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput67 net974 VGND VGND VPWR VPWR out24 sky130_fd_sc_hd__clkbuf_1
Xoutput89 net996 VGND VGND VPWR VPWR out46 sky130_fd_sc_hd__buf_2
Xoutput78 clknet_1_1__leaf_net985 VGND VGND VPWR VPWR out35 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c180_A3 net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c187_Q net136 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input16_A in22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c189_A1 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net1068 net1068 VGND VGND VPWR VPWR clknet_0_net1068 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge773_A2 net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_14_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c355_A3 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net263 clknet_0_net263 VGND VGND VPWR VPWR clknet_1_1__leaf_net263
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net252 clknet_0_net252 VGND VGND VPWR VPWR clknet_1_1__leaf_net252
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c234_S0 clknet_1_0__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc309 net255 net1018 net108 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__a21oi_4
XFILLER_0_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s967_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c409_S0 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input8_A in15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge819 net454 clknet_4_5_0_clk net509 VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__dlrtn_2
Xmerge808 net537 net540 VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__xor2_2
Xs903 net315 clknet_4_11_0_clk VGND VGND VPWR VPWR net818 net817 sky130_fd_sc_hd__dlxbn_1
Xs914 clknet_4_1_0_clk net367 VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__dfxtp_4
Xs925 net402 clknet_4_6_0_clk VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xs958 clknet_4_7_0_clk net589 VGND VGND VPWR VPWR net885 net884 sky130_fd_sc_hd__dfxbp_2
Xs947 clknet_4_15_0_clk net539 VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__dlclkp_1
Xs936 net458 clknet_4_6_0_clk VGND VGND VPWR VPWR net857 net856 sky130_fd_sc_hd__dlxbp_1
Xclkbuf_0_net420 net420 VGND VGND VPWR VPWR clknet_0_net420 sky130_fd_sc_hd__clkbuf_16
Xs969 net615 clknet_4_7_0_clk VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_63_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c175_A3 net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s895_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c472_A1 net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c191_A2 net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge801_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net308 clknet_0_net308 VGND VGND VPWR VPWR clknet_1_0__leaf_net308
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge868_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout109 net97 VGND VGND VPWR VPWR net1016 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c557_A1 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout153_A net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc106 net950 net1010 net46 net51 net50 net699 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__mux4_1
XFILLER_0_5_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc117 net922 net1010 net61 net1023 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_96_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc128 net60 net68 net75 net1023 net750 clknet_1_0__leaf_net765 VGND VGND VPWR VPWR
+ net77 sky130_fd_sc_hd__mux4_4
Xc139 net957 net913 net87 net85 net1052 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__a41oi_4
XANTENNA_c442_A4 net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c69_A2 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net250 net250 VGND VGND VPWR VPWR clknet_0_net250 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_52_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge770_A3 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c633_A3 clknet_1_1__leaf_net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc673 clknet_1_0__leaf_net555 net566 net561 clknet_1_0__leaf_net553 VGND VGND VPWR
+ VPWR net567 sky130_fd_sc_hd__a31o_1
Xc662 net1054 net1050 clknet_1_0__leaf_net553 VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__o21ba_4
XANTENNA_c352_A4 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc684 clknet_1_1__leaf_net559 clknet_1_0__leaf_net570 clknet_1_1__leaf_net553 net854
+ net878 net880 VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__mux4_4
Xc695 clknet_1_1__leaf_net372 clknet_1_0__leaf_net585 net812 net881 net882 net883
+ VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__mux4_1
XANTENNA_s950_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c231_S1 net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c568_A0 net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout156_X net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c143_X net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_21_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c734_A2 net597 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c71_A3 net1081 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c453_A3 net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c478_A0 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge765_A3 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c628_A3 clknet_1_1__leaf_net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c363_A3 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c660_A1 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc470 clknet_1_0__leaf_net290 clknet_1_1__leaf_net287 net134 net224 net749 net840
+ VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__mux4_2
Xc481 net410 clknet_1_0__leaf_net414 net762 net786 net1041 net844 VGND VGND VPWR VPWR
+ net416 sky130_fd_sc_hd__mux4_4
Xc492 net151 net956 net1013 net819 clknet_1_1__leaf_net993 net848 VGND VGND VPWR VPWR
+ net427 sky130_fd_sc_hd__mux4_4
XANTENNA_c388_A0 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c257_A4 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c554_A2 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout116_A net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc66 net1029 net1063 net6 VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__o21bai_4
Xc55 net954 net945 net1055 net1053 net959 net949 VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__mux4_2
XFILLER_0_97_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc88 net3 net8 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__nor2b_2
Xc77 net20 net13 net23 net21 net16 VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__a41oi_1
Xc99 net41 net42 net43 net1026 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__a31oi_2
XFILLER_0_97_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A2 net597 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c578_SET_B net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c761_A0 net587 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input46_A in5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c237_S0 net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net794_X clknet_1_0__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c549_A2 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net849 net849 VGND VGND VPWR VPWR clknet_0_net849 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout119_X net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c195_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c581_B1 net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_A3 clknet_1_1__leaf_net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c320_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold12 net742 VGND VGND VPWR VPWR net1087 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_merge817_B net691 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c77_A2 net1081 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_39_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c610_S0 net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c475_A1 clknet_1_1__leaf_net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c194_A2 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c66_Y net1081 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c491_A0 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input49_X net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net401 clknet_0_net401 VGND VGND VPWR VPWR clknet_1_1__leaf_net401
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_83_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net445 clknet_0_net445 VGND VGND VPWR VPWR clknet_1_1__leaf_net445
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net434 clknet_0_net434 VGND VGND VPWR VPWR clknet_1_1__leaf_net434
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net489 clknet_0_net489 VGND VGND VPWR VPWR clknet_1_1__leaf_net489
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c385_A1 net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_90_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_9_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c551_A3 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_69_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net990 clknet_0_net990 VGND VGND VPWR VPWR clknet_1_1__leaf_net990
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_0_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c279_A2 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c726_A3 net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s928_Q net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_78_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c742_A2 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput57 clknet_1_1__leaf_net964 VGND VGND VPWR VPWR out12 sky130_fd_sc_hd__clkbuf_1
Xoutput79 net1010 VGND VGND VPWR VPWR out36 sky130_fd_sc_hd__buf_2
Xoutput68 clknet_1_1__leaf_net975 VGND VGND VPWR VPWR out25 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c180_A4 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c605_S0 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net1069 net1069 VGND VGND VPWR VPWR clknet_0_net1069 sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_70_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c636_A3 net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c371_A3 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output77_A net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net297 clknet_0_net297 VGND VGND VPWR VPWR clknet_1_1__leaf_net297
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net275 clknet_0_net275 VGND VGND VPWR VPWR clknet_1_1__leaf_net275
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c281_A3 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c278_Y net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s878_Q net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge809 net669 clknet_4_5_0_clk net596 VGND VGND VPWR VPWR net708 net707 sky130_fd_sc_hd__dlrbn_1
XFILLER_0_83_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs904 net318 clknet_4_11_0_clk VGND VGND VPWR VPWR net820 net819 sky130_fd_sc_hd__dlxbp_1
Xs915 clknet_4_3_0_clk net374 VGND VGND VPWR VPWR net993 sky130_fd_sc_hd__dlclkp_1
Xs959 clknet_4_7_0_clk net590 VGND VGND VPWR VPWR net887 net886 sky130_fd_sc_hd__dfxbp_1
Xs937 net460 clknet_4_4_0_clk VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__dlxtn_2
Xs948 clknet_4_14_0_clk net544 VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__dlclkp_2
XFILLER_0_48_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xs926 clknet_4_12_0_clk net408 VGND VGND VPWR VPWR net845 net844 sky130_fd_sc_hd__dfxbp_2
XFILLER_0_90_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net487 net487 VGND VGND VPWR VPWR clknet_0_net487 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_11_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c472_A2 clknet_1_1__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c187_Q_N net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c99_B1 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c663_A1 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_85_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net832 clknet_0_net832 VGND VGND VPWR VPWR clknet_1_0__leaf_net832
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c557_A2 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c573_A1 net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc107 net42 net47 net45 net51 net8 net1047 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__mux4_2
Xc118 net713 VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__inv_4
XFILLER_0_5_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout101_X net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc129 net66 net62 net68 net60 net764 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__a41oi_1
XFILLER_0_95_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c748_A1 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c467_A2 net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net251 net251 VGND VGND VPWR VPWR clknet_0_net251 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net295 net295 VGND VGND VPWR VPWR clknet_0_net295 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c483_A1 clknet_1_1__leaf_net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc630 net534 net1008 clknet_1_1__leaf_net472 clknet_1_1__leaf_net794 clknet_1_0__leaf_net849
+ clknet_1_1__leaf_net870 VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__mux4_4
Xc663 net212 clknet_1_0__leaf_net461 clknet_1_0__leaf_net553 VGND VGND VPWR VPWR net556
+ sky130_fd_sc_hd__a21boi_2
Xc696 clknet_1_0__leaf_net573 clknet_1_0__leaf_net583 net481 net853 net878 net884
+ VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__mux4_4
Xc674 net566 clknet_1_1__leaf_net461 clknet_1_0__leaf_net555 clknet_1_0__leaf_net553
+ clknet_1_0__leaf_net556 net852 VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__mux4_2
Xc685 net465 clknet_1_0__leaf_net559 net466 net1043 net831 net879 VGND VGND VPWR VPWR
+ net579 sky130_fd_sc_hd__mux4_1
XANTENNA_merge786_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge777_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c703_S0 net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c287_A2 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c310_Y net257 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c734_A3 net720 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c750_A2 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_14_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c101_SET_B net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c197_A2 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c89_X net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_23_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc460 net1037 clknet_1_0__leaf_net832 net836 net838 net839 net842 VGND VGND VPWR VPWR
+ net399 sky130_fd_sc_hd__mux4_1
Xc482 net134 net383 net256 net763 net772 net786 VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__mux4_4
Xc471 clknet_1_1__leaf_net281 net1018 net279 net772 net840 net1041 VGND VGND VPWR
+ VPWR net407 sky130_fd_sc_hd__mux4_1
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc493 net427 net962 clknet_1_1__leaf_net964 net36 net1040 net1044 VGND VGND VPWR VPWR
+ net428 sky130_fd_sc_hd__mux4_4
XFILLER_0_99_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_32_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_244 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_41_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_93_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_1__f_net448_X clknet_1_1__leaf_net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout109_A net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc56 net1053 net12 net951 net1 net3 net1055 VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__mux4_2
Xc67 net920 net952 net1091 VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__mux2_2
XPHY_EDGE_ROW_50_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c579_B1 net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc78 net24 net1028 net18 net1055 net22 net23 VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__mux4_2
Xc89 net1057 net989 VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__or2b_4
XTAP_TAPCELL_ROW_26_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A3 net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c433_S0 net679 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s958_Q net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c152_S1 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c608_S0 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input39_A in43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_A0 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge776_A3 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c358_A4 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge869_Q net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc290 clknet_4_3_0_clk net109 net218 net918 net807 VGND VGND VPWR VPWR net237 net236
+ sky130_fd_sc_hd__sdfrbp_2
XFILLER_0_46_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c399_B1 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_5_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c332_D net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c581_A1 clknet_1_0__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold13 net369 VGND VGND VPWR VPWR net1088 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c459_A3 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c756_A1 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c475_A2 clknet_1_1__leaf_net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s913_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c194_A3 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c491_A1 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net446 clknet_0_net446 VGND VGND VPWR VPWR clknet_1_1__leaf_net446
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c369_A3 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net980 clknet_0_net980 VGND VGND VPWR VPWR clknet_1_1__leaf_net980
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_36_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c576_A1 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c295_A2 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout131_X net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc532_6 clknet_1_1__leaf_net1068 VGND VGND VPWR VPWR net1073 sky130_fd_sc_hd__clkinv_8
XFILLER_0_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput58 clknet_1_1__leaf_net965 VGND VGND VPWR VPWR out13 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_101_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput69 net976 VGND VGND VPWR VPWR out26 sky130_fd_sc_hd__buf_2
XFILLER_0_98_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c605_S1 net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c189_A3 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c486_A1 clknet_1_1__leaf_net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c340_S1 net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_42_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge819_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_6_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net254 clknet_0_net254 VGND VGND VPWR VPWR clknet_1_1__leaf_net254
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net265 clknet_0_net265 VGND VGND VPWR VPWR clknet_1_1__leaf_net265
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net287 clknet_0_net287 VGND VGND VPWR VPWR clknet_1_1__leaf_net287
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_526 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c706_S0 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c737_A3 net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs905 net320 clknet_4_11_0_clk VGND VGND VPWR VPWR net1006 sky130_fd_sc_hd__dlxtn_2
Xs916 clknet_4_3_0_clk net375 VGND VGND VPWR VPWR net990 sky130_fd_sc_hd__dlclkp_2
Xs949 clknet_4_5_0_clk net568 VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__dlclkp_4
XANTENNA_c160_S1 net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs927 clknet_4_12_0_clk net409 VGND VGND VPWR VPWR net978 net846 sky130_fd_sc_hd__dfxbp_2
Xs938 net475 clknet_4_4_0_clk VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_75_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net455 net455 VGND VGND VPWR VPWR clknet_0_net455 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net488 net488 VGND VGND VPWR VPWR clknet_0_net488 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc530_3 clknet_1_0__leaf_net1069 VGND VGND VPWR VPWR net1070 sky130_fd_sc_hd__inv_2
XANTENNA_c472_A3 clknet_1_0__leaf_net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c616_S0 net738 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input21_A in27 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_13_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c497_A0 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c351_S0 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge851_Q net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c382_A3 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_97_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc108 clknet_4_10_0_clk net51 net38 net3 net1010 net712 VGND VGND VPWR VPWR net55
+ net54 sky130_fd_sc_hd__sdfbbn_1
XTAP_TAPCELL_ROW_96_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc119 net62 net63 net58 net60 net699 net766 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__mux4_2
XFILLER_0_41_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c436_S0 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s890_Q net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c748_A2 net1013 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c85_A3 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c467_A3 net1013 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_52_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net263 net263 VGND VGND VPWR VPWR clknet_0_net263 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net252 net252 VGND VGND VPWR VPWR clknet_0_net252 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c483_A2 net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc620 net1033 clknet_1_1__leaf_net968 clknet_1_1__leaf_net252 clknet_1_0__leaf_net147
+ net388 net797 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__mux4_2
Xc631 net532 net307 net1033 clknet_1_1__leaf_net472 net797 net862 VGND VGND VPWR VPWR
+ net546 sky130_fd_sc_hd__mux4_2
Xc664 net682 VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__clkbuf_2
XANTENNA_s934_Q_N net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c331_SET_B clknet_1_0__leaf_net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc697 net1051 net587 net584 net672 net882 net885 VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__mux4_1
Xc686 clknet_1_1__leaf_net556 net1062 clknet_1_1__leaf_net559 net564 net877 net880
+ VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__mux4_4
Xc675 net565 net562 clknet_1_1__leaf_net555 net566 net855 clknet_1_0__leaf_net872
+ VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__mux4_4
XANTENNA_c346_S0 clknet_1_0__leaf_net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input24_X net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c690_A0 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c568_A2 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c287_A3 net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c136_Y net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c759_A1 net587 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c478_A2 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c197_A3 net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c494_A1 clknet_1_0__leaf_net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc472 clknet_1_1__leaf_net287 net158 clknet_1_1__leaf_net252 clknet_1_0__leaf_net969
+ net840 net1041 VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__mux4_2
Xc450 clknet_1_1__leaf_net376 clknet_1_0__leaf_net252 net1038 net371 net385 net830
+ VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__mux4_4
Xc461 net399 clknet_1_0__leaf_net398 net1 net693 net778 net842 VGND VGND VPWR VPWR
+ net975 sky130_fd_sc_hd__mux4_1
Xc483 clknet_1_1__leaf_net362 clknet_1_1__leaf_net975 net1015 clknet_1_1__leaf_net414
+ net786 net1005 VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__mux4_1
Xc494 clknet_1_0__leaf_net428 clknet_1_0__leaf_net147 net1044 clknet_1_1__leaf_net990
+ net847 net848 VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__mux4_1
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c554_A4 clknet_1_0__leaf_net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_93_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c570_A3 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_1_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc57 net920 net954 net141 net12 net1053 net934 VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__mux4_1
XANTENNA_c714_S0 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc79 net18 net2 net9 net25 net1028 net13 VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__mux4_2
Xc68 net924 net945 net937 VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__a21boi_4
XFILLER_0_97_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c433_S1 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c65_B1_N net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c480_A3 clknet_1_1__leaf_net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c624_S0 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c489_A1 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc280 net1014 net219 net213 net94 net1037 net807 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__mux4_4
Xc291 net232 net233 net235 net234 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__a31o_1
XANTENNA_c399_A1 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge790 net69 net74 VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout121_A net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_31_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_362 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold14 net826 VGND VGND VPWR VPWR net1089 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c62_S0 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge840_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c444_S0 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_100_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c93_A3 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net290 clknet_0_net290 VGND VGND VPWR VPWR clknet_1_0__leaf_net290
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_34_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c491_A2 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c619_S0 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c338_S1 net760 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input51_A in8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge831_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net436 clknet_0_net436 VGND VGND VPWR VPWR clknet_1_1__leaf_net436
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net447 clknet_0_net447 VGND VGND VPWR VPWR clknet_1_1__leaf_net447
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net414 clknet_0_net414 VGND VGND VPWR VPWR clknet_1_1__leaf_net414
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c202_B1_N net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c666_A2 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c385_A3 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_77_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c592_A1 clknet_1_0__leaf_net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc532_7 clknet_1_0__leaf_net1068 VGND VGND VPWR VPWR net1074 sky130_fd_sc_hd__clkinv_8
XANTENNA_fanout124_X net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c57_S0 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput59 net966 VGND VGND VPWR VPWR out16 sky130_fd_sc_hd__buf_2
XFILLER_0_11_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c174_S0 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c621_S1 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s898_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net266 clknet_0_net266 VGND VGND VPWR VPWR clknet_1_1__leaf_net266
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net299 clknet_0_net299 VGND VGND VPWR VPWR clknet_1_1__leaf_net299
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c706_S1 net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c159_X net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs906 net321 clknet_4_11_0_clk VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__dlxtn_1
Xs939 net478 clknet_4_4_0_clk VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__dlxtn_1
Xs917 clknet_4_3_0_clk net379 VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__dlclkp_4
Xclkbuf_0_net401 net401 VGND VGND VPWR VPWR clknet_0_net401 sky130_fd_sc_hd__clkbuf_16
Xs928 clknet_4_12_0_clk net417 VGND VGND VPWR VPWR net1005 sky130_fd_sc_hd__dfxtp_4
XFILLER_0_90_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net445 net445 VGND VGND VPWR VPWR clknet_0_net445 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net434 net434 VGND VGND VPWR VPWR clknet_0_net434 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net489 net489 VGND VGND VPWR VPWR clknet_0_net489 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c753_A3 net1013 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc530_4 clknet_1_1__leaf_net1069 VGND VGND VPWR VPWR net1071 sky130_fd_sc_hd__inv_2
XANTENNA_c169_S0 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c616_S1 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input14_A in20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c497_A1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net990 net990 VGND VGND VPWR VPWR clknet_0_net990 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output82_A net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge811_GATE clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c321_SCE net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc109 clknet_4_10_0_clk net51 net43 net46 net1010 net1083 VGND VGND VPWR VPWR net57
+ net56 sky130_fd_sc_hd__sdfbbp_1
XTAP_TAPCELL_ROW_96_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c717_S0 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input6_A in13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c436_S1 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net297 net297 VGND VGND VPWR VPWR clknet_0_net297 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net275 net275 VGND VGND VPWR VPWR clknet_0_net275 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c483_A3 clknet_1_1__leaf_net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc610 net757 net994 net791 net844 net853 net867 VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__mux4_1
Xc621 clknet_1_1__leaf_net488 net1027 net307 net1008 clknet_1_1__leaf_net436 net797
+ VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__mux4_4
Xc632 clknet_1_0__leaf_net529 net740 net970 net797 clknet_1_0__leaf_net870 clknet_1_0__leaf_net871
+ VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__mux4_2
Xc698 net584 clknet_1_0__leaf_net585 net671 net779 net881 net884 VGND VGND VPWR VPWR
+ net592 sky130_fd_sc_hd__mux4_4
Xc676 net211 net562 net1017 net852 clknet_1_0__leaf_net872 net873 VGND VGND VPWR VPWR
+ net570 sky130_fd_sc_hd__mux4_1
Xc665 net91 clknet_1_1__leaf_net461 net557 VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__a21o_1
Xc687 net467 clknet_1_0__leaf_net474 clknet_1_1__leaf_net556 net812 net878 net879
+ VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__mux4_1
XANTENNA_c627_S0 net1013 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c346_S1 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input17_X net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c187_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c568_A3 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net620 clknet_0_net620 VGND VGND VPWR VPWR clknet_1_0__leaf_net620
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net631 clknet_0_net631 VGND VGND VPWR VPWR clknet_1_0__leaf_net631
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net653 clknet_0_net653 VGND VGND VPWR VPWR clknet_1_0__leaf_net653
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout151_A net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c105_A1 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c478_A3 net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c494_A2 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c297_SCD net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc440 clknet_1_0__leaf_net271 clknet_1_0__leaf_net266 net1016 net136 net723 VGND VGND
+ VPWR VPWR net376 sky130_fd_sc_hd__a41oi_4
Xc451 clknet_1_1__leaf_net265 clknet_1_1__leaf_net250 net386 net387 clknet_1_0__leaf_net266
+ VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__a41oi_4
Xc462 net1067 clknet_1_0__leaf_net975 net1057 net771 clknet_1_0__leaf_net815 net840
+ VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__mux4_2
Xc473 net378 clknet_1_1__leaf_net281 clknet_1_0__leaf_net975 clknet_1_0__leaf_net401
+ net679 net844 VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__mux4_4
Xc484 net158 net378 clknet_1_1__leaf_net172 clknet_1_0__leaf_net964 net817 net978
+ VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__mux4_1
Xc495 net15 clknet_1_0__leaf_net428 net306 net278 net1005 net847 VGND VGND VPWR VPWR
+ net430 sky130_fd_sc_hd__mux4_1
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c332_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc58 net947 net1 net4 net1055 net1053 net954 VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__mux4_2
XANTENNA_c186_A net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc69 net1091 net909 net1053 VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__a21boi_4
XANTENNA_c668_CLK_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net461 clknet_0_net461 VGND VGND VPWR VPWR clknet_1_0__leaf_net461
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net450 clknet_0_net450 VGND VGND VPWR VPWR clknet_1_0__leaf_net450
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout154_X net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net494 clknet_0_net494 VGND VGND VPWR VPWR clknet_1_0__leaf_net494
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net472 clknet_0_net472 VGND VGND VPWR VPWR clknet_1_0__leaf_net472
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c595_A1 clknet_1_1__leaf_net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c177_S0 net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net629 clknet_0_net629 VGND VGND VPWR VPWR clknet_1_1__leaf_net629
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net618 clknet_0_net618 VGND VGND VPWR VPWR clknet_1_1__leaf_net618
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_A2 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c624_S1 clknet_1_1__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s952_GATE clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc270 net213 net214 net956 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__o21ba_1
Xc281 net221 net223 net219 net1037 net806 net808 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__mux4_1
Xc292 net728 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c399_A2 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge780 net162 net168 VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__xor2_2
Xmerge791 net137 net143 VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__xor2_1
XFILLER_0_70_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c581_A3 net1051 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout114_A net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold15 net386 VGND VGND VPWR VPWR net1090 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c62_S1 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c444_S1 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c756_A3 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c619_S1 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input44_A in48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c635_S0 net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net448 clknet_0_net448 VGND VGND VPWR VPWR clknet_1_1__leaf_net448
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net459 clknet_0_net459 VGND VGND VPWR VPWR clknet_1_1__leaf_net459
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_84_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c545_S0 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c203_A1 clknet_1_1__leaf_net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net960 clknet_0_net960 VGND VGND VPWR VPWR clknet_1_1__leaf_net960
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_0_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net993 clknet_0_net993 VGND VGND VPWR VPWR clknet_1_1__leaf_net993
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_95_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c280_S0 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_38_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc532_8 clknet_1_1__leaf_net1068 VGND VGND VPWR VPWR net1075 sky130_fd_sc_hd__clkinv_8
XFILLER_0_16_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c104_X net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c57_S1 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout117_X net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c439_S1 clknet_1_0__leaf_net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c406_SCD net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c486_A3 net15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c304_B1 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_38_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c266_A net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs907 net322 clknet_4_11_0_clk VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__dlxtn_2
XFILLER_0_48_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs929 clknet_4_14_0_clk net423 VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__dfxtp_2
Xs918 net380 clknet_4_6_0_clk VGND VGND VPWR VPWR net834 net833 sky130_fd_sc_hd__dlxbn_1
Xclkbuf_0_net446 net446 VGND VGND VPWR VPWR clknet_0_net446 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s926_Q net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc530_5 clknet_1_0__leaf_net1069 VGND VGND VPWR VPWR net1072 sky130_fd_sc_hd__inv_2
XANTENNA_c169_S1 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge798_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c497_A2 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0_net980 net980 VGND VGND VPWR VPWR clknet_0_net980 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net813 clknet_0_net813 VGND VGND VPWR VPWR clknet_1_0__leaf_net813
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c200_A2 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c598_A1 net388 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c452_S1 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net254 net254 VGND VGND VPWR VPWR clknet_0_net254 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net265 net265 VGND VGND VPWR VPWR clknet_0_net265 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0_net287 net287 VGND VGND VPWR VPWR clknet_0_net287 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_32_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc600 clknet_1_1__leaf_net401 clknet_1_0__leaf_net968 net809 net811 clknet_1_0__leaf_net990
+ net862 VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__mux4_1
Xc622 clknet_1_0__leaf_net434 net388 net962 net1000 net785 clknet_1_1__leaf_net851
+ VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__mux4_4
Xc611 net97 clknet_1_1__leaf_net398 clknet_1_0__leaf_net513 clknet_1_0__leaf_net968
+ clknet_1_1__leaf_net401 net862 VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__mux4_2
Xc633 net542 clknet_1_1__leaf_net522 net306 clknet_1_1__leaf_net975 net845 clknet_1_0__leaf_net871
+ VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__mux4_2
Xc688 net564 net467 clknet_1_1__leaf_net474 clknet_1_1__leaf_net559 net879 net882
+ VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__mux4_2
Xc677 net558 net566 clknet_1_0__leaf_net570 clknet_1_0__leaf_net553 net561 net338
+ VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__mux4_1
Xc666 clknet_1_1__leaf_net445 net212 clknet_1_0__leaf_net553 VGND VGND VPWR VPWR net559
+ sky130_fd_sc_hd__a21boi_4
Xc699 net591 net783 net881 net882 net883 net886 VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s961_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_80_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout144_A net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c728_S0 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c81_S0 net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c463_S0 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s943_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c494_A3 clknet_1_1__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c297_SCE net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge775_S0 net338 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc430 net958 net1054 net1034 VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__a21bo_1
XFILLER_0_20_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc441 clknet_1_0__leaf_net376 net371 net359 net1031 net1035 VGND VGND VPWR VPWR net377
+ sky130_fd_sc_hd__a41o_4
Xc452 clknet_1_1__leaf_net250 clknet_1_0__leaf_net390 clknet_1_0__leaf_net252 net385
+ clknet_1_0__leaf_net389 net828 VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__mux4_2
Xc463 net1057 clknet_1_0__leaf_net975 net679 net778 net1045 net840 VGND VGND VPWR
+ VPWR net401 sky130_fd_sc_hd__mux4_4
Xc474 net13 net1063 net1067 net989 net845 net846 VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__mux4_1
Xc496 clknet_1_1__leaf_net172 clknet_1_0__leaf_net965 net989 net848 clknet_1_0__leaf_net849
+ clknet_1_0__leaf_net850 VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__mux4_1
Xc485 clknet_1_1__leaf_net164 net1018 net1013 clknet_1_1__leaf_net312 net977 clknet_1_1__leaf_net990
+ VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__mux4_2
XFILLER_0_19_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_306 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s939_GATE_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_10_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c206_A1 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc59 net914 net5 net923 net1055 net6 net947 VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__mux4_1
XFILLER_0_92_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c298_A4 net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net462 clknet_0_net462 VGND VGND VPWR VPWR clknet_1_0__leaf_net462
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c595_A2 clknet_1_1__leaf_net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout147_X net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c458_S0 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c177_S1 net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_A3 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc260 clknet_1_0__leaf_net204 clknet_1_1__leaf_net202 net992 net767 net768 net803
+ VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__mux4_1
Xc271 net1052 net212 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__and2_1
Xc293 net234 net239 net109 net113 net233 net1021 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__mux4_1
Xc282 net732 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__buf_6
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge770 net138 net30 net123 net148 net121 VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__a41oi_2
XFILLER_0_28_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge781 net327 net328 VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__xnor2_2
XFILLER_0_62_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge792 clknet_4_4_0_clk net477 net470 VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_15_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c217_A0 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c581_A4 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c582_D net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net281 clknet_0_net281 VGND VGND VPWR VPWR clknet_1_0__leaf_net281
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input37_A in41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c370_S1 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge867_Q net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c682_A3 clknet_1_1__leaf_net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c545_S1 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c500_A0 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c576_A4 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc532_9 clknet_1_0__leaf_net1068 VGND VGND VPWR VPWR net1076 sky130_fd_sc_hd__clkinv_8
XFILLER_0_16_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c736_S0 net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c406_SCE net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c471_S0 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net202 clknet_0_net202 VGND VGND VPWR VPWR clknet_1_1__leaf_net202
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c365_S1 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs919 net391 clknet_4_3_0_clk VGND VGND VPWR VPWR net836 net835 sky130_fd_sc_hd__dlxbn_1
Xs908 net345 clknet_4_4_0_clk VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__dlxtp_1
Xclkbuf_0_net414 net414 VGND VGND VPWR VPWR clknet_0_net414 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net436 net436 VGND VGND VPWR VPWR clknet_0_net436 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net447 net447 VGND VGND VPWR VPWR clknet_0_net447 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_2_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c466_S0 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c124_A1 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c497_A3 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_57_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output68_A clknet_1_1__leaf_net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_66_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net814 clknet_0_net814 VGND VGND VPWR VPWR clknet_1_0__leaf_net814
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_75_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_84_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c598_A2 clknet_1_1__leaf_net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s889_GATE_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c164_X net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c79_S0 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_52_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net266 net266 VGND VGND VPWR VPWR clknet_0_net266 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net299 net299 VGND VGND VPWR VPWR clknet_0_net299 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_32_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc601 clknet_1_0__leaf_net489 clknet_1_1__leaf_net398 clknet_1_1__leaf_net290 net784
+ clknet_1_1__leaf_net794 net857 VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__mux4_2
Xc612 clknet_1_1__leaf_net513 net1011 net755 net970 net864 net868 VGND VGND VPWR VPWR
+ net528 sky130_fd_sc_hd__mux4_1
Xc634 clknet_1_1__leaf_net472 clknet_1_1__leaf_net428 clknet_1_1__leaf_net436 clknet_1_1__leaf_net538
+ clknet_1_1__leaf_net420 net977 VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__mux4_2
Xc623 net55 net1027 clknet_1_0__leaf_net436 net785 net797 net862 VGND VGND VPWR VPWR
+ net538 sky130_fd_sc_hd__mux4_1
Xc689 net925 clknet_1_1__leaf_net553 net831 net854 net880 net881 VGND VGND VPWR VPWR
+ net583 sky130_fd_sc_hd__mux4_4
Xc678 clknet_1_1__leaf_net555 net566 clknet_1_0__leaf_net553 net682 net874 net876
+ VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__mux4_4
Xc667 net682 VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__inv_2
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c301_A2 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net633 clknet_0_net633 VGND VGND VPWR VPWR clknet_1_0__leaf_net633
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net611 clknet_0_net611 VGND VGND VPWR VPWR clknet_1_0__leaf_net611
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c584_A4 net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout137_A net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge870_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c105_A3 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c81_S1 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c463_S1 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc420 net332 net228 net92 net1037 net1034 net1031 VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__mux4_2
XFILLER_0_20_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc453 clknet_1_0__leaf_net389 net102 net384 net918 net1038 net835 VGND VGND VPWR VPWR
+ net392 sky130_fd_sc_hd__mux4_2
Xc464 clknet_1_1__leaf_net252 clknet_1_0__leaf_net299 clknet_1_1__leaf_net364 clknet_1_0__leaf_net398
+ net771 clknet_1_0__leaf_net990 VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__mux4_1
Xc431 net946 net105 net1035 clknet_1_0__leaf_net364 net829 net830 VGND VGND VPWR VPWR
+ net367 sky130_fd_sc_hd__mux4_4
Xc442 net359 net1024 net1031 net959 net1045 VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__a41o_2
XFILLER_0_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge861_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc486 clknet_1_0__leaf_net312 clknet_1_1__leaf_net414 clknet_1_0__leaf_net420 net15
+ clknet_1_1__leaf_net164 net796 VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__mux4_4
Xc475 net384 clknet_1_1__leaf_net271 clknet_1_1__leaf_net147 net749 net844 net978
+ VGND VGND VPWR VPWR net964 sky130_fd_sc_hd__mux4_1
Xc497 net1018 net1041 net844 net978 net848 clknet_1_1__leaf_net850 VGND VGND VPWR
+ VPWR net974 sky130_fd_sc_hd__mux4_2
XFILLER_0_99_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c685_A3 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c503_A0 net54 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c564_S0 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c283_S1 net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c579_A4 clknet_1_1__leaf_net488 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net474 clknet_0_net474 VGND VGND VPWR VPWR clknet_1_0__leaf_net474
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net463 clknet_0_net463 VGND VGND VPWR VPWR clknet_1_0__leaf_net463
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net496 clknet_0_net496 VGND VGND VPWR VPWR clknet_1_0__leaf_net496
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_34_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c458_S1 net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c116_A2 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge843_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net609 clknet_0_net609 VGND VGND VPWR VPWR clknet_1_1__leaf_net609
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c474_S0 net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c193_S1 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c320_Q net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c368_S1 net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc250 net1029 net79 net70 clknet_1_1__leaf_net178 net989 VGND VGND VPWR VPWR net199
+ sky130_fd_sc_hd__a41o_4
XANTENNA_merge834_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc261 clknet_1_1__leaf_net206 net197 clknet_1_0__leaf_net960 net992 net767 VGND VGND
+ VPWR VPWR net207 sky130_fd_sc_hd__a41o_4
Xc272 net916 net217 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__or2b_4
Xc283 net214 net215 net220 net81 net222 net808 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__mux4_1
Xc294 net916 net939 net116 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__o21ai_2
XANTENNA_c323_B1 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c384_S0 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c447_Q_N net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge782 net663 net665 VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__xnor2_1
Xmerge771 net219 net220 net222 net112 net1061 net806 VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__mux4_1
Xmerge793 clknet_4_8_0_clk net33 merge793/RESET_B VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_31_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c559_S0 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c102_A4 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_1_1__f_net975_X clknet_1_1__leaf_net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net271 clknet_0_net271 VGND VGND VPWR VPWR clknet_1_0__leaf_net271
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c469_S0 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c188_S1 net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c143_B1 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net428 clknet_0_net428 VGND VGND VPWR VPWR clknet_1_1__leaf_net428
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_output98_A net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c500_A1 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c561_S1 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge877_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net618 net618 VGND VGND VPWR VPWR clknet_0_net618 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net629 net629 VGND VGND VPWR VPWR clknet_0_net629 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_16_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c228_B1 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c471_S1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c138_B1 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net269 clknet_0_net269 VGND VGND VPWR VPWR clknet_1_1__leaf_net269
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c693_A3 net1051 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs909 net346 clknet_4_4_0_clk VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xclkbuf_0_net448 net448 VGND VGND VPWR VPWR clknet_0_net448 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net459 net459 VGND VGND VPWR VPWR clknet_0_net459 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout122_X net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c421_A0 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c482_S0 net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net960 net960 VGND VGND VPWR VPWR clknet_0_net960 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c400_Q net336 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net993 net993 VGND VGND VPWR VPWR clknet_0_net993 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c62_X net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input52_X net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net815 clknet_0_net815 VGND VGND VPWR VPWR clknet_1_0__leaf_net815
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_85_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c111_B1_N net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_7_0_clk_X clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c79_S1 net1081 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c693_X net587 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc613 net526 clknet_1_1__leaf_net462 net1036 net866 net867 net868 VGND VGND VPWR VPWR
+ net529 sky130_fd_sc_hd__mux4_1
Xc602 clknet_1_1__leaf_net505 clknet_1_0__leaf_net514 clknet_1_1__leaf_net290 net1039
+ clknet_1_0__leaf_net987 net784 VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__mux4_4
XANTENNA_c477_S0 clknet_1_0__leaf_net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc635 net55 clknet_1_1__leaf_net504 net740 clknet_1_1__leaf_net987 net977 clknet_1_0__leaf_net871
+ VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__mux4_2
Xc624 clknet_1_1__leaf_net529 net1033 clknet_1_0__leaf_net965 clknet_1_1__leaf_net428
+ net966 clknet_1_1__leaf_net794 VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__mux4_4
XANTENNA_c135_A1 net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc679 clknet_1_0__leaf_net553 net682 net853 clknet_1_1__leaf_net872 net874 net876
+ VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__mux4_4
Xc668 clknet_4_5_0_clk net557 clknet_1_1__leaf_net445 net1050 clknet_1_0__leaf_net553
+ clknet_1_0__leaf_net559 VGND VGND VPWR VPWR net562 net561 sky130_fd_sc_hd__sdfbbn_1
XANTENNA_c196_S1 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c151_A0 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input12_A in19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c387_S0 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c699_A2 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net601 clknet_0_net601 VGND VGND VPWR VPWR clknet_1_0__leaf_net601
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_0_net147_A net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c583_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input4_A in11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s881_Q net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c121_A3 net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c157_B1_N net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c146_B1 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s909_SLEEP_B clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s905_GATE_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc421 net931 net228 clknet_1_0__leaf_net251 net1034 net1030 net807 VGND VGND VPWR
+ VPWR net357 sky130_fd_sc_hd__mux4_4
Xc410 net340 net344 net343 net335 net1049 net698 VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__mux4_1
Xc443 net956 net1049 net256 net1093 clknet_1_1__leaf_net266 net1024 VGND VGND VPWR
+ VPWR net379 sky130_fd_sc_hd__mux4_2
Xc432 clknet_1_0__leaf_net364 net335 net356 net105 net1034 net831 VGND VGND VPWR VPWR
+ net368 sky130_fd_sc_hd__mux4_1
Xc454 net386 clknet_1_0__leaf_net377 net383 net387 net836 net838 VGND VGND VPWR VPWR
+ net393 sky130_fd_sc_hd__mux4_1
XFILLER_0_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc487 clknet_1_0__leaf_net305 clknet_1_1__leaf_net172 clknet_1_0__leaf_net147 net1007
+ net976 net817 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__mux4_4
Xc465 clknet_1_1__leaf_net295 net972 clknet_1_0__leaf_net401 net279 net1067 net778
+ VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__mux4_4
Xc476 net1048 clknet_1_1__leaf_net364 net749 net792 net843 net846 VGND VGND VPWR VPWR
+ net411 sky130_fd_sc_hd__mux4_1
Xc498 net1007 net387 clknet_1_1__leaf_net794 net818 net1005 net848 VGND VGND VPWR
+ VPWR net432 sky130_fd_sc_hd__mux4_2
XFILLER_0_35_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input15_X net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c222_A2 net1066 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net420 clknet_0_net420 VGND VGND VPWR VPWR clknet_1_0__leaf_net420
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_25_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c739_S1 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c474_S1 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c490_S0 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc251 clknet_1_1__leaf_net165 net76 c251/A3 clknet_1_1__leaf_net735 clknet_1_1__leaf_net793
+ VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__a41o_2
Xc262 clknet_1_0__leaf_net207 clknet_1_1__leaf_net204 net992 clknet_1_0__leaf_net206
+ net767 net768 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__mux4_4
Xc240 clknet_1_0__leaf_net186 clknet_1_0__leaf_net182 clknet_1_0__leaf_net172 net673
+ net799 net1044 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__mux4_4
XANTENNA_c323_A1 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc273 net213 net141 net101 net218 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__a31o_1
Xc295 net239 net1037 net236 VGND VGND VPWR VPWR net981 sky130_fd_sc_hd__a21boi_1
Xc284 net221 net218 net1046 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__o21bai_4
XANTENNA_c384_S1 net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c696_A3 net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge772 net64 net67 net68 net63 net750 net766 VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__mux4_2
XFILLER_0_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge794 net240 net253 VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__xor2_1
Xmerge783 clknet_4_1_0_clk net368 net358 VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__dfrtn_1
XFILLER_0_15_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c217_A2 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s951_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c184_A net723 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net250 clknet_0_net250 VGND VGND VPWR VPWR clknet_1_0__leaf_net250
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_clkbuf_1_1__f_net968_X clknet_1_1__leaf_net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout152_X net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c469_S1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c485_S0 net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c89_B_N net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_583 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_90_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c334_B1 net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net985 clknet_0_net985 VGND VGND VPWR VPWR clknet_1_1__leaf_net985
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c500_A2 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout112_A net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c108_Q_N net54 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c419_B1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c138_A1 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c154_B1 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input42_A in46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net204 clknet_0_net204 VGND VGND VPWR VPWR clknet_1_1__leaf_net204
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net248 clknet_0_net248 VGND VGND VPWR VPWR clknet_1_1__leaf_net248
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_97_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge872_Q net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s957_SLEEP_B clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c660_B1_N net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c214_A3 net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net793 clknet_0_net793 VGND VGND VPWR VPWR clknet_1_1__leaf_net793
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c230_A2 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout115_X net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c421_A1 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c149_A0 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c55_X net1082 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c392_S1 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s964_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net849 clknet_0_net849 VGND VGND VPWR VPWR clknet_1_0__leaf_net849
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_57_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c271_B net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net414_X clknet_1_1__leaf_net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c134_A_N net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c264_A net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c157_Y net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c529_A net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net202 net202 VGND VGND VPWR VPWR clknet_0_net202 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge827_GATE clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc603 clknet_1_0__leaf_net513 clknet_1_1__leaf_net398 net97 clknet_1_0__leaf_net514
+ net856 net864 VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__mux4_4
XFILLER_0_32_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c477_S1 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc625 clknet_1_1__leaf_net462 clknet_1_0__leaf_net965 net1057 net1047 clknet_1_0__leaf_net967
+ clknet_1_1__leaf_net472 VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__mux4_2
Xc636 clknet_1_0__leaf_net522 clknet_1_1__leaf_net305 net550 net1015 net740 clknet_1_1__leaf_net870
+ VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__mux4_1
Xc614 net526 clknet_1_0__leaf_net529 clknet_1_1__leaf_net252 clknet_1_0__leaf_net522
+ net755 net856 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__mux4_4
XFILLER_0_4_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c135_A2 net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc669 clknet_1_1__leaf_net461 clknet_1_1__leaf_net445 clknet_1_0__leaf_net448 VGND
+ VGND VPWR VPWR net563 sky130_fd_sc_hd__a21bo_4
XANTENNA_c432_A0 clknet_1_0__leaf_net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c493_S0 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_23_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c607_A0 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c326_A1 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_57_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c357_SET_B net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc400 clknet_4_1_0_clk net222 net214 net220 net335 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__sdfrtp_1
Xc411 net333 net1049 net732 net810 net811 net824 VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__mux4_2
Xc422 net244 clknet_1_0__leaf_net357 net1034 net1030 net112 VGND VGND VPWR VPWR net358
+ sky130_fd_sc_hd__a41o_1
Xc455 clknet_1_1__leaf_net271 clknet_1_0__leaf_net377 clknet_1_1__leaf_net250 net830
+ net838 net839 VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__mux4_4
Xc433 net366 net946 net1037 net332 net679 net810 VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__mux4_2
Xc444 net918 net363 clknet_1_0__leaf_net377 net1024 net378 net827 VGND VGND VPWR VPWR
+ net380 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_8_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc466 net400 clknet_1_0__leaf_net281 net909 clknet_1_0__leaf_net401 net1037 net843
+ VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__mux4_2
Xc488 clknet_1_0__leaf_net305 clknet_1_0__leaf_net965 net1020 net1018 clknet_1_1__leaf_net765
+ net775 VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__mux4_2
Xc477 clknet_1_1__leaf_net299 clknet_1_1__leaf_net281 clknet_1_0__leaf_net964 net762
+ clknet_1_0__leaf_net993 net978 VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__mux4_4
XFILLER_0_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc499 net424 clknet_1_0__leaf_net290 clknet_1_1__leaf_net965 clknet_1_0__leaf_net428
+ net984 net848 VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__mux4_1
XFILLER_0_35_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_11_0_clk_X clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c503_A2 net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_hold13_A net369 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net968_X clknet_1_0__leaf_net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net487 clknet_0_net487 VGND VGND VPWR VPWR clknet_1_0__leaf_net487
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout142_A net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net793_A net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c710_A0 clknet_1_1__leaf_net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc230 net171 clknet_1_0__leaf_net175 net922 net173 net1039 net1059 VGND VGND VPWR
+ VPWR net180 sky130_fd_sc_hd__mux4_4
XFILLER_0_32_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc241 clknet_1_1__leaf_net187 clknet_1_0__leaf_net178 net772 net799 net803 net1044
+ VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__mux4_1
Xc263 clknet_1_1__leaf_net204 clknet_1_0__leaf_net207 net697 net790 net1044 net805
+ VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__mux4_4
Xc252 net197 net79 net70 net922 net697 VGND VGND VPWR VPWR net982 sky130_fd_sc_hd__a41oi_4
XANTENNA_c604_A1 clknet_1_1__leaf_net488 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc274 net217 net210 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__nor2b_2
Xc296 net241 net239 net931 net1030 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__a31o_1
Xc285 net912 net220 net223 net228 net215 net806 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__mux4_1
XANTENNA_c323_A2 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c620_A0 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge773 net452 clknet_1_0__leaf_net446 net96 net337 net344 net1011 VGND VGND VPWR
+ VPWR net667 sky130_fd_sc_hd__mux4_2
XFILLER_0_55_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge784 net625 net628 VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_31_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge795 net264 net261 VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__xor2_1
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xs890 net188 clknet_4_10_0_clk VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__dlxtn_4
XFILLER_0_30_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c233_A2 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c591_S0 net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net251 clknet_0_net251 VGND VGND VPWR VPWR clknet_1_0__leaf_net251
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net295 clknet_0_net295 VGND VGND VPWR VPWR clknet_1_0__leaf_net295
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c408_A2 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c599_X net515 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c485_S1 clknet_1_1__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_98_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c440_B1 net723 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c173_SET_B net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c334_A1 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c395_S1 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c449_CLK_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c350_A0 net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net975 clknet_0_net975 VGND VGND VPWR VPWR clknet_1_1__leaf_net975
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net964 clknet_0_net964 VGND VGND VPWR VPWR clknet_1_1__leaf_net964
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_64_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c500_A3 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net609 net609 VGND VGND VPWR VPWR clknet_0_net609 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_7_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c228_A2 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c447_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c138_A2 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c53_B1 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c435_B1 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c154_A1 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input35_A in4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c170_A0 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c601_A2 clknet_1_1__leaf_net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net249 clknet_0_net249 VGND VGND VPWR VPWR clknet_1_1__leaf_net249
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_43_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c329_A1 clknet_1_0__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c345_A0 net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net794 clknet_0_net794 VGND VGND VPWR VPWR clknet_1_1__leaf_net794
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net428 net428 VGND VGND VPWR VPWR clknet_0_net428 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_33_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout108_X net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c405_A3 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge796_Y net691 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_17_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_26_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c612_A1 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net364_X clknet_1_0__leaf_net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c241_A2 net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c264_B net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_53_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net990_A net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net269 net269 VGND VGND VPWR VPWR clknet_0_net269 sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_62_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc604 clknet_1_0__leaf_net975 clknet_1_1__leaf_net488 clknet_1_0__leaf_net964 clknet_1_0__leaf_net414
+ net1054 net970 VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__mux4_4
Xc637 net439 clknet_1_1__leaf_net434 net1004 net770 net977 clknet_1_1__leaf_net871
+ VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__mux4_2
Xc615 clknet_1_0__leaf_net414 clknet_1_1__leaf_net734 net757 net994 net868 net869
+ VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__mux4_4
Xc626 clknet_1_1__leaf_net414 clknet_1_1__leaf_net964 net1006 net1005 clknet_1_1__leaf_net851
+ clknet_1_1__leaf_net870 VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__mux4_1
XANTENNA_c713_A0 clknet_1_1__leaf_net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c493_S1 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_80_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c607_A1 clknet_1_1__leaf_net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c623_A0 net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s882_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c342_A1 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s934_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c541_A net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c488_S1 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc401 net220 net221 net211 VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__o21bai_4
Xc412 net347 net340 net1049 net101 net1050 net698 VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__mux4_1
XANTENNA_c443_A0 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc423 net939 net1012 net1035 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__a21oi_2
Xc434 net1088 net363 net1034 net679 VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__a31o_1
Xc445 clknet_1_1__leaf_net377 clknet_1_1__leaf_net271 net1062 clknet_1_0__leaf_net993
+ clknet_1_0__leaf_net832 net833 VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__mux4_4
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc467 clknet_1_0__leaf_net362 clknet_1_0__leaf_net295 net158 net1013 net1011 clknet_1_0__leaf_net815
+ VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__mux4_4
Xc456 net1014 clknet_1_0__leaf_net275 net693 net835 net837 net840 VGND VGND VPWR VPWR
+ net395 sky130_fd_sc_hd__mux4_1
Xc478 net909 clknet_1_0__leaf_net964 net378 net387 net15 net845 VGND VGND VPWR VPWR
+ net413 sky130_fd_sc_hd__mux4_4
Xc489 net1020 net972 net1004 net1006 net1041 net846 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__mux4_4
XFILLER_0_35_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_93_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge837_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c353_B1 net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net455 clknet_0_net455 VGND VGND VPWR VPWR clknet_1_0__leaf_net455
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net488 clknet_0_net488 VGND VGND VPWR VPWR clknet_1_0__leaf_net488
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_34_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c413_A3 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c56_A0 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c438_A0 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c499_S0 net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c157_A1 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_79_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc220 net35 net158 net1047 net37 net44 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__a41o_1
Xc231 net84 clknet_1_0__leaf_net180 clknet_1_0__leaf_net176 net121 net171 net158 VGND
+ VGND VPWR VPWR net181 sky130_fd_sc_hd__mux4_2
Xc253 net196 net197 net79 net1015 net772 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__a41o_1
XFILLER_0_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc242 net79 net1059 net913 net803 net1044 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__a41o_1
Xc286 net120 net105 net946 net1021 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__a31o_1
Xc264 net918 net91 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__or2_4
Xc297 clknet_4_0_0_clk net114 net1030 net108 net113 net806 VGND VGND VPWR VPWR net244
+ net243 sky130_fd_sc_hd__sdfbbn_1
Xc275 net213 net218 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_5_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A1 clknet_1_1__leaf_net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge763 net116 net113 net230 net1022 net109 net1086 VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__mux4_1
XANTENNA_c348_A0 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge796 net612 net617 VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__xnor2_2
Xmerge774 net131 net918 net1009 net118 net947 VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__a41oi_4
XTAP_TAPCELL_ROW_31_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge785 net511 net520 VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__xnor2_4
Xs880 clknet_4_10_0_clk net80 VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__dfxtp_4
Xs891 net189 clknet_4_11_0_clk VGND VGND VPWR VPWR net983 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_51_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c591_S1 net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput1 in0 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_67_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net263 clknet_0_net263 VGND VGND VPWR VPWR clknet_1_0__leaf_net263
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net252 clknet_0_net252 VGND VGND VPWR VPWR clknet_1_0__leaf_net252
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout138_X net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c408_A3 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c424_A2 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c290_SCD net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c692_S0 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net965 clknet_0_net965 VGND VGND VPWR VPWR clknet_1_1__leaf_net965
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net987 clknet_0_net987 VGND VGND VPWR VPWR clknet_1_1__leaf_net987
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_64_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c244_A2 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c419_A2 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_76_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c154_A2 net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c170_A1 net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net206 clknet_0_net206 VGND VGND VPWR VPWR clknet_1_1__leaf_net206
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_input28_A in33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c566_SCE net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_87_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge858_Q net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c626_A0 clknet_1_1__leaf_net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_output96_A net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net795 clknet_0_net795 VGND VGND VPWR VPWR clknet_1_1__leaf_net795
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c239_A2 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c597_S0 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c702_A2 net587 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s897_Q net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c149_A2 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c187_SET_B net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net985 net985 VGND VGND VPWR VPWR clknet_0_net985 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c300_S0 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net570 clknet_0_net570 VGND VGND VPWR VPWR clknet_1_1__leaf_net570
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net204 net204 VGND VGND VPWR VPWR clknet_0_net204 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net248 net248 VGND VGND VPWR VPWR clknet_0_net248 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_60_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout120_X net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc616 clknet_1_0__leaf_net147 clknet_1_1__leaf_net494 clknet_1_1__leaf_net305 clknet_1_1__leaf_net967
+ net738 net1005 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__mux4_4
Xc627 net388 clknet_1_0__leaf_net538 net1015 clknet_1_0__leaf_net436 net1013 clknet_1_1__leaf_net851
+ VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__mux4_4
Xc605 clknet_1_1__leaf_net446 clknet_1_0__leaf_net414 clknet_1_0__leaf_net398 clknet_1_1__leaf_net252
+ net1033 net791 VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__mux4_2
XANTENNA_c713_A1 net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net793 net793 VGND VGND VPWR VPWR clknet_0_net793 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c326_A3 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge764_1_A net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c623_A1 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output59_A net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c205_S0 net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c236_A3 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_1_1__f_net252_X clknet_1_1__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c146_A3 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c61_A1 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc402 net337 net101 net1017 VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__o21bai_4
XFILLER_0_32_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c443_A1 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc435 net241 net918 net1012 net1035 net831 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__a41oi_4
Xc413 net348 net223 net340 net1011 net347 net332 VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__mux4_4
Xc446 net371 clknet_1_1__leaf_net250 net1024 net363 net1011 clknet_1_0__leaf_net377
+ VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__mux4_2
Xc424 net1035 net105 net811 VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__o21ba_1
Xc479 net410 net1063 clknet_1_0__leaf_net964 net989 net749 net845 VGND VGND VPWR VPWR
+ net414 sky130_fd_sc_hd__mux4_4
Xc468 net279 net224 net1032 net1025 clknet_1_1__leaf_net993 net840 VGND VGND VPWR
+ VPWR net985 sky130_fd_sc_hd__mux4_1
Xc457 clknet_1_1__leaf_net389 net692 net830 net834 net836 net840 VGND VGND VPWR VPWR
+ net396 sky130_fd_sc_hd__mux4_4
XANTENNA_c162_A2 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input10_A in17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c321_RESET_B net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge840_Q net744 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c353_A1 net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s893_SLEEP_B clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net434 clknet_0_net434 VGND VGND VPWR VPWR clknet_1_0__leaf_net434
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net401 clknet_0_net401 VGND VGND VPWR VPWR clknet_1_0__leaf_net401
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net445 clknet_0_net445 VGND VGND VPWR VPWR clknet_1_0__leaf_net445
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net489 clknet_0_net489 VGND VGND VPWR VPWR clknet_1_0__leaf_net489
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c589_S1 net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c528_A1 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout128_A net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input2_A in1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net990 clknet_0_net990 VGND VGND VPWR VPWR clknet_1_0__leaf_net990
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c157_A2 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c72_B1 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc210 net952 net158 net157 net1063 clknet_1_0__leaf_net156 net152 VGND VGND VPWR VPWR
+ net160 sky130_fd_sc_hd__mux4_4
Xc221 net23 net47 net1059 net962 net121 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__a41oi_4
XFILLER_0_20_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc232 net30 clknet_1_0__leaf_net178 net173 net674 net746 net796 VGND VGND VPWR VPWR
+ net182 sky130_fd_sc_hd__mux4_4
Xc243 net1039 clknet_1_1__leaf_net735 net802 net804 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__a31o_4
Xc254 net196 net982 net1060 net804 VGND VGND VPWR VPWR net992 sky130_fd_sc_hd__a31oi_4
Xc287 net94 net116 net98 net108 net230 net724 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__mux4_2
Xc276 net217 net101 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__or2_2
Xc265 net210 net1017 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__nand2_4
XANTENNA_c323_A4 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc298 net243 net1030 net116 net1061 net711 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__a41o_1
XTAP_TAPCELL_ROW_5_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A2 clknet_1_1__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge766_B1 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c348_A1 net1081 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge775 net560 clknet_1_1__leaf_net555 net1049 net86 net338 net557 VGND VGND VPWR
+ VPWR net669 sky130_fd_sc_hd__mux4_2
Xmerge786 clknet_4_5_0_clk net567 net662 VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_31_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge797 clknet_4_3_0_clk net381 net382 VGND VGND VPWR VPWR net693 net692 sky130_fd_sc_hd__dfsbp_1
XFILLER_0_83_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs892 net191 clknet_4_11_0_clk VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__dlxtp_1
Xs881 clknet_4_2_0_clk net124 VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_70_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput2 in1 VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_67_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net275 clknet_0_net275 VGND VGND VPWR VPWR clknet_1_0__leaf_net275
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net297 clknet_0_net297 VGND VGND VPWR VPWR clknet_1_0__leaf_net297
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c705_A2 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge843_D net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c143_A4 net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c721_A1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c536_B1_N net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c334_A3 net1081 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c631_A1 net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c350_A2 net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c359_B1 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c107_S1 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c123_S0 net1066 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout150_X net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c716_A1 net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c53_A2 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c435_A2 net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c732_A0 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net207 clknet_0_net207 VGND VGND VPWR VPWR clknet_1_1__leaf_net207
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c329_A3 net744 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge763_A1 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s900_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_49_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_8_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c597_S1 net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c536_A1 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout110_A net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c702_A3 net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s958_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c149_A3 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net964 net964 VGND VGND VPWR VPWR clknet_0_net964 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net975 net975 VGND VGND VPWR VPWR clknet_0_net975 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c165_A2 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c300_S1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c462_A0 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input40_A in44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c181_A1 net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c612_A3 net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s949_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge774_B1 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c698_S0 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge870_Q net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c356_A1 clknet_1_1__leaf_net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c210_S1 net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net252_X clknet_1_0__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c372_A0 clknet_1_1__leaf_net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s890_GATE_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout158_A net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net249 net249 VGND VGND VPWR VPWR clknet_0_net249 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout113_X net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc606 clknet_1_1__leaf_net252 net1026 net760 clknet_1_0__leaf_net987 net784 net863
+ VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__mux4_1
Xc628 clknet_1_1__leaf_net514 clknet_1_1__leaf_net290 clknet_1_0__leaf_net965 clknet_1_1__leaf_net968
+ net1000 clknet_1_1__leaf_net851 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__mux4_2
Xc617 clknet_1_1__leaf_net514 net388 clknet_1_1__leaf_net968 net738 net820 net845
+ VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__mux4_2
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c100_X net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c713_A2 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c432_A3 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c607_A3 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net794 net794 VGND VGND VPWR VPWR clknet_0_net794 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c53_X net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c342_A3 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c205_S1 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c236_A4 net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c448_SCE net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net390 clknet_0_net390 VGND VGND VPWR VPWR clknet_1_1__leaf_net390
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c155_Y net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c148_X net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c708_A2 net597 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s922_Q net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc403 net1050 net86 net1012 net337 net810 VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__a41o_1
XANTENNA_c61_A2 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc436 clknet_1_1__leaf_net249 net371 net931 clknet_1_0__leaf_net250 net1031 net1054
+ VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__mux4_2
Xc425 net1035 net679 net808 VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__a21oi_1
Xc414 net348 net344 net1012 net223 net824 net1089 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__mux4_1
XANTENNA_c443_A2 net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc469 clknet_1_1__leaf_net281 net1025 clknet_1_0__leaf_net985 net772 net810 net1041
+ VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__mux4_1
Xc447 clknet_4_1_0_clk net363 clknet_1_0__leaf_net377 net371 clknet_1_0__leaf_net250
+ clknet_1_0__leaf_net993 VGND VGND VPWR VPWR net384 net383 sky130_fd_sc_hd__sdfbbp_1
Xc458 net378 net385 net778 net837 net840 net841 VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__mux4_1
XANTENNA_c740_A0 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c306_S0 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c127_SCD net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c618_A2 net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output71_A net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_max_cap126_X net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c366_SCD net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net446 clknet_0_net446 VGND VGND VPWR VPWR clknet_1_0__leaf_net446
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c528_A2 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c247_A3 net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c544_A1 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c710_A3 net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net980 clknet_0_net980 VGND VGND VPWR VPWR clknet_1_0__leaf_net980
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_37_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_59_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c201_S net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc200 net17 net913 net1054 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__o21ba_1
Xc211 net29 clknet_1_0__leaf_net153 net152 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_68_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc222 clknet_1_0__leaf_net156 net23 net1066 net157 net37 net746 VGND VGND VPWR VPWR
+ net172 sky130_fd_sc_hd__mux4_1
Xc233 net171 clknet_1_0__leaf_net182 net1059 net173 clknet_1_0__leaf_net172 net673
+ VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__mux4_1
Xc244 clknet_1_1__leaf_net193 net26 net70 net1060 clknet_1_1__leaf_net793 VGND VGND
+ VPWR VPWR net194 sky130_fd_sc_hd__a41oi_4
XFILLER_0_32_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc255 net992 clknet_1_1__leaf_net198 net697 net802 net804 VGND VGND VPWR VPWR net202
+ sky130_fd_sc_hd__a41o_1
Xc288 net722 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__clkbuf_1
Xc266 net210 net957 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__or2b_2
Xc277 net732 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__buf_1
Xc299 net116 net243 net242 net233 net1030 net807 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__mux4_1
XANTENNA_c470_A0 clknet_1_0__leaf_net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A3 clknet_1_0__leaf_net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge783_Q net679 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge776 net561 clknet_1_0__leaf_net559 clknet_1_0__leaf_net553 net113 net109 net1037
+ VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__mux4_4
Xmerge765 net51 net56 net1060 net63 net1057 VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__a41o_1
Xmerge787 net507 net486 VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__xor2_1
Xmerge798 clknet_4_4_0_clk net440 net451 VGND VGND VPWR VPWR net695 net694 sky130_fd_sc_hd__dfsbp_2
Xs882 clknet_4_2_0_clk net142 VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_24_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xs893 net208 clknet_4_11_0_clk VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__lpflow_inputisolatch_1
XANTENNA_net999_2_A net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput3 in10 VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_39_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net254 clknet_0_net254 VGND VGND VPWR VPWR clknet_1_0__leaf_net254
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net265 clknet_0_net265 VGND VGND VPWR VPWR clknet_1_0__leaf_net265
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c258_A2 net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net287 clknet_0_net287 VGND VGND VPWR VPWR clknet_1_0__leaf_net287
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout140_A net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c440_A3 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c615_A3 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c631_A2 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c350_A3 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net967 clknet_0_net967 VGND VGND VPWR VPWR clknet_1_1__leaf_net967
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c244_A4 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_4_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c123_S1 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c419_A4 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout143_X net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c402_Y net338 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c435_A3 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c732_A1 net720 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c83_X net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge763_A2 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c626_A2 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c361_A2 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c224_S0 net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c108_CLK_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput50 in7 VGND VGND VPWR VPWR net957 sky130_fd_sc_hd__dlymetal6s2s_1
XANTENNA_fanout103_A net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c292_A net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c397_B net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c178_X net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s916_GCLK net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c446_A2 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net965 net965 VGND VGND VPWR VPWR clknet_0_net965 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net987 net987 VGND VGND VPWR VPWR clknet_0_net987 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c743_A0 net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s894_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input33_A in38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge800_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_46_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c356_A2 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge867_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge809_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s885_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s923_GATE_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c372_A1 clknet_1_0__leaf_net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net583 clknet_0_net583 VGND VGND VPWR VPWR clknet_1_1__leaf_net583
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net206 net206 VGND VGND VPWR VPWR clknet_0_net206 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c312_B net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge858_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc607 net1011 clknet_1_1__leaf_net147 clknet_1_0__leaf_net975 net1039 clknet_1_0__leaf_net513
+ net865 VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__mux4_4
Xc618 clknet_1_1__leaf_net522 clknet_1_1__leaf_net462 net1064 net54 net1040 clknet_1_1__leaf_net734
+ VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_73_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc629 clknet_1_1__leaf_net487 clknet_1_0__leaf_net980 clknet_1_1__leaf_net414 net1000
+ net785 clknet_1_1__leaf_net870 VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__mux4_2
XFILLER_0_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout106_X net1013 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c713_A3 net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c738_A0 net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_40_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net795 net795 VGND VGND VPWR VPWR clknet_0_net795 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_50_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c473_A0 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c192_A1 net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_12_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c367_A1 net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c252_A4 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge831_GCLK net733 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c412_S0 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c724_A2 net740 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c61_A3 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc426 net92 net332 net1012 clknet_1_0__leaf_net249 net1034 net1043 VGND VGND VPWR
+ VPWR net362 sky130_fd_sc_hd__mux4_2
Xc404 net221 net1012 net1019 net335 net332 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__a41oi_4
Xc437 clknet_1_0__leaf_net372 clknet_1_0__leaf_net250 c437/A2 net1043 net824 net830
+ VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__mux4_2
Xc415 net347 net343 net340 net823 net824 net825 VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__mux4_1
Xc448 clknet_4_3_0_clk clknet_1_0__leaf_net377 net1039 net371 net1062 net692 VGND
+ VGND VPWR VPWR net386 net385 sky130_fd_sc_hd__sdfbbn_1
Xc459 clknet_1_1__leaf_net250 net834 net837 net840 net841 net842 VGND VGND VPWR VPWR
+ net398 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c306_S1 clknet_1_0__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c618_A3 net54 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net570 net570 VGND VGND VPWR VPWR clknet_0_net570 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c353_A3 net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c216_S1 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net414 clknet_0_net414 VGND VGND VPWR VPWR clknet_1_0__leaf_net414
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net447 clknet_0_net447 VGND VGND VPWR VPWR clknet_1_0__leaf_net447
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net436 clknet_0_net436 VGND VGND VPWR VPWR clknet_1_0__leaf_net436
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c544_A2 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c263_A3 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c126_S1 net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c265_Y net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c160_X net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c357_SCE net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c719_A2 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c109_SCE net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c56_A3 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c438_A3 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c735_A1 net597 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc201 net148 net145 net1028 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__mux2_4
Xc212 net161 net30 net157 net151 net736 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__a41o_1
XANTENNA_c454_A2 net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc223 net38 net122 net922 net171 net1023 net1059 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__mux4_2
Xc245 net70 net913 net79 clknet_1_1__leaf_net165 net46 VGND VGND VPWR VPWR net195
+ sky130_fd_sc_hd__a41oi_2
Xc234 clknet_1_1__leaf_net174 net158 net171 clknet_1_0__leaf_net180 clknet_1_0__leaf_net794
+ net799 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__mux4_4
Xc256 clknet_1_1__leaf_net199 clknet_1_0__leaf_net202 net992 net697 net790 VGND VGND
+ VPWR VPWR net203 sky130_fd_sc_hd__a41oi_4
Xc267 net212 net81 net1017 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__a21o_1
Xc278 net1046 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__inv_12
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc289 net722 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_5_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge766_A2 net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c629_A2 clknet_1_1__leaf_net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c348_A3 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge777 clknet_4_5_0_clk net577 net580 VGND VGND VPWR VPWR net672 net671 sky130_fd_sc_hd__dfrbp_1
Xmerge766 net110 net1009 net111 net120 net922 VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__a41oi_1
Xmerge788 net303 net319 VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__xnor2_1
Xmerge799 net647 net649 VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__xor2_2
Xs883 clknet_4_2_0_clk net146 VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__dlclkp_1
Xs894 clknet_4_0_0_clk net225 VGND VGND VPWR VPWR net807 net806 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c661_A0 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput4 in11 VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c539_A2 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net266 clknet_0_net266 VGND VGND VPWR VPWR clknet_1_0__leaf_net266
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net299 clknet_0_net299 VGND VGND VPWR VPWR clknet_1_0__leaf_net299
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_0_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout133_A net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c440_A4 net136 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c465_A1 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net968 clknet_0_net968 VGND VGND VPWR VPWR clknet_1_1__leaf_net968
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_64_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c391_A0 net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_87_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout136_X net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c716_A3 clknet_1_1__leaf_net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_76_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c732_A2 net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c78_A1 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c179_A2 net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c314_S1 net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c476_A0 net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge763_A3 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c626_A3 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net765 clknet_0_net765 VGND VGND VPWR VPWR clknet_1_1__leaf_net765
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_49_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput40 in44 VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__buf_2
Xinput51 in8 VGND VGND VPWR VPWR net958 sky130_fd_sc_hd__buf_2
XFILLER_0_12_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c727_A2 net1051 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c64_A3 net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c150_S0 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c80_A2 net1092 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c462_A2 net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c181_A3 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input26_A in31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c325_S0 net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net1068 clknet_0_net1068 VGND VGND VPWR VPWR clknet_1_1__leaf_net1068
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_18_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge774_A2 net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c637_A2 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c356_A3 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c219_S1 clknet_1_0__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net573 clknet_0_net573 VGND VGND VPWR VPWR clknet_1_1__leaf_net573
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net207 net207 VGND VGND VPWR VPWR clknet_0_net207 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc608 clknet_1_0__leaf_net512 clknet_1_1__leaf_net513 clknet_1_1__leaf_net967 clknet_1_0__leaf_net494
+ net1005 net866 VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__mux4_2
Xc619 clknet_1_1__leaf_net514 clknet_1_1__leaf_net414 clknet_1_1__leaf_net522 clknet_1_1__leaf_net968
+ net797 net862 VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__mux4_2
XFILLER_0_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s895_Q net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input29_X net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c331_Q_N net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net629 clknet_0_net629 VGND VGND VPWR VPWR clknet_1_0__leaf_net629
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net618 clknet_0_net618 VGND VGND VPWR VPWR clknet_1_0__leaf_net618
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c383_A1 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c724_A3 net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc405 net215 net89 net335 net92 net340 net1012 VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__mux4_1
Xc416 net343 net215 net347 net337 net809 net1089 VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__mux4_1
Xc427 net335 net360 net355 net1035 net340 VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__a41o_1
Xc438 net112 net371 net334 net1043 net830 net831 VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__mux4_1
Xc449 clknet_4_6_0_clk net1090 net378 clknet_1_1__leaf_net147 net827 net1084 VGND
+ VGND VPWR VPWR net388 net387 sky130_fd_sc_hd__sdfbbn_2
XANTENNA_c740_A2 net587 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c603_S0 net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c468_A1 net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c484_A0 net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge771_A3 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c353_A4 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge819_Q net720 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net448 clknet_0_net448 VGND VGND VPWR VPWR clknet_1_0__leaf_net448
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net459 clknet_0_net459 VGND VGND VPWR VPWR clknet_1_0__leaf_net459
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c232_S1 net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c394_A0 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_558 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c719_A3 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net960 clknet_0_net960 VGND VGND VPWR VPWR clknet_1_0__leaf_net960
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net993 clknet_0_net993 VGND VGND VPWR VPWR clknet_1_0__leaf_net993
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c735_A2 clknet_1_1__leaf_net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c72_A3 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc202 net1056 net150 net0 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__o21ba_2
XFILLER_0_32_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c454_A3 net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc213 clknet_1_0__leaf_net153 net1092 net151 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__o21ba_1
Xc224 net145 net173 clknet_1_1__leaf_net164 net129 net979 net751 VGND VGND VPWR VPWR
+ net174 sky130_fd_sc_hd__mux4_2
Xc235 clknet_1_1__leaf_net180 net962 net1010 clknet_1_0__leaf_net172 net173 clknet_1_0__leaf_net794
+ VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_92_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c751_A1 net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc246 clknet_1_1__leaf_net178 net1029 net70 net1063 net790 VGND VGND VPWR VPWR net991
+ sky130_fd_sc_hd__a41oi_1
Xc257 net194 net992 net982 net768 net790 VGND VGND VPWR VPWR net960 sky130_fd_sc_hd__a41oi_1
Xc268 net957 net213 net1052 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__o21a_2
Xc279 net222 net217 net211 net219 net1017 net89 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c97_B1 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge778 clknet_4_8_0_clk net170 net177 VGND VGND VPWR VPWR net674 net673 sky130_fd_sc_hd__dfrbp_1
Xmerge767 net112 net110 net113 net109 net118 net116 VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__mux4_1
Xs884 clknet_4_8_0_clk net166 VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__dlclkp_2
Xs895 clknet_4_0_0_clk net226 VGND VGND VPWR VPWR net809 net808 sky130_fd_sc_hd__dfxbp_2
Xmerge789 net421 net431 VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__xor2_4
Xclkbuf_0_net390 net390 VGND VGND VPWR VPWR clknet_0_net390 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c661_A1 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c227_S1 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput5 in12 VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__buf_1
XFILLER_0_36_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire134_X net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c553_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c555_A2 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c571_A1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c153_S0 net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c83_A2 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c600_S1 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s912_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c762_A0 net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net969 clknet_0_net969 VGND VGND VPWR VPWR clknet_1_1__leaf_net969
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_input11_X net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s906_GATE_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s969_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c420_S1 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout129_X net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c451_A4 net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c757_A0 net587 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c492_A0 net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_max_cap139_A net732 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c386_A1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c240_S1 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput30 in35 VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__buf_1
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput52 in9 VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__buf_4
Xinput41 in45 VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__buf_1
XFILLER_0_24_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c727_A3 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net967 net967 VGND VGND VPWR VPWR clknet_0_net967 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c150_S1 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c743_A2 net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c80_A3 net1082 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c462_A3 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c181_A4 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input19_A in25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net1069 clknet_0_net1069 VGND VGND VPWR VPWR clknet_1_1__leaf_net1069
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_18_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c357_Q net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_46_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge774_A3 net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c637_A3 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output87_A net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net552 clknet_0_net552 VGND VGND VPWR VPWR clknet_1_1__leaf_net552
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net563 clknet_0_net563 VGND VGND VPWR VPWR clknet_1_1__leaf_net563
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c235_S1 clknet_1_0__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net585 clknet_0_net585 VGND VGND VPWR VPWR clknet_1_1__leaf_net585
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c547_A3 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc609 clknet_1_1__leaf_net398 clknet_1_1__leaf_net364 net1008 clknet_1_0__leaf_net522
+ net760 clknet_1_1__leaf_net990 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__mux4_2
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c563_A2 clknet_1_0__leaf_net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c183_X net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c91_A2 net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c192_A3 net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c680_A0 net336 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge821_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout156_A net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout111_X net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c293_A2 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc428 net334 net333 net1034 clknet_1_0__leaf_net362 net356 VGND VGND VPWR VPWR net364
+ sky130_fd_sc_hd__a41oi_4
Xc417 net340 net348 net337 net220 net823 net825 VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__mux4_1
Xc406 clknet_4_1_0_clk net338 net1085 net86 net98 VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__sdfrtp_4
XFILLER_0_13_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc439 net361 net1035 net1031 clknet_1_0__leaf_net364 net830 clknet_1_0__leaf_net993
+ VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__mux4_2
XFILLER_0_99_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c468_A2 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c484_A1 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net583 net583 VGND VGND VPWR VPWR clknet_0_net583 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c449_RESET_B net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c163_B1_N net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_19_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c704_S0 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout159_X net1066 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c585_B1 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c735_A3 net587 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_28_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc203 net27 clknet_1_1__leaf_net147 net148 net23 net1028 net989 VGND VGND VPWR VPWR
+ net153 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_79_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc214 net150 clknet_1_0__leaf_net156 net157 net1048 net159 clknet_1_0__leaf_net793
+ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__mux4_1
Xc225 clknet_1_0__leaf_net172 net37 net171 clknet_1_0__leaf_net164 net157 net751 VGND
+ VGND VPWR VPWR net175 sky130_fd_sc_hd__mux4_2
Xc236 net44 clknet_1_0__leaf_net174 net121 net796 net801 VGND VGND VPWR VPWR net186
+ sky130_fd_sc_hd__a41o_2
XTAP_TAPCELL_ROW_92_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc258 net76 clknet_1_0__leaf_net202 net772 net789 net802 net803 VGND VGND VPWR VPWR
+ net204 sky130_fd_sc_hd__mux4_1
Xc247 net79 net70 net924 net802 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__a31oi_2
Xc269 net101 net95 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__nand2b_1
XANTENNA_c470_A3 net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c479_A1 net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge766_A4 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c495_A0 net15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge768 net338 clknet_1_0__leaf_net555 clknet_1_0__leaf_net553 net554 net557 VGND
+ VGND VPWR VPWR net662 sky130_fd_sc_hd__a41oi_1
Xmerge779 net533 net535 VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__xor2_1
XFILLER_0_70_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs885 clknet_4_9_0_clk net179 VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs896 clknet_4_0_0_clk net227 VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__dfxtp_4
XFILLER_0_51_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c364_A4 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput6 in13 VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_36_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net202 clknet_0_net202 VGND VGND VPWR VPWR clknet_1_0__leaf_net202
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_52_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c555_A3 net1051 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_30_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout119_A net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c153_S1 net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c609_S0 net760 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input49_A in6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge830_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c344_S0 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c359_A4 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c274_B_N net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c285_A3 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge834_D net666 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c429_S0 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c148_S1 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c164_S0 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c611_S1 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s897_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c492_A1 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c339_S0 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net734 clknet_0_net734 VGND VGND VPWR VPWR clknet_1_1__leaf_net734
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_29_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput31 in36 VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__clkbuf_2
Xinput20 in26 VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__buf_1
Xinput42 in46 VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_1__f_net156_X clknet_1_1__leaf_net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout141_X net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net968 net968 VGND VGND VPWR VPWR clknet_0_net968 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s879_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c743_A3 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net553 clknet_0_net553 VGND VGND VPWR VPWR clknet_1_1__leaf_net553
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c320_SCE net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c563_A3 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout101_A net257 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_73_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c426_S1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_63_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_23_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net765 net765 VGND VGND VPWR VPWR clknet_0_net765 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_51_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c91_A3 net1066 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_S0 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input31_A in36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c498_A0 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net609 clknet_0_net609 VGND VGND VPWR VPWR clknet_1_0__leaf_net609
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net372 clknet_0_net372 VGND VGND VPWR VPWR clknet_1_1__leaf_net372
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net488_X clknet_1_1__leaf_net488 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c574_A2 clknet_1_0__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c293_A3 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc407 net1049 net1050 net337 net1012 net698 VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__a41oi_2
Xc418 net732 VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__inv_2
XANTENNA_clkbuf_0_net967_A net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout104_X net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc429 net356 net361 net1067 clknet_1_0__leaf_net364 net1031 net1034 VGND VGND VPWR
+ VPWR net365 sky130_fd_sc_hd__mux4_2
XANTENNA_c55_S0 net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c321_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c468_A3 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c89_A net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net573 net573 VGND VGND VPWR VPWR clknet_0_net573 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c347_S0 net759 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input34_X net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net428 clknet_0_net428 VGND VGND VPWR VPWR clknet_1_0__leaf_net428
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_39_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c691_A0 net369 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c560_A4 net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c569_A2 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net180 clknet_0_net180 VGND VGND VPWR VPWR clknet_1_1__leaf_net180
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c585_A1 net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c720_S0 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc204 net149 net122 net17 net151 net152 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__a41o_1
Xc226 net171 net173 clknet_1_1__leaf_net156 net1066 clknet_1_0__leaf_net172 net674
+ VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__mux4_4
Xc215 net163 net11 net1039 net148 net952 net962 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__mux4_1
XFILLER_0_60_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c751_A3 net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc237 clknet_1_1__leaf_net176 net173 net35 net1059 net796 net798 VGND VGND VPWR VPWR
+ net187 sky130_fd_sc_hd__mux4_4
Xc259 clknet_1_0__leaf_net204 clknet_1_0__leaf_net198 clknet_1_0__leaf_net199 net70
+ clknet_1_0__leaf_net193 clknet_1_1__leaf_net202 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__mux4_4
Xc248 net1002 net70 net79 net1057 net804 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__a41o_2
XFILLER_0_99_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c614_S1 net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge769 net95 net222 net219 net99 net218 VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__a41o_1
Xs886 net181 clknet_4_9_0_clk VGND VGND VPWR VPWR net797 net796 sky130_fd_sc_hd__dlxbn_2
XFILLER_0_23_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xs897 clknet_4_1_0_clk net231 VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__dfxtp_4
XFILLER_0_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc760 clknet_1_1__leaf_net434 clknet_1_0__leaf_net653 clknet_1_1__leaf_net420 net903
+ net904 net907 VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__mux4_2
Xinput7 in14 VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net269 clknet_0_net269 VGND VGND VPWR VPWR clknet_1_0__leaf_net269
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_52_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c552_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_30_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c609_S1 clknet_1_1__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s935_GATE_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c625_S0 clknet_1_0__leaf_net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c344_S1 net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_1_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc590 clknet_1_1__leaf_net501 clknet_1_0__leaf_net502 net498 clknet_1_0__leaf_net490
+ clknet_1_0__leaf_net504 clknet_1_1__leaf_net814 VGND VGND VPWR VPWR net968 sky130_fd_sc_hd__mux4_4
XFILLER_0_47_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_63_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_65_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_74_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c164_S1 net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c757_A2 net759 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c476_A3 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_83_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c492_A2 net1013 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c355_S0 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_92_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net735 clknet_0_net735 VGND VGND VPWR VPWR clknet_1_1__leaf_net735
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c386_A3 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput10 in17 VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_12_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput21 in27 VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__buf_2
Xinput43 in47 VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput32 in37 VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__buf_2
XFILLER_0_58_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c204_B1 net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c187_RESET_B net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c296_A3 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c593_A1 clknet_1_0__leaf_net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c58_S0 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c219_X net169 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net969 net969 VGND VGND VPWR VPWR clknet_0_net969 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_99_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c175_S0 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_46_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c487_A2 clknet_1_0__leaf_net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c694_A0 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_73_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c723_S0 net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c60_S1 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c754_A3 net759 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c91_A4 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c566_CLK_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c617_S1 net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input24_A in3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c498_A1 net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c633_S0 net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s960_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge854_Q net759 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s908_GATE clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net362 clknet_0_net362 VGND VGND VPWR VPWR clknet_1_1__leaf_net362
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c558_A4 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c262_S1 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c574_A3 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net1068 clknet_0_net1068 VGND VGND VPWR VPWR clknet_1_0__leaf_net1068
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_13_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc419 net1034 net1012 net711 net1045 net1043 VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__a41oi_2
Xc408 net343 net1049 net1050 net337 VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__a31o_1
XANTENNA_clkbuf_4_6_0_clk_X clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c599_A0 clknet_1_1__leaf_net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c337_RESET_B net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c453_S0 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c749_A3 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c111_A1 net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s942_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0_net563 net563 VGND VGND VPWR VPWR clknet_0_net563 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net552 net552 VGND VGND VPWR VPWR clknet_0_net552 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net585 net585 VGND VGND VPWR VPWR clknet_0_net585 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c347_S1 net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input27_X net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_10_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c569_A3 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net985 clknet_0_net985 VGND VGND VPWR VPWR clknet_1_0__leaf_net985
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c201_X net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc227 net37 net1039 clknet_1_0__leaf_net165 net171 net144 net1059 VGND VGND VPWR VPWR
+ net177 sky130_fd_sc_hd__mux4_4
Xc216 net10 net0 clknet_1_0__leaf_net165 clknet_1_0__leaf_net164 net1056 net106 VGND
+ VGND VPWR VPWR net166 sky130_fd_sc_hd__mux4_2
Xc205 net125 net152 net1066 net1018 net151 net123 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_92_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc238 net173 net986 clknet_1_0__leaf_net186 clknet_1_0__leaf_net187 clknet_1_0__leaf_net176
+ clknet_1_0__leaf_net178 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__mux4_2
Xc249 net197 net1029 net989 clknet_1_1__leaf_net793 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__a31o_4
XANTENNA_c106_A1 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c402_B1_N net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c479_A3 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs887 net183 clknet_4_10_0_clk VGND VGND VPWR VPWR net799 net798 sky130_fd_sc_hd__dlxbn_1
Xs898 clknet_4_0_0_clk net246 VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_23_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge823_GATE clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc750 clknet_1_1__leaf_net290 clknet_1_1__leaf_net601 net956 net754 clknet_1_0__leaf_net870
+ net904 VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__mux4_4
Xc761 net587 net747 net756 net763 net820 net906 VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__mux4_4
Xinput8 in15 VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__clkbuf_1
XANTENNA_output55_A net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net204 clknet_0_net204 VGND VGND VPWR VPWR clknet_1_0__leaf_net204
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c686_A1 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net248 clknet_0_net248 VGND VGND VPWR VPWR clknet_1_0__leaf_net248
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_52_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c335_CLK_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_2_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c596_A1 net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c256_Y net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c151_X net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net793 clknet_0_net793 VGND VGND VPWR VPWR clknet_1_0__leaf_net793
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c117_B1 net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c187_SCD net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc591 net498 clknet_1_1__leaf_net448 net493 clknet_1_0__leaf_net489 net127 net809
+ VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__mux4_4
Xc580 clknet_1_1__leaf_net275 clknet_1_1__leaf_net455 clknet_1_0__leaf_net488 c580/A4
+ clknet_1_0__leaf_net990 VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__a41o_4
XFILLER_0_47_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c697_A0 net1051 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout124_A net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c726_S0 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c63_S1 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c757_A3 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c461_S0 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c492_A3 net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c636_S0 net740 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c371_S0 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c332_SCD clknet_1_1__leaf_net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c270_B1_N net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput22 in28 VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_40_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput11 in18 VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__clkbuf_8
Xinput33 in38 VGND VGND VPWR VPWR net940 sky130_fd_sc_hd__clkbuf_2
Xinput44 in48 VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c546_S0 net720 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c577_A3 net773 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input1_X net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c191_S0 net136 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c487_A3 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge873_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s936_Q_N net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c67_X net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net522 clknet_0_net522 VGND VGND VPWR VPWR clknet_1_1__leaf_net522
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net555 clknet_0_net555 VGND VGND VPWR VPWR clknet_1_1__leaf_net555
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s927_Q_N net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_4_2_0_clk_X clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c100_A3 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s936_Q net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net734 net734 VGND VGND VPWR VPWR clknet_0_net734 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_7_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input17_A in23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c498_A2 clknet_1_1__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c689_A1 clknet_1_1__leaf_net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c574_A4 net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net1069 clknet_0_net1069 VGND VGND VPWR VPWR clknet_1_0__leaf_net1069
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc409 net223 net337 net1012 net344 net1049 net340 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__mux4_4
XANTENNA_input9_A in16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s886_Q net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net553 net553 VGND VGND VPWR VPWR clknet_0_net553 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge860_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s918_GATE_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c70_S net1081 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net182 clknet_0_net182 VGND VGND VPWR VPWR clknet_1_1__leaf_net182
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net193 clknet_0_net193 VGND VGND VPWR VPWR clknet_1_1__leaf_net193
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_53_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_81_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net964 clknet_0_net964 VGND VGND VPWR VPWR clknet_1_0__leaf_net964
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net975 clknet_0_net975 VGND VGND VPWR VPWR clknet_1_0__leaf_net975
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c585_A3 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc217 net962 clknet_1_0__leaf_net164 net106 clknet_1_0__leaf_net165 net144 net704
+ VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__mux4_2
Xc206 net148 net909 clknet_1_0__leaf_net793 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__mux2_2
XTAP_TAPCELL_ROW_92_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc228 clknet_1_1__leaf_net175 net1020 net144 net173 net1059 VGND VGND VPWR VPWR net178
+ sky130_fd_sc_hd__a41oi_4
Xc239 clknet_1_1__leaf_net186 clknet_1_0__leaf_net187 net1029 net673 net798 net800
+ VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__mux4_1
XANTENNA_c82_S0 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c403_B1 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c464_S0 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c97_A4 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s891_GATE_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c495_A3 net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net372 net372 VGND VGND VPWR VPWR clknet_0_net372 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs888 net184 clknet_4_10_0_clk VGND VGND VPWR VPWR net801 net800 sky130_fd_sc_hd__dlxbp_1
Xs899 clknet_4_2_0_clk net247 VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__dlclkp_1
XANTENNA_merge776_S0 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc740 net1027 clknet_1_0__leaf_net631 net587 net600 net902 net903 VGND VGND VPWR VPWR
+ net634 sky130_fd_sc_hd__mux4_2
Xc751 net623 net307 net643 net36 net895 net898 VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__mux4_2
Xc762 net36 net656 clknet_1_0__leaf_net653 net747 net756 net908 VGND VGND VPWR VPWR
+ c762/X sky130_fd_sc_hd__mux4_2
XANTENNA_merge833_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c313_B1 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_10_0_clk_X clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput9 in16 VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__buf_1
Xclkbuf_1_0__f_net249 clknet_0_net249 VGND VGND VPWR VPWR clknet_1_0__leaf_net249
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_52_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c549_S0 net720 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c596_A2 clknet_1_1__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout157_X net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c144_X net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net794 clknet_0_net794 VGND VGND VPWR VPWR clknet_1_0__leaf_net794
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c459_S0 net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c117_A1 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_36_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net180 net180 VGND VGND VPWR VPWR clknet_0_net180 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc581 clknet_1_0__leaf_net252 net471 net1051 net1024 net841 VGND VGND VPWR VPWR net496
+ sky130_fd_sc_hd__a41o_2
Xc570 net228 net360 net688 net776 net777 net861 VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__mux4_1
Xc592 clknet_1_1__leaf_net455 clknet_1_0__leaf_net968 clknet_1_0__leaf_net504 net480
+ net777 net841 VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__mux4_4
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c697_A1 net587 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c279_S0 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout117_A net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c103_A3 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c189_S0 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge773_S1 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input47_A in50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge877_Q net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput12 in19 VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_40_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput34 in39 VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput23 in29 VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__buf_1
Xinput45 in49 VGND VGND VPWR VPWR net952 sky130_fd_sc_hd__buf_1
XFILLER_0_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c204_A2 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c562_S0 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c281_S1 net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c593_A3 clknet_1_1__leaf_net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c107_X net53 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c737_S0 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c456_S1 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c472_S0 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge863_Q_N net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net501 clknet_0_net501 VGND VGND VPWR VPWR clknet_1_1__leaf_net501
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net512 clknet_0_net512 VGND VGND VPWR VPWR clknet_1_1__leaf_net512
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net556 clknet_0_net556 VGND VGND VPWR VPWR clknet_1_1__leaf_net556
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c694_A2 net587 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_73_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c290_D net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c231_A0 net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net735 net735 VGND VGND VPWR VPWR clknet_0_net735 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_23_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c467_S0 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c141_A0 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c689_A2 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net364 clknet_0_net364 VGND VGND VPWR VPWR clknet_1_1__leaf_net364
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net271_X clknet_1_1__leaf_net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c287_S0 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c174_X net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c136_B1 net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c691_A3 clknet_1_1__leaf_net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c212_A2 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net172 clknet_0_net172 VGND VGND VPWR VPWR clknet_1_1__leaf_net172
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c570_S0 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net987 clknet_0_net987 VGND VGND VPWR VPWR clknet_1_0__leaf_net987
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net965 clknet_0_net965 VGND VGND VPWR VPWR clknet_1_0__leaf_net965
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout147_A net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c585_A4 clknet_1_1__leaf_net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc218 net159 clknet_1_0__leaf_net164 clknet_1_0__leaf_net165 net148 net157 net17 VGND
+ VGND VPWR VPWR net168 sky130_fd_sc_hd__mux4_2
Xc207 clknet_4_8_0_clk clknet_1_0__leaf_net156 net123 net152 net151 VGND VGND VPWR
+ VPWR net962 net157 sky130_fd_sc_hd__sdfrbp_2
XTAP_TAPCELL_ROW_92_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc229 clknet_1_0__leaf_net174 net158 net1048 net35 net171 net674 VGND VGND VPWR VPWR
+ net179 sky130_fd_sc_hd__mux4_1
XANTENNA_fanout102_X net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c403_A1 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c179_B1_N net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs889 net185 clknet_4_10_0_clk VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_23_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs878 clknet_4_11_0_clk net53 VGND VGND VPWR VPWR net966 net788 sky130_fd_sc_hd__dfxbp_1
Xclkbuf_0_net362 net362 VGND VGND VPWR VPWR clknet_0_net362 sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge776_S1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc730 clknet_1_0__leaf_net618 net342 net1051 clknet_1_1__leaf_net504 net869 net900
+ VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__mux4_4
Xc741 clknet_1_0__leaf_net620 net1036 clknet_1_1__leaf_net631 net867 net888 net901
+ VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__mux4_1
Xc752 clknet_1_1__leaf_net420 net307 clknet_1_1__leaf_net428 clknet_1_1__leaf_net849
+ net903 net904 VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__mux4_1
XANTENNA_c313_A1 net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input32_X net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net206 clknet_0_net206 VGND VGND VPWR VPWR clknet_1_0__leaf_net206
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_30_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c549_S1 net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c223_A1 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c596_A3 clknet_1_1__leaf_net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net795 clknet_0_net795 VGND VGND VPWR VPWR clknet_1_0__leaf_net795
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c137_X net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_360 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s911_Q net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c117_A2 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c475_S0 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c194_S1 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c308_A1 net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c369_S1 net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s970_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc582 clknet_4_6_0_clk net1009 clknet_1_0__leaf_net488 clknet_1_1__leaf_net967 clknet_1_1__leaf_net489
+ clknet_1_1__leaf_net398 VGND VGND VPWR VPWR net498 net497 sky130_fd_sc_hd__sdfbbn_1
Xc571 clknet_1_1__leaf_net463 net1043 net855 net859 net860 net861 VGND VGND VPWR VPWR
+ net485 sky130_fd_sc_hd__mux4_2
Xc560 net333 net471 clknet_1_0__leaf_net459 net857 net858 VGND VGND VPWR VPWR net474
+ sky130_fd_sc_hd__a41oi_1
XANTENNA_merge822_Q net723 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c385_S0 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c324_B1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output60_A clknet_1_0__leaf_net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc593 clknet_1_0__leaf_net462 clknet_1_0__leaf_net968 clknet_1_0__leaf_net504 clknet_1_1__leaf_net271
+ net773 net827 VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__mux4_4
XPHY_EDGE_ROW_16_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s884_GCLK net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net570 clknet_0_net570 VGND VGND VPWR VPWR clknet_1_0__leaf_net570
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_43_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_98_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c144_B1 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c310_A2 net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_61_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput13 in2 VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_40_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput46 in5 VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__clkbuf_2
Xinput35 in4 VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput24 in3 VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__buf_2
XFILLER_0_52_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc390 net1040 net971 net730 net1001 net805 net822 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_48_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c220_A2 net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c195_SET_B net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c411_A1 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c472_S1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net502 clknet_0_net502 VGND VGND VPWR VPWR clknet_1_1__leaf_net502
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net513 clknet_0_net513 VGND VGND VPWR VPWR clknet_1_1__leaf_net513
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c382_S1 net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s963_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c694_A3 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c215_A2 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_1_1__f_net147_X clknet_1_1__leaf_net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout132_X net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c422_B1 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c141_A1 net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s945_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge826_GATE clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net398 clknet_0_net398 VGND VGND VPWR VPWR clknet_1_1__leaf_net398
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net376 net1079 VGND VGND VPWR VPWR clknet_1_1__leaf_net376 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c242_B1 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net522 net522 VGND VGND VPWR VPWR clknet_0_net522 sky130_fd_sc_hd__clkbuf_16
XANTENNA_s941_Q net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net555 net555 VGND VGND VPWR VPWR clknet_0_net555 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c478_S0 net15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c136_A1 net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input22_A in28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge852_Q net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c388_S0 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output90_A net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc208 net30 net106 net151 net736 net792 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__a41o_4
XTAP_TAPCELL_ROW_92_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc219 net29 clknet_1_0__leaf_net165 clknet_1_0__leaf_net153 net30 net704 clknet_1_0__leaf_net794
+ VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__mux4_2
XANTENNA_c403_A2 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s891_Q net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c761_S0 net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c480_S1 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs879 clknet_4_10_0_clk net77 VGND VGND VPWR VPWR net999 net789 sky130_fd_sc_hd__dfxbp_1
XANTENNA_c147_B1 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc731 clknet_1_1__leaf_net573 clknet_1_0__leaf_net563 net1051 clknet_1_1__leaf_net290
+ net900 net901 VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__mux4_4
Xc720 net941 net600 clknet_1_1__leaf_net601 clknet_1_0__leaf_net609 net811 net897
+ VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__mux4_2
Xc742 net342 clknet_1_1__leaf_net618 net911 net758 net890 net902 VGND VGND VPWR VPWR
+ net636 sky130_fd_sc_hd__mux4_4
Xc753 clknet_1_1__leaf_net633 clknet_1_1__leaf_net504 clknet_1_1__leaf_net552 net1013
+ clknet_1_1__leaf_net871 net895 VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__mux4_2
XANTENNA_c313_A2 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c320_RESET_B net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net207 clknet_0_net207 VGND VGND VPWR VPWR clknet_1_0__leaf_net207
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c223_A2 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s904_Q net820 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c475_S1 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c133_A2 net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net182 net182 VGND VGND VPWR VPWR clknet_0_net182 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c308_A2 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net193 net193 VGND VGND VPWR VPWR clknet_0_net193 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc550 clknet_1_0__leaf_net448 net333 net1043 net1042 net855 VGND VGND VPWR VPWR net462
+ sky130_fd_sc_hd__a41o_1
XANTENNA_c385_S1 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc561 net105 clknet_1_0__leaf_net472 clknet_1_1__leaf_net446 net469 clknet_1_0__leaf_net462
+ net1019 VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__mux4_1
Xc572 net1 net481 clknet_1_1__leaf_net275 net959 clknet_1_0__leaf_net252 VGND VGND
+ VPWR VPWR net486 sky130_fd_sc_hd__a41o_1
Xc583 clknet_4_6_0_clk net484 clknet_1_0__leaf_net489 net1045 clknet_1_1__leaf_net832
+ VGND VGND VPWR VPWR net500 net499 sky130_fd_sc_hd__sdfsbp_1
Xc594 clknet_1_0__leaf_net967 clknet_1_0__leaf_net964 net387 clknet_1_0__leaf_net290
+ clknet_1_0__leaf_net980 net747 VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__mux4_1
XFILLER_0_47_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c207_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c335_SCD net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c234_A1 net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c578_D net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c250_B1 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c486_S0 clknet_1_1__leaf_net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c425_B1 net808 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c160_A0 net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c310_A3 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput25 in30 VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__clkbuf_1
Xinput36 in40 VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__buf_1
XFILLER_0_24_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput14 in20 VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput47 in50 VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__buf_1
XFILLER_0_52_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc391 net286 net330 net973 clknet_1_1__leaf_net969 net816 net1006 VGND VGND VPWR VPWR
+ net988 sky130_fd_sc_hd__mux4_2
XANTENNA_clkbuf_1_0__f_net147_X clknet_1_0__leaf_net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c204_A4 net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c501_A2 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c220_A3 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c229_A1 net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c197_X net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c411_A2 net732 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net390 clknet_0_net390 VGND VGND VPWR VPWR clknet_1_0__leaf_net390
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input52_A in9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c305_A3 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net503 clknet_0_net503 VGND VGND VPWR VPWR clknet_1_1__leaf_net503
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net514 clknet_0_net514 VGND VGND VPWR VPWR clknet_1_1__leaf_net514
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_7_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout125_X net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s907_GATE_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c483_S1 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c316_A2 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge863_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s881_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net377 clknet_0_net377 VGND VGND VPWR VPWR clknet_1_1__leaf_net377
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_44_159 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c226_A2 clknet_1_1__leaf_net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_56_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0_net501 net501 VGND VGND VPWR VPWR clknet_0_net501 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net512 net512 VGND VGND VPWR VPWR clknet_0_net512 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net556 net556 VGND VGND VPWR VPWR clknet_0_net556 sky130_fd_sc_hd__clkbuf_16
XANTENNA_s934_Q net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c478_S1 net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c136_A2 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c152_A1 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input15_A in21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c388_S1 net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c327_A1 clknet_1_1__leaf_net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s953_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output83_A clknet_1_1__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c343_B1 net759 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge863_RESET_B net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c212_A4 net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net174 clknet_0_net174 VGND VGND VPWR VPWR clknet_1_1__leaf_net174
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c449_Q_N net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_81_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net967 clknet_0_net967 VGND VGND VPWR VPWR clknet_1_0__leaf_net967
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_61_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c406_D net338 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc209 net154 net1056 net1038 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_92_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c253_B1 net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input7_A in14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c284_Y net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c403_A3 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c489_S0 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net364 net364 VGND VGND VPWR VPWR clknet_0_net364 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c147_A1 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc721 net598 net777 net887 net888 net894 net896 VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__mux4_2
Xc710 clknet_1_1__leaf_net553 clknet_1_0__leaf_net601 clknet_1_1__leaf_net377 net841
+ net886 net889 VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__mux4_4
XANTENNA_c101_Q net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc743 net256 clknet_1_1__leaf_net631 net917 net953 net1036 net787 VGND VGND VPWR VPWR
+ net637 sky130_fd_sc_hd__mux4_4
Xc754 clknet_1_1__leaf_net548 clknet_1_1__leaf_net434 net758 net759 net819 net853
+ VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__mux4_2
Xc732 net1067 net720 net852 net867 net901 net902 VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__mux4_1
XANTENNA_clkbuf_4_15_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c610_A1 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c338_A0 net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_30_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout152_A net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c414_A2 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge822_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c430_A1 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_582 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c158_B1 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net172 net172 VGND VGND VPWR VPWR clknet_0_net172 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c308_A3 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc540 net1011 net449 net694 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__o21a_1
Xc562 net360 net469 net466 net464 net771 net829 VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__mux4_1
XANTENNA_c324_A2 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc551 clknet_1_1__leaf_net251 net369 net1033 net359 net858 VGND VGND VPWR VPWR net463
+ sky130_fd_sc_hd__a41oi_2
Xc573 net135 net782 clknet_1_0__leaf_net990 net839 VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__a31o_4
Xc584 clknet_1_0__leaf_net496 clknet_1_1__leaf_net455 net499 net1061 net839 VGND VGND
+ VPWR VPWR net501 sky130_fd_sc_hd__a41o_4
Xc595 clknet_1_0__leaf_net505 clknet_1_1__leaf_net271 clknet_1_1__leaf_net290 clknet_1_0__leaf_net398
+ net97 clknet_1_0__leaf_net975 VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__mux4_1
XANTENNA_c621_A0 clknet_1_1__leaf_net488 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c340_A1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c583_SCE net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c335_SCE net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c592_S0 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c250_A1 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout155_X net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net583 clknet_0_net583 VGND VGND VPWR VPWR clknet_1_0__leaf_net583
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c142_X net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c409_A2 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c128_A3 net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c113_B1_N net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c486_S1 net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c101_CLK_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c616_A0 clknet_1_0__leaf_net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput15 in21 VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__buf_4
Xinput37 in41 VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__buf_1
Xinput26 in31 VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_40_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput48 in51 VGND VGND VPWR VPWR net955 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_75_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc370 net913 net317 net286 net997 clknet_1_1__leaf_net314 net1006 VGND VGND VPWR VPWR
+ net321 sky130_fd_sc_hd__mux4_1
Xc392 net325 net1032 net330 net973 net789 net803 VGND VGND VPWR VPWR net995 sky130_fd_sc_hd__mux4_1
XANTENNA_c501_A3 clknet_1_1__leaf_net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c229_A2 net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_4_3_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout115_A net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net990_X clknet_1_1__leaf_net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c411_A3 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c139_A2 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c54_B1 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input45_A in49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net504 clknet_0_net504 VGND VGND VPWR VPWR clknet_1_1__leaf_net504
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c602_A2 clknet_1_1__leaf_net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net559 clknet_0_net559 VGND VGND VPWR VPWR clknet_1_1__leaf_net559
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net548 clknet_0_net548 VGND VGND VPWR VPWR clknet_1_1__leaf_net548
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_558 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c231_A3 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c337_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c256_B1 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout118_X net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c166_B1 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c674_S1 net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c173_Q_N net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net312 clknet_0_net312 VGND VGND VPWR VPWR clknet_1_1__leaf_net312
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_58_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net389 clknet_0_net389 VGND VGND VPWR VPWR clknet_1_1__leaf_net389
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c226_A3 net1066 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c242_A2 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net502 net502 VGND VGND VPWR VPWR clknet_0_net502 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net513 net513 VGND VGND VPWR VPWR clknet_0_net513 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c759_S1 net1013 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s927_Q net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c714_A0 net136 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c433_A1 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c152_A2 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c207_RESET_B net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_4_11_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c327_A2 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c685_S0 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output76_A net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net153 clknet_0_net153 VGND VGND VPWR VPWR clknet_1_1__leaf_net153
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net164 clknet_0_net164 VGND VGND VPWR VPWR clknet_1_1__leaf_net164
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net175 clknet_0_net175 VGND VGND VPWR VPWR clknet_1_1__leaf_net175
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net186 clknet_0_net186 VGND VGND VPWR VPWR clknet_1_1__leaf_net186
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_81_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net968 clknet_0_net968 VGND VGND VPWR VPWR clknet_1_0__leaf_net968
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c668_SCD net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c595_S0 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c534_B1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c700_A2 net587 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c172_X net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c489_S1 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net376 net376 VGND VGND VPWR VPWR clknet_0_net376 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net398 net398 VGND VGND VPWR VPWR clknet_0_net398 sky130_fd_sc_hd__clkbuf_16
Xc722 clknet_1_1__leaf_net390 clknet_1_1__leaf_net489 clknet_1_0__leaf_net601 net787
+ net889 clknet_1_1__leaf_net893 VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__mux4_4
Xc711 clknet_1_0__leaf_net573 clknet_1_1__leaf_net553 clknet_1_0__leaf_net601 net707
+ net780 net886 VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__mux4_1
Xc700 net593 clknet_1_1__leaf_net556 net587 net739 net783 net880 VGND VGND VPWR VPWR
+ net594 sky130_fd_sc_hd__mux4_4
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c444_A0 net918 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc744 clknet_4_13_0_clk clknet_1_1__leaf_net563 clknet_1_1__leaf_net631 clknet_1_0__leaf_net633
+ net1087 net902 VGND VGND VPWR VPWR net639 net638 sky130_fd_sc_hd__sdfbbp_1
Xc755 net1013 clknet_1_0__leaf_net548 net742 clknet_1_1__leaf_net871 net894 net906
+ VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__mux4_4
Xc733 net1025 net626 net869 net888 net900 net902 VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__mux4_1
XANTENNA_c610_A2 net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_98_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_30_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c504_A3 clknet_1_1__leaf_net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net765 clknet_0_net765 VGND VGND VPWR VPWR clknet_1_0__leaf_net765
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c248_A1 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c132_A net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout100_X net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c711_A1 clknet_1_1__leaf_net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c430_A2 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c92_B net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c158_A1 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c174_A0 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc541 net733 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__clkbuf_8
Xc552 clknet_4_4_0_clk clknet_1_1__leaf_net459 clknet_1_0__leaf_net446 clknet_1_0__leaf_net372
+ clknet_1_0__leaf_net364 net1067 VGND VGND VPWR VPWR net465 net464 sky130_fd_sc_hd__sdfbbp_1
XANTENNA_c324_A3 net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc563 clknet_1_0__leaf_net455 clknet_1_0__leaf_net446 clknet_1_0__leaf_net364 net771
+ net858 net859 VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__mux4_4
Xc585 net224 net500 net1062 clknet_1_1__leaf_net448 net827 VGND VGND VPWR VPWR net502
+ sky130_fd_sc_hd__a41oi_2
Xc574 net471 clknet_1_0__leaf_net252 net1062 net809 net842 VGND VGND VPWR VPWR net488
+ sky130_fd_sc_hd__a41o_1
Xc596 clknet_1_0__leaf_net487 net224 clknet_1_1__leaf_net252 clknet_1_1__leaf_net147
+ net1045 net1005 VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__mux4_4
XANTENNA_c621_A1 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c331_CLK_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c203_S0 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c592_S1 net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net573 clknet_0_net573 VGND VGND VPWR VPWR clknet_1_0__leaf_net573
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c135_X net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_12_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c706_A1 net1051 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_98_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c425_A2 net679 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_21_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c160_A2 net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_30_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput27 in32 VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__buf_2
Xinput16 in22 VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_40_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c677_S1 net338 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput38 in42 VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__clkbuf_4
Xinput49 in6 VGND VGND VPWR VPWR net956 sky130_fd_sc_hd__buf_6
XFILLER_0_52_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc382 net317 net992 net999 net790 net805 net984 VGND VGND VPWR VPWR net971 sky130_fd_sc_hd__mux4_2
Xc360 clknet_1_1__leaf_net252 net1060 clknet_1_0__leaf_net304 net801 net816 VGND VGND
+ VPWR VPWR net310 sky130_fd_sc_hd__a41oi_1
Xc371 clknet_1_1__leaf_net313 net1047 clknet_1_1__leaf_net314 net820 net1006 net821
+ VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__mux4_4
Xc393 net330 net971 net995 net973 net730 net788 VGND VGND VPWR VPWR net996 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_48_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge870 clknet_4_6_0_clk net479 net506 VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__dfstp_2
XFILLER_0_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c245_A2 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout108_A net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge854_RESET_B net291 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c54_A1 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c155_A2 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net505 clknet_0_net505 VGND VGND VPWR VPWR clknet_1_1__leaf_net505
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c602_A3 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input38_A in42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c171_A1 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net538 clknet_0_net538 VGND VGND VPWR VPWR clknet_1_1__leaf_net538
+ sky130_fd_sc_hd__clkbuf_16
Xfanout160 net917 VGND VGND VPWR VPWR net1067 sky130_fd_sc_hd__buf_4
XFILLER_0_69_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c627_A0 net388 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c346_A1 net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc190 net1038 net132 net1023 net1058 net133 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__a41oi_1
XFILLER_0_85_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c598_S0 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone1 net1029 net1063 net6 VGND VGND VPWR VPWR net1081 sky130_fd_sc_hd__o21bai_1
XFILLER_0_26_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_22_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c613_A2 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net313 clknet_0_net313 VGND VGND VPWR VPWR clknet_1_1__leaf_net313
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c690_S1 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net357 clknet_0_net357 VGND VGND VPWR VPWR clknet_1_1__leaf_net357
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_58_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmax_cap135 net824 VGND VGND VPWR VPWR net1042 sky130_fd_sc_hd__buf_4
XANTENNA_c242_A3 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net891 clknet_0_net891 VGND VGND VPWR VPWR clknet_1_1__leaf_net891
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net503 net503 VGND VGND VPWR VPWR clknet_0_net503 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net514 net514 VGND VGND VPWR VPWR clknet_0_net514 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c267_B1 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout130_X net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_net993_A net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c714_A1 clknet_1_1__leaf_net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c433_A2 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_4_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c608_A2 clknet_1_1__leaf_net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c327_A3 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c624_A1 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c343_A2 clknet_1_0__leaf_net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output69_A net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net165 clknet_0_net165 VGND VGND VPWR VPWR clknet_1_1__leaf_net165
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net176 clknet_0_net176 VGND VGND VPWR VPWR clknet_1_1__leaf_net176
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net198 clknet_0_net198 VGND VGND VPWR VPWR clknet_1_1__leaf_net198
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net187 clknet_0_net187 VGND VGND VPWR VPWR clknet_1_1__leaf_net187
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net969 clknet_0_net969 VGND VGND VPWR VPWR clknet_1_0__leaf_net969
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c237_A3 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c534_A1 net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_92_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s911_Q_N net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_77_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c709_A1 clknet_1_1__leaf_net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c400_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c108_SCD net1082 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net377 net377 VGND VGND VPWR VPWR clknet_0_net377 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c725_A0 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc712 clknet_1_1__leaf_net474 net1036 clknet_1_0__leaf_net601 net811 net889 clknet_1_1__leaf_net892
+ VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__mux4_4
Xc701 clknet_1_1__leaf_net372 clknet_1_1__leaf_net583 net591 clknet_1_1__leaf_net585
+ net878 net883 VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__mux4_4
XPHY_EDGE_ROW_86_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc745 net621 net639 clknet_1_0__leaf_net633 clknet_1_1__leaf_net504 net758 net902
+ VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__mux4_4
Xc723 net608 clknet_1_0__leaf_net611 clknet_1_0__leaf_net390 clknet_1_0__leaf_net504
+ net841 net897 VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__mux4_1
Xc734 net626 clknet_1_1__leaf_net573 net597 net720 net867 net899 VGND VGND VPWR VPWR
+ net628 sky130_fd_sc_hd__mux4_1
Xc756 clknet_1_0__leaf_net420 net1014 net754 net820 net899 net908 VGND VGND VPWR VPWR
+ net651 sky130_fd_sc_hd__mux4_4
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c460_A0 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s902_Q_N net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input20_A in26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c610_A3 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c619_A1 clknet_1_1__leaf_net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c338_A2 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c635_A0 net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c354_A1 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_78_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s925_SLEEP_B clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c370_A0 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c132_B net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout138_A net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c280_A0 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c282_X net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c73_B1 net1081 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net174 net174 VGND VGND VPWR VPWR clknet_0_net174 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c455_A0 clknet_1_1__leaf_net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c174_A1 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc531 net732 net823 VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__xnor2_1
XANTENNA_c605_A3 clknet_1_1__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc542 clknet_1_1__leaf_net450 net441 net452 clknet_1_0__leaf_net446 clknet_1_0__leaf_net448
+ net449 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__mux4_2
Xc553 clknet_4_4_0_clk net245 clknet_1_0__leaf_net446 net464 clknet_1_0__leaf_net463
+ net809 VGND VGND VPWR VPWR net467 net466 sky130_fd_sc_hd__sdfbbn_1
Xc564 clknet_1_1__leaf_net251 clknet_1_1__leaf_net357 clknet_1_0__leaf_net474 net228
+ net776 net858 VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__mux4_4
Xc597 net1051 clknet_1_1__leaf_net252 clknet_1_0__leaf_net494 net1067 net776 net856
+ VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__mux4_2
Xc586 clknet_1_0__leaf_net398 net1036 net723 net839 net842 VGND VGND VPWR VPWR net503
+ sky130_fd_sc_hd__a41oi_4
Xc575 net1011 net1054 net959 net782 clknet_1_1__leaf_net832 VGND VGND VPWR VPWR net489
+ sky130_fd_sc_hd__a41o_4
XANTENNA_c621_A2 net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge767_A0 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c349_A1 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c203_S1 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net552 clknet_0_net552 VGND VGND VPWR VPWR clknet_1_0__leaf_net552
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net563 clknet_0_net563 VGND VGND VPWR VPWR clknet_1_0__leaf_net563
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net585 clknet_0_net585 VGND VGND VPWR VPWR clknet_1_0__leaf_net585
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s886_GATE_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge853_D net515 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c706_A2 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_s902_Q net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c144_A4 net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c160_A3 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c169_A1 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput17 in23 VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c185_B1 net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput28 in33 VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_40_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput39 in43 VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_75_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c632_A1 net740 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc361 clknet_1_0__leaf_net308 clknet_1_1__leaf_net182 net50 clknet_1_0__leaf_net305
+ net1020 net1013 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__mux4_1
Xc372 clknet_1_1__leaf_net156 clknet_1_0__leaf_net290 net317 net731 net821 net822
+ VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__mux4_4
Xc350 net0 clknet_1_1__leaf_net297 net278 net778 clknet_1_1__leaf_net815 net984 VGND
+ VGND VPWR VPWR net299 sky130_fd_sc_hd__mux4_1
XFILLER_0_58_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc383 net192 net1032 net992 net971 net999 net810 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__mux4_1
Xc394 net26 net971 net973 net996 net330 net822 VGND VGND VPWR VPWR net998 sky130_fd_sc_hd__mux4_1
XFILLER_0_74_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmerge860 clknet_4_11_0_clk net71 net422 VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__sdlclkp_2
Xmerge871 clknet_4_9_0_clk net709 net761 VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__dfstp_2
XFILLER_0_7_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c182_B1_N net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout160_X net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc532_10 clknet_1_0__leaf_net1068 VGND VGND VPWR VPWR net1077 sky130_fd_sc_hd__clkinv_8
XANTENNA_c717_A1 net1051 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c139_A4 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c54_A2 net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c436_A2 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c733_A0 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout150 net911 VGND VGND VPWR VPWR net1057 sky130_fd_sc_hd__buf_6
XFILLER_0_44_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s915_GCLK net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c346_A2 net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge866_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s884_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output99_A net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c362_A1 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc180 net934 net119 net103 net1028 net1023 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__a41oi_4
Xc191 net131 net1038 net1009 net128 net136 net753 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__mux4_1
XFILLER_0_85_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c598_S1 clknet_1_1__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout120_A net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c703_A3 net1064 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclone2 net954 net945 net1055 net1053 net959 net949 VGND VGND VPWR VPWR net1082 sky130_fd_sc_hd__mux4_1
XANTENNA_c728_A0 clknet_1_1__leaf_net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c65_A1 net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_159 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c463_A0 net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input50_A in7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net314 clknet_0_net314 VGND VGND VPWR VPWR clknet_1_1__leaf_net314
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c242_A4 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net892 clknet_0_net892 VGND VGND VPWR VPWR clknet_1_1__leaf_net892
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net870 clknet_0_net870 VGND VGND VPWR VPWR clknet_1_1__leaf_net870
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net504 net504 VGND VGND VPWR VPWR clknet_0_net504 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net548 net548 VGND VGND VPWR VPWR clknet_0_net548 sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c267_A1 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net559 net559 VGND VGND VPWR VPWR clknet_0_net559 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c208_X net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c730_A1 net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c458_A0 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c193_A0 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c624_A2 clknet_1_0__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net199 clknet_0_net199 VGND VGND VPWR VPWR clknet_1_1__leaf_net199
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge874_GATE_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c165_Y net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c108_SCE net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_net312 net312 VGND VGND VPWR VPWR clknet_0_net312 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c116_B1_N net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c147_A4 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net389 net389 VGND VGND VPWR VPWR clknet_0_net389 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c62_A2 net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc702 clknet_1_1__leaf_net585 net587 net728 net779 net783 VGND VGND VPWR VPWR net596
+ sky130_fd_sc_hd__a41oi_1
Xc713 clknet_1_1__leaf_net448 net1008 net828 net841 clknet_1_1__leaf_net891 clknet_1_0__leaf_net893
+ VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__mux4_2
XFILLER_0_16_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc746 clknet_1_1__leaf_net629 net636 net638 net627 clknet_1_0__leaf_net633 net889
+ VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__mux4_2
Xc735 net627 net597 clknet_1_1__leaf_net448 net587 net787 net890 VGND VGND VPWR VPWR
+ net629 sky130_fd_sc_hd__mux4_4
Xc724 clknet_1_1__leaf_net390 net740 net852 net888 net896 VGND VGND VPWR VPWR net618
+ sky130_fd_sc_hd__a41o_4
Xc757 net587 net758 net759 net885 net903 net905 VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__mux4_1
XFILLER_0_98_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input13_A in2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c449_Q net388 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c354_A2 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge843_Q net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c448_RESET_B net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_78_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c195_RESET_B net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net734 clknet_0_net734 VGND VGND VPWR VPWR clknet_1_0__leaf_net734
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c561_A0 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input5_A in12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s882_Q net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c57_A2 net141 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c442_X net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c439_A2 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge774_Y net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c158_A3 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net153 net153 VGND VGND VPWR VPWR clknet_0_net153 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net164 net164 VGND VGND VPWR VPWR clknet_0_net164 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net175 net175 VGND VGND VPWR VPWR clknet_0_net175 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c211_S net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net186 net186 VGND VGND VPWR VPWR clknet_0_net186 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c174_A2 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc543 net1074 net695 VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__xnor2_2
Xc554 clknet_1_1__leaf_net357 net1062 clknet_1_0__leaf_net455 clknet_1_0__leaf_net364
+ net1064 VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__a41o_4
XTAP_TAPCELL_ROW_9_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc565 net476 net466 clknet_1_1__leaf_net357 clknet_1_0__leaf_net474 net859 net860
+ VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__mux4_1
Xc587 clknet_1_1__leaf_net490 clknet_1_1__leaf_net496 net481 clknet_1_0__leaf_net488
+ net741 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__a41o_1
Xc598 clknet_1_1__leaf_net401 net388 clknet_1_1__leaf_net147 clknet_1_1__leaf_net512
+ net1054 clknet_1_1__leaf_net794 VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__mux4_4
Xc576 net1033 net471 clknet_1_0__leaf_net390 net1024 net688 VGND VGND VPWR VPWR net490
+ sky130_fd_sc_hd__a41o_1
XANTENNA_c190_A1 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge869_Q_N net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c621_A3 net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c365_A1 net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c187_D net107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net553 clknet_0_net553 VGND VGND VPWR VPWR clknet_1_0__leaf_net553
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout150_A net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c410_S0 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c706_A3 net597 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c68_A1 net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c169_A2 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput18 in24 VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_12_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c616_A3 clknet_1_1__leaf_net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput29 in34 VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_32_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_75_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c632_A2 net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc340 net280 net1037 clknet_1_0__leaf_net287 clknet_1_1__leaf_net153 net259 net152
+ VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__mux4_2
Xc362 net230 clknet_1_0__leaf_net304 clknet_1_0__leaf_net305 net301 net731 VGND VGND
+ VPWR VPWR net312 sky130_fd_sc_hd__a41o_4
Xc351 net296 clknet_1_1__leaf_net254 clknet_1_0__leaf_net297 clknet_1_0__leaf_net299
+ net778 clknet_1_1__leaf_net815 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__mux4_1
Xc373 clknet_1_1__leaf_net313 net1040 net743 net1006 net821 net822 VGND VGND VPWR
+ VPWR net965 sky130_fd_sc_hd__mux4_2
Xc384 net47 net1025 net789 net790 net810 net984 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__mux4_1
Xc395 net201 net330 net998 net324 net996 net790 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__mux4_1
XANTENNA_merge875_GATE clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge850 net634 clknet_4_13_0_clk net648 VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__dlrtn_1
Xmerge861 clknet_4_11_0_clk net169 net209 VGND VGND VPWR VPWR net969 sky130_fd_sc_hd__sdlclkp_4
XFILLER_0_55_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge872 clknet_4_12_0_clk net407 net547 VGND VGND VPWR VPWR net977 sky130_fd_sc_hd__dfstp_2
XFILLER_0_15_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c230_S0 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc532_11 clknet_1_1__leaf_net1068 VGND VGND VPWR VPWR net1078 sky130_fd_sc_hd__clkinv_8
XANTENNA_fanout153_X net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net372 clknet_0_net372 VGND VGND VPWR VPWR clknet_1_0__leaf_net372
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c286_B1 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c54_A3 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c452_A2 clknet_1_0__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout140 net36 VGND VGND VPWR VPWR net1047 sky130_fd_sc_hd__buf_4
XANTENNA_c171_A3 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s902_GATE_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net529 clknet_0_net529 VGND VGND VPWR VPWR clknet_1_1__leaf_net529
+ sky130_fd_sc_hd__clkbuf_16
Xfanout151 net1061 VGND VGND VPWR VPWR net1058 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_17_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c196_A0 net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c627_A2 net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc170 net105 net107 net116 net94 net928 net1063 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__mux4_2
Xc181 net1009 net444 net1019 net1021 net1086 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__a41oi_1
Xc192 net1009 net132 net135 net138 c192/B1 VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__a41o_1
XFILLER_0_18_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_87_252 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c537_A2 net732 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout113_A net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge793_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c728_A1 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net180 clknet_0_net180 VGND VGND VPWR VPWR clknet_1_0__leaf_net180
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_18_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input43_A in47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net304 clknet_0_net304 VGND VGND VPWR VPWR clknet_1_1__leaf_net304
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap126 net443 VGND VGND VPWR VPWR net1033 sky130_fd_sc_hd__buf_4
XFILLER_0_13_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c373_A1 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net893 clknet_0_net893 VGND VGND VPWR VPWR clknet_1_1__leaf_net893
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net871 clknet_0_net871 VGND VGND VPWR VPWR clknet_1_1__leaf_net871
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net505 net505 VGND VGND VPWR VPWR clknet_0_net505 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net538 net538 VGND VGND VPWR VPWR clknet_0_net538 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c315_A net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout116_X net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c730_A2 net1051 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c739_A0 net597 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c474_A0 net1081 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c193_A1 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input46_X net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net178 clknet_0_net178 VGND VGND VPWR VPWR clknet_1_1__leaf_net178
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net156 clknet_0_net156 VGND VGND VPWR VPWR clknet_1_1__leaf_net156
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_97_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c368_A1 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c384_A0 net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c534_A3 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c253_A4 net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c265_A net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c559_A0 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c158_Y net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net313 net313 VGND VGND VPWR VPWR clknet_0_net313 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net357 net357 VGND VGND VPWR VPWR clknet_0_net357 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c725_A2 net597 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc703 net584 net564 net593 net1064 net728 net779 VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__mux4_2
XFILLER_0_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c444_A3 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc725 net941 clknet_1_0__leaf_net601 net597 net707 clknet_1_1__leaf_net892 net897
+ VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__mux4_4
Xc747 clknet_1_1__leaf_net618 clknet_1_1__leaf_net620 net639 net627 clknet_1_0__leaf_net633
+ net867 VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__mux4_2
Xc736 net624 net1027 clknet_1_0__leaf_net618 net627 net853 net867 VGND VGND VPWR VPWR
+ net630 sky130_fd_sc_hd__mux4_2
Xc714 net136 clknet_1_1__leaf_net553 net480 clknet_1_0__leaf_net504 net881 clknet_1_0__leaf_net891
+ VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__mux4_1
XANTENNA_c741_A1 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc758 clknet_1_1__leaf_net436 net742 net770 net904 net905 net907 VGND VGND VPWR VPWR
+ net653 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_4_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c619_A3 clknet_1_1__leaf_net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net891 net891 VGND VGND VPWR VPWR clknet_0_net891 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c635_A2 net740 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge836_Q net740 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_output74_A net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c370_A2 net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net735 clknet_0_net735 VGND VGND VPWR VPWR clknet_1_0__leaf_net735
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_26_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c248_A4 net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_0_clk_X clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_4_9_0_clk_X clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s904_GATE clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c439_A3 clknet_1_0__leaf_net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c736_A1 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net165 net165 VGND VGND VPWR VPWR clknet_0_net165 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_64_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net176 net176 VGND VGND VPWR VPWR clknet_0_net176 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net198 net198 VGND VGND VPWR VPWR clknet_0_net198 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net187 net187 VGND VGND VPWR VPWR clknet_0_net187 sky130_fd_sc_hd__clkbuf_16
XANTENNA_s911_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c174_A3 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc500 net1060 net1018 net1044 net1041 clknet_1_1__leaf_net850 clknet_1_0__leaf_net851
+ VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__mux4_4
Xc533 net211 net1078 VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__xnor2_2
Xc544 net441 net212 net1050 net351 net1072 net1073 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_9_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c471_A1 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc555 net361 net1062 net1051 net464 net774 VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__a41o_2
Xc566 clknet_4_5_0_clk net476 clknet_1_0__leaf_net472 clknet_1_0__leaf_net474 net857
+ net860 VGND VGND VPWR VPWR net481 net480 sky130_fd_sc_hd__sdfbbn_2
Xc588 net497 clknet_1_0__leaf_net504 clknet_1_0__leaf_net502 net741 net1045 net839
+ VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__mux4_4
Xc577 clknet_1_1__leaf_net364 clknet_1_0__leaf_net489 net773 net782 net839 VGND VGND
+ VPWR VPWR net491 sky130_fd_sc_hd__a41o_2
Xc599 clknet_1_1__leaf_net271 clknet_1_1__leaf_net462 clknet_1_1__leaf_net364 clknet_1_0__leaf_net514
+ net1024 net1045 VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__mux4_4
XANTENNA_merge767_A2 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_71_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net969_X clknet_1_0__leaf_net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout143_A net336 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_0_net794_A net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c572_B1 clknet_1_0__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c722_A3 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c441_A4 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c84_A1 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c601_S0 clknet_1_1__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput19 in25 VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__buf_1
XANTENNA_c185_A2 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc330 clknet_1_0__leaf_net263 net230 net658 clknet_1_0__leaf_net794 VGND VGND VPWR
+ VPWR net277 sky130_fd_sc_hd__a31oi_4
XFILLER_0_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c632_A3 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc363 net309 clknet_1_1__leaf_net304 net267 net285 net800 VGND VGND VPWR VPWR net313
+ sky130_fd_sc_hd__a41o_4
Xc341 net286 clknet_1_0__leaf_net287 net1038 net282 net279 VGND VGND VPWR VPWR net290
+ sky130_fd_sc_hd__a41o_2
Xc352 net50 net283 net47 net1047 net796 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__a41oi_4
Xc385 net324 net286 clknet_1_0__leaf_net207 net1032 net790 net1044 VGND VGND VPWR
+ VPWR net326 sky130_fd_sc_hd__mux4_1
Xc396 net89 net810 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__xor2_4
XFILLER_0_99_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s878_D net53 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge873 net603 clknet_4_7_0_clk net748 VGND VGND VPWR VPWR net780 net779 sky130_fd_sc_hd__dlrbn_1
Xmerge862 clknet_4_10_0_clk net205 net65 VGND VGND VPWR VPWR net767 net766 sky130_fd_sc_hd__dfrbp_1
Xmerge840 clknet_4_11_0_clk net274 net717 VGND VGND VPWR VPWR net744 net743 sky130_fd_sc_hd__dfsbp_2
Xmerge851 net418 clknet_4_14_0_clk net714 VGND VGND VPWR VPWR net1004 sky130_fd_sc_hd__dlrtn_1
XFILLER_0_15_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c230_S1 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_97_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c178_A net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c405_S1 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net362 clknet_0_net362 VGND VGND VPWR VPWR clknet_1_0__leaf_net362
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout146_X net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c133_X net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c286_A1 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c171_A4 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout130 net224 VGND VGND VPWR VPWR net1037 sky130_fd_sc_hd__buf_4
Xfanout141 net15 VGND VGND VPWR VPWR net1048 sky130_fd_sc_hd__clkbuf_4
Xfanout152 net1060 VGND VGND VPWR VPWR net1059 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_88_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c95_B1 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c196_A1 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc171 net1021 net83 net1022 net1054 net724 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__a41o_2
Xc160 net933 net100 net141 net105 net83 net1057 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__mux4_2
XFILLER_0_85_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc182 net4 net949 net107 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__o21ba_1
XFILLER_0_20_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc193 net120 net1018 net119 net128 net133 net934 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__mux4_1
XFILLER_0_18_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c241_S0 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_s971_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout106_A net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c416_S0 net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s955_Q net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c728_A2 net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c463_A2 net679 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net305 clknet_0_net305 VGND VGND VPWR VPWR clknet_1_1__leaf_net305
+ sky130_fd_sc_hd__clkbuf_16
Xhold8 net712 VGND VGND VPWR VPWR net1083 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input36_A in40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c326_S0 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge775_A2 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net850 clknet_0_net850 VGND VGND VPWR VPWR clknet_1_1__leaf_net850
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net872 clknet_0_net872 VGND VGND VPWR VPWR clknet_1_1__leaf_net872
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_334 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c315_B net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout109_X net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c76_A2 net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c458_A2 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c177_A3 net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c755_A0 net1013 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c474_A1 net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c490_A0 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input39_X net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_610 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c384_A1 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_0_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c550_A3 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_37_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c265_B net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_101_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_5_0_clk_X clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net314 net314 VGND VGND VPWR VPWR clknet_0_net314 sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_46_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge869_D net473 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc704 clknet_1_0__leaf_net503 clknet_1_1__leaf_net390 clknet_1_0__leaf_net563 net1062
+ net881 net886 VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__mux4_1
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc715 clknet_1_1__leaf_net503 net780 clknet_1_1__leaf_net814 net887 net890 clknet_1_0__leaf_net893
+ VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__mux4_2
Xc726 clknet_1_1__leaf_net448 net587 net597 net1057 net828 net867 VGND VGND VPWR VPWR
+ net620 sky130_fd_sc_hd__mux4_1
Xc737 net600 clknet_1_0__leaf_net629 net626 net1015 net770 net781 VGND VGND VPWR VPWR
+ net631 sky130_fd_sc_hd__mux4_1
XFILLER_0_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc748 clknet_1_0__leaf_net552 net1003 net1013 clknet_1_0__leaf_net870 net895 net903
+ VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__mux4_1
Xc759 net652 net587 net646 clknet_1_1__leaf_net633 clknet_1_1__leaf_net653 net1013
+ VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__mux4_2
XPHY_EDGE_ROW_55_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c162_B1_N net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c469_A1 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c604_S0 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_80_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_64_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c188_A2 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c337_Q net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c485_A0 clknet_1_1__leaf_net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net870 net870 VGND VGND VPWR VPWR clknet_0_net870 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net892 net892 VGND VGND VPWR VPWR clknet_0_net892 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_78_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c370_A3 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_82_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c545_A3 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net199 net199 VGND VGND VPWR VPWR clknet_0_net199 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c752_A1 net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc501 clknet_1_0__leaf_net428 clknet_1_0__leaf_net434 net1004 clknet_1_1__leaf_net993
+ clknet_1_1__leaf_net850 clknet_1_0__leaf_net851 VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__mux4_4
Xc545 net453 net449 net452 net1016 net1011 net1014 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_9_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc534 net82 net1077 net228 net811 VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__a31oi_2
Xc589 clknet_1_0__leaf_net501 net256 clknet_1_0__leaf_net504 net1049 clknet_1_0__leaf_net472
+ net733 VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__mux4_4
Xc578 clknet_4_6_0_clk net1015 clknet_1_0__leaf_net489 net741 net842 net856 VGND VGND
+ VPWR VPWR net493 net492 sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc556 net469 clknet_1_0__leaf_net364 net1035 net774 net1042 VGND VGND VPWR VPWR net470
+ sky130_fd_sc_hd__a41oi_4
Xc567 net355 clknet_1_0__leaf_net463 net469 clknet_1_0__leaf_net472 net858 net859
+ VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__mux4_1
XANTENNA_c190_A3 net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge767_A3 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c662_A1 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c297_CLK_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net522 clknet_0_net522 VGND VGND VPWR VPWR clknet_1_0__leaf_net522
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net555 clknet_0_net555 VGND VGND VPWR VPWR clknet_1_0__leaf_net555
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c556_A2 clknet_1_0__leaf_net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout136_A net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c572_A1 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c200_B1_N net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c601_S1 net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge772_X net666 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c466_A2 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s896_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c482_A1 net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc320 clknet_4_2_0_clk net256 net1009 net262 net103 net752 VGND VGND VPWR VPWR net997
+ net267 sky130_fd_sc_hd__sdfbbp_1
XTAP_TAPCELL_ROW_75_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc331 clknet_4_9_0_clk net444 clknet_1_1__leaf_net263 net158 net924 clknet_1_0__leaf_net969
+ VGND VGND VPWR VPWR net972 net278 sky130_fd_sc_hd__sdfbbn_2
Xc353 net152 clknet_1_1__leaf_net172 net278 net1032 net796 VGND VGND VPWR VPWR net302
+ sky130_fd_sc_hd__a41o_1
Xc342 net258 net1016 net285 net1037 clknet_1_1__leaf_net815 net816 VGND VGND VPWR
+ VPWR net291 sky130_fd_sc_hd__mux4_4
XANTENNA_c329_S0 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc386 clknet_1_0__leaf_net207 net962 clknet_1_1__leaf_net969 net790 net803 net805
+ VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__mux4_2
Xc364 clknet_1_0__leaf_net304 clknet_1_0__leaf_net313 clknet_1_0__leaf_net305 net1020
+ net282 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__a41oi_4
Xc397 net214 net909 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__xor2_4
XFILLER_0_74_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge802_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input21_X net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_86_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge830 clknet_4_0_0_clk net229 net678 VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__edfxtp_1
Xmerge841 clknet_4_8_0_clk net160 net664 VGND VGND VPWR VPWR net746 net745 sky130_fd_sc_hd__dfsbp_1
Xmerge863 clknet_4_2_0_clk net130 net203 VGND VGND VPWR VPWR net769 net768 sky130_fd_sc_hd__dfrbp_2
Xmerge852 net681 clknet_4_12_0_clk net412 VGND VGND VPWR VPWR net970 sky130_fd_sc_hd__dlrtn_1
XFILLER_0_99_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge874 net485 clknet_4_6_0_clk net531 VGND VGND VPWR VPWR net782 net781 sky130_fd_sc_hd__dlrbn_1
XANTENNA_c392_A1 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c178_B net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c286_A2 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s878_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout120 net14 VGND VGND VPWR VPWR net1027 sky130_fd_sc_hd__clkbuf_2
Xfanout131 net134 VGND VGND VPWR VPWR net1038 sky130_fd_sc_hd__clkbuf_4
Xfanout153 net1061 VGND VGND VPWR VPWR net1060 sky130_fd_sc_hd__buf_4
Xfanout142 net342 VGND VGND VPWR VPWR net1049 sky130_fd_sc_hd__buf_4
XANTENNA_c127_CLK_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c79_X net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc172 net724 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__buf_2
Xc161 net108 net936 net104 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__mux2_4
Xc150 net910 net931 net98 net89 net86 net1016 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__mux4_2
XFILLER_0_85_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc194 net133 net1015 net1021 net1016 net727 net792 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__mux4_1
Xc183 net976 VGND VGND VPWR VPWR net961 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c387_A1 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c241_S1 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net182 clknet_0_net182 VGND VGND VPWR VPWR clknet_1_0__leaf_net182
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net193 clknet_0_net193 VGND VGND VPWR VPWR clknet_1_0__leaf_net193
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_38_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_50_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c81_A3 net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c463_A3 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold9 net833 VGND VGND VPWR VPWR net1084 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input29_A in34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge775_A3 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output97_A net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap139 net732 VGND VGND VPWR VPWR net1046 sky130_fd_sc_hd__buf_4
XANTENNA_c373_A3 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net851 clknet_0_net851 VGND VGND VPWR VPWR clknet_1_1__leaf_net851
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net529 net529 VGND VGND VPWR VPWR clknet_0_net529 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_61_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net290_X clknet_1_1__leaf_net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_1_0_clk_X clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s898_Q net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c739_A2 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_27_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c474_A2 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c490_A1 net1060 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net147 clknet_0_net147 VGND VGND VPWR VPWR clknet_1_1__leaf_net147
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_97_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c665_A1 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_22 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge855_GATE clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net304 net304 VGND VGND VPWR VPWR clknet_0_net304 sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_101_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c418_A net732 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c575_A1 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c294_A2 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_60_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout121_X net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc716 clknet_1_1__leaf_net609 net1008 clknet_1_1__leaf_net390 clknet_1_1__leaf_net553
+ net777 net811 VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__mux4_1
Xc705 clknet_1_1__leaf_net570 clknet_1_1__leaf_net573 net1024 net480 net885 net888
+ VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__mux4_2
Xc727 net493 clknet_1_0__leaf_net563 net1051 net787 net827 net885 VGND VGND VPWR VPWR
+ net621 sky130_fd_sc_hd__mux4_1
Xc738 net102 clknet_1_1__leaf_net563 net626 clknet_1_0__leaf_net631 clknet_1_1__leaf_net601
+ net901 VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__mux4_1
XFILLER_0_97_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc749 clknet_1_1__leaf_net428 clknet_1_1__leaf_net504 clknet_1_1__leaf_net633 net770
+ net775 clknet_1_1__leaf_net871 VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_4_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c604_S1 net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c188_A3 net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c485_A1 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c620_S0 net388 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net893 net893 VGND VGND VPWR VPWR clknet_0_net893 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net871 net871 VGND VGND VPWR VPWR clknet_0_net871 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_78_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input51_X net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c676_A0 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c705_S0 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c535_A net1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net156 net156 VGND VGND VPWR VPWR clknet_0_net156 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net178 net178 VGND VGND VPWR VPWR clknet_0_net178 sky130_fd_sc_hd__clkbuf_16
Xc502 net426 net994 net983 net845 clknet_1_0__leaf_net849 clknet_1_0__leaf_net850
+ VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__mux4_2
Xc546 net453 net452 clknet_1_0__leaf_net455 clknet_1_0__leaf_net445 net720 net854
+ VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__mux4_2
Xc535 net1057 net1076 VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_9_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc568 net1064 clknet_1_1__leaf_net446 net777 net827 net859 net861 VGND VGND VPWR VPWR
+ net967 sky130_fd_sc_hd__mux4_1
Xc579 net471 clknet_1_0__leaf_net487 net492 clknet_1_1__leaf_net488 net733 VGND VGND
+ VPWR VPWR net494 sky130_fd_sc_hd__a41oi_1
Xc557 net98 net1033 net469 net464 net688 VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__a41oi_4
XANTENNA_c471_A3 net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c190_A4 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input11_A in18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_71_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c662_A2 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput90 net997 VGND VGND VPWR VPWR out47 sky130_fd_sc_hd__buf_2
Xclkbuf_1_0__f_net501 clknet_0_net501 VGND VGND VPWR VPWR clknet_1_0__leaf_net501
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net512 clknet_0_net512 VGND VGND VPWR VPWR clknet_1_0__leaf_net512
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net556 clknet_0_net556 VGND VGND VPWR VPWR clknet_1_0__leaf_net556
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c260_S0 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s954_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input3_A in10 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s880_Q net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c84_A3 net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c170_S0 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c357_CLK_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc310 net949 net108 net1039 net703 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__a31oi_4
Xc321 clknet_4_2_0_clk net260 net106 clknet_1_0__leaf_net254 net1007 VGND VGND VPWR
+ VPWR net268 sky130_fd_sc_hd__sdfrtn_1
XANTENNA_c482_A2 net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc332 clknet_4_8_0_clk net972 net259 clknet_1_1__leaf_net156 net157 VGND VGND VPWR
+ VPWR net279 sky130_fd_sc_hd__sdfrtp_1
Xc354 net122 net1007 net301 clknet_1_1__leaf_net172 clknet_1_0__leaf_net795 VGND VGND
+ VPWR VPWR net303 sky130_fd_sc_hd__a41o_2
Xc343 net268 clknet_1_0__leaf_net290 net285 net759 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__a31oi_4
Xc387 net192 net1060 net986 net971 net803 net822 VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__mux4_1
Xc365 clknet_1_1__leaf_net182 net286 clknet_1_0__leaf_net314 clknet_1_0__leaf_net313
+ clknet_1_1__leaf_net308 net50 VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__mux4_2
Xc398 net99 net89 net221 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__a21bo_1
XANTENNA_c345_S0 net760 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge820 net632 net651 VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__xor2_4
XFILLER_0_74_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge864 clknet_4_15_0_clk net551 net680 VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__dfrtn_1
Xmerge831 clknet_4_5_0_clk net483 net667 VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__sdlclkp_1
Xmerge842 clknet_4_13_0_clk net413 net654 VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__dfstp_1
Xmerge853 net515 clknet_4_14_0_clk net719 VGND VGND VPWR VPWR net994 sky130_fd_sc_hd__dlrtp_1
XFILLER_0_99_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs970 net616 clknet_4_7_0_clk VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_82_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge875 net516 clknet_4_7_0_clk net592 VGND VGND VPWR VPWR net784 net783 sky130_fd_sc_hd__dlrbp_1
XFILLER_0_55_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer1 net9 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_23_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xnet999_2 net733 VGND VGND VPWR VPWR net1069 sky130_fd_sc_hd__clkinv_8
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net364 clknet_0_net364 VGND VGND VPWR VPWR clknet_1_0__leaf_net364
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c286_A3 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c149_S1 net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout121 net1029 VGND VGND VPWR VPWR net1028 sky130_fd_sc_hd__buf_4
Xfanout110 net96 VGND VGND VPWR VPWR net1017 sky130_fd_sc_hd__buf_4
XANTENNA_input6_X net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout132 net961 VGND VGND VPWR VPWR net1039 sky130_fd_sc_hd__buf_4
Xfanout154 net943 VGND VGND VPWR VPWR net1061 sky130_fd_sc_hd__buf_4
Xfanout143 net336 VGND VGND VPWR VPWR net1050 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_17_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c196_A3 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c493_A1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc140 net88 net921 net87 net1052 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__a31o_4
Xc162 net87 net931 net1054 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__a21boi_2
Xc151 net98 net99 net912 net1052 net921 net89 VGND VGND VPWR VPWR net1003 sky130_fd_sc_hd__mux4_2
Xc173 clknet_4_0_0_clk net932 net114 net120 net119 net1021 VGND VGND VPWR VPWR net122
+ net121 sky130_fd_sc_hd__sdfbbn_2
Xc195 clknet_4_2_0_clk net133 net108 net1009 net727 net792 VGND VGND VPWR VPWR net145
+ net144 sky130_fd_sc_hd__sdfbbn_2
Xc184 net723 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__inv_4
XANTENNA_c387_A2 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net290_X clknet_1_0__leaf_net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_99_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c183_A net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge778_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c432_S1 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net967_X clknet_1_1__leaf_net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout151_X net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net172 clknet_0_net172 VGND VGND VPWR VPWR clknet_1_0__leaf_net172
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_A0 clknet_1_0__leaf_net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c623_S0 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c488_A1 clknet_1_0__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c342_S1 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c91_X net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c213_B1_N net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_94_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c173_CLK_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c564_A3 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c708_S0 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c61_S0 net922 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c739_A3 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c474_A3 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c108_Q net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c490_A2 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c618_S0 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input41_A in45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge871_Q net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c384_A3 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c263_S0 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout159_A net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net305 net305 VGND VGND VPWR VPWR clknet_0_net305 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c575_A2 net1054 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout114_X net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc728 clknet_1_1__leaf_net448 net1036 net1008 net781 net828 net888 VGND VGND VPWR
+ VPWR net622 sky130_fd_sc_hd__mux4_4
Xc717 net481 net1051 clknet_1_1__leaf_net570 clknet_1_0__leaf_net609 net787 clknet_1_0__leaf_net891
+ VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__mux4_1
Xc706 net500 net1051 net1025 net597 net1036 net841 VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__mux4_2
XANTENNA_c591_A1 clknet_1_1__leaf_net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c56_S0 net1082 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc739 net597 clknet_1_1__leaf_net563 net1003 net1027 net781 net828 VGND VGND VPWR
+ VPWR net633 sky130_fd_sc_hd__mux4_2
XFILLER_0_12_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c568_X net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c112_B1 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c469_A3 net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_80_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c485_A2 net1013 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s914_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c620_S1 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net850 net850 VGND VGND VPWR VPWR clknet_0_net850 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net872 net872 VGND VGND VPWR VPWR clknet_0_net872 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c401_B1_N net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net490 clknet_0_net490 VGND VGND VPWR VPWR clknet_1_1__leaf_net490
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_65_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c195_SCD net1009 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c149_X net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s923_Q net841 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc503 net54 clknet_1_0__leaf_net436 net1064 clknet_1_1__leaf_net964 clknet_1_0__leaf_net850
+ clknet_1_0__leaf_net851 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__mux4_1
Xc536 net1016 clknet_1_0__leaf_net445 net1019 VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_9_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc569 net925 clknet_1_0__leaf_net472 net777 net831 net860 net861 VGND VGND VPWR VPWR
+ net483 sky130_fd_sc_hd__mux4_1
Xc547 net449 clknet_1_0__leaf_net448 net1071 net1017 net1042 net857 VGND VGND VPWR
+ VPWR net459 sky130_fd_sc_hd__mux4_2
Xc558 net469 clknet_1_0__leaf_net462 clknet_1_0__leaf_net446 net1045 net829 VGND VGND
+ VPWR VPWR net472 sky130_fd_sc_hd__a41o_2
XANTENNA_c424_B1_N net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c98_A2 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c631_S0 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c496_A1 clknet_1_0__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c350_S1 net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output72_A net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput80 clknet_1_1__leaf_net987 VGND VGND VPWR VPWR out37 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput91 net998 VGND VGND VPWR VPWR out48 sky130_fd_sc_hd__buf_2
XFILLER_0_77_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net502 clknet_0_net502 VGND VGND VPWR VPWR clknet_1_0__leaf_net502
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net513 clknet_0_net513 VGND VGND VPWR VPWR clknet_1_0__leaf_net513
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c260_S1 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_14_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c716_S0 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c266_X net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c597_A0 net1051 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c433_X net369 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c170_S1 net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc311 net947 net128 net769 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__o21a_1
XFILLER_0_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc300 net114 net1022 net1030 net710 net810 net1043 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_75_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc333 net0 net122 net924 net792 clknet_1_0__leaf_net794 VGND VGND VPWR VPWR net280
+ sky130_fd_sc_hd__a41o_2
Xc344 net259 clknet_1_1__leaf_net164 net286 net1032 net989 net808 VGND VGND VPWR VPWR
+ net293 sky130_fd_sc_hd__mux4_2
Xc322 clknet_1_1__leaf_net266 clknet_1_1__leaf_net250 net703 VGND VGND VPWR VPWR net269
+ sky130_fd_sc_hd__a21bo_4
Xc355 net283 net285 clknet_1_0__leaf_net147 net1002 net989 clknet_1_0__leaf_net795
+ VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__mux4_2
Xc366 clknet_4_11_0_clk clknet_1_0__leaf_net314 clknet_1_1__leaf_net304 net50 clknet_1_0__leaf_net313
+ net818 VGND VGND VPWR VPWR net317 net316 sky130_fd_sc_hd__sdfbbn_1
Xc388 net1026 net316 net1001 net999 net803 net984 VGND VGND VPWR VPWR net973 sky130_fd_sc_hd__mux4_2
XANTENNA_merge763_S0 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc399 net1022 net211 net810 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__o21a_2
XANTENNA_c345_S1 net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c361_S0 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge846_GATE_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge821 net716 clknet_4_2_0_clk net657 VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__dlrtn_2
Xmerge810 net272 net395 VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__xor2_2
Xmerge854 net721 clknet_4_13_0_clk net291 VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__dlrtp_2
XFILLER_0_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge832 clknet_4_9_0_clk net270 net528 VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__sdlclkp_2
Xmerge843 clknet_4_9_0_clk net668 net685 VGND VGND VPWR VPWR net976 sky130_fd_sc_hd__dfstp_1
Xs960 clknet_4_7_0_clk net595 VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_82_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge865 clknet_4_15_0_clk net706 net675 VGND VGND VPWR VPWR net1000 sky130_fd_sc_hd__dfrtp_1
Xmerge876 net415 clknet_4_14_0_clk net536 VGND VGND VPWR VPWR net786 net785 sky130_fd_sc_hd__dlrbp_1
XFILLER_0_99_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs971 net622 clknet_4_7_0_clk VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__dlxtn_2
XTAP_TAPCELL_ROW_11_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c331_SCD net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer2 net442 VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_79_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s940_GATE clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net967_X clknet_1_0__leaf_net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net376 clknet_0_net376 VGND VGND VPWR VPWR clknet_1_0__leaf_net376
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout141_A net15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net398 clknet_0_net398 VGND VGND VPWR VPWR clknet_1_0__leaf_net398
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_88_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c64_S0 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout122 net7 VGND VGND VPWR VPWR net1029 sky130_fd_sc_hd__buf_4
XFILLER_0_1_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout111 net129 VGND VGND VPWR VPWR net1018 sky130_fd_sc_hd__buf_4
Xfanout100 net257 VGND VGND VPWR VPWR net1007 sky130_fd_sc_hd__clkbuf_4
Xfanout155 net941 VGND VGND VPWR VPWR net1062 sky130_fd_sc_hd__buf_4
Xfanout133 net961 VGND VGND VPWR VPWR net1040 sky130_fd_sc_hd__buf_2
XANTENNA_c446_S0 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout144 net102 VGND VGND VPWR VPWR net1051 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c758_A2 net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc163 net930 net104 net107 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__a21bo_1
Xc130 net737 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__clkinv_8
Xc141 net86 net82 net88 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__mux2_4
Xc152 net87 net909 net1017 net88 net99 net1022 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__mux4_2
Xc196 net1009 net123 net131 net1038 net727 net792 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__mux4_1
Xc185 net104 net1 net1023 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__o21ai_2
Xc174 net106 net946 net105 net121 net120 net110 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__mux4_2
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s926_Q_N net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclone7 net1029 net1063 net6 VGND VGND VPWR VPWR net1092 sky130_fd_sc_hd__o21bai_1
XANTENNA_c176_A net723 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout144_X net1051 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_72_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c165_B1_N net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net308 clknet_0_net308 VGND VGND VPWR VPWR clknet_1_1__leaf_net308
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c406_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c623_S1 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c488_A2 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c589_A1 net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c443_S1 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input34_A in39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge771_S0 net1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c499_A1 clknet_1_0__leaf_net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc90 net938 net20 net35 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__a21boi_4
XFILLER_0_97_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge864_Q net770 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c681_A2 net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c528_S1 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c575_A3 net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_15_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc707 clknet_1_1__leaf_net502 net1015 net941 clknet_1_1__leaf_net814 net884 net888
+ VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__mux4_2
XANTENNA_c719_S0 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc718 clknet_1_1__leaf_net611 clknet_1_0__leaf_net504 clknet_1_1__leaf_net601 net780
+ clknet_1_1__leaf_net891 clknet_1_0__leaf_net892 VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__mux4_2
Xc729 net956 net1036 net597 net773 net867 net902 VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__mux4_1
XANTENNA_s937_GATE_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout107_X net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c438_S1 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge841_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_68_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_579 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net851 net851 VGND VGND VPWR VPWR clknet_0_net851 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c348_S1 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_42_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge832_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c676_A2 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_51_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c692_A1 net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c539_S0 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c258_S1 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c447_SET_B clknet_1_0__leaf_net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_60_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_65_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c586_A2 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net147 net147 VGND VGND VPWR VPWR clknet_0_net147 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc537 net443 net732 net1042 VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__o21ai_2
XANTENNA_c107_A1 net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc504 net437 net306 clknet_1_0__leaf_net436 clknet_1_1__leaf_net993 net847 clknet_1_0__leaf_net849
+ VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__mux4_2
Xc548 clknet_1_0__leaf_net459 clknet_1_1__leaf_net447 net452 clknet_1_0__leaf_net448
+ net829 net854 VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__mux4_2
Xc559 net105 clknet_1_0__leaf_net357 clknet_1_0__leaf_net472 net339 net771 net774
+ VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__mux4_1
XANTENNA_c631_S1 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c496_A2 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s899_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge827_Q net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput70 net977 VGND VGND VPWR VPWR out27 sky130_fd_sc_hd__buf_2
XANTENNA_merge806_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output65_A net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput92 net999 VGND VGND VPWR VPWR out49 sky130_fd_sc_hd__buf_2
Xoutput81 net988 VGND VGND VPWR VPWR out38 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net503 clknet_0_net503 VGND VGND VPWR VPWR clknet_1_0__leaf_net503
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net514 clknet_0_net514 VGND VGND VPWR VPWR clknet_1_0__leaf_net514
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c208_B1 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c101_SCE net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c572_A4 net959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c716_S1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c597_A1 clknet_1_1__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c161_X net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc312 net128 net210 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__xnor2_4
Xc301 net235 net241 net939 net237 net116 clknet_1_0__leaf_net813 VGND VGND VPWR VPWR
+ net248 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_75_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc323 net1007 net1020 net268 net267 net120 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__a41oi_1
Xc334 net106 clknet_1_0__leaf_net271 net1092 net0 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__a31oi_1
Xc345 net286 net282 net258 net268 net760 net764 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__mux4_1
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc356 clknet_1_1__leaf_net156 net122 net1047 clknet_1_1__leaf_net172 clknet_1_1__leaf_net795
+ VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__a41oi_1
Xc367 net302 net47 clknet_1_0__leaf_net314 net316 clknet_1_0__leaf_net313 net986 VGND
+ VGND VPWR VPWR net318 sky130_fd_sc_hd__mux4_4
Xc389 net971 net325 net973 clknet_1_1__leaf_net207 net790 net822 VGND VGND VPWR VPWR
+ net329 sky130_fd_sc_hd__mux4_4
XFILLER_0_87_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s892_GATE clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c300_A1 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge812_GATE clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge800 clknet_4_10_0_clk net195 merge800/SET_B VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__dfstp_1
Xmerge811 net238 clknet_4_0_0_clk net689 VGND VGND VPWR VPWR net711 net710 sky130_fd_sc_hd__dlrbp_1
XANTENNA_c361_S1 net1013 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge844 net586 net588 VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__xnor2_2
Xmerge833 clknet_4_10_0_clk net78 net686 VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__sdlclkp_4
XFILLER_0_23_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge822 net660 clknet_4_2_0_clk net276 VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__dlrtn_2
Xmerge855 net519 clknet_4_9_0_clk net701 VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__dlrtp_2
Xs961 clknet_4_7_0_clk net599 VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__dfxtp_2
Xmerge877 net610 clknet_4_7_0_clk net619 VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__dlrtn_2
Xs950 net569 clknet_4_5_0_clk VGND VGND VPWR VPWR net874 net873 sky130_fd_sc_hd__dlxbn_1
Xmerge866 clknet_4_1_0_clk merge866/D net370 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__dfrtp_1
Xs972 net630 clknet_4_13_0_clk VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__dlxtp_1
XTAP_TAPCELL_ROW_11_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c331_SCE net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer3 net444 VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_97_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c210_A1 net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net377 clknet_0_net377 VGND VGND VPWR VPWR clknet_1_0__leaf_net377
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c727_S0 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout101 net257 VGND VGND VPWR VPWR net1008 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_10_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout112 net93 VGND VGND VPWR VPWR net1019 sky130_fd_sc_hd__buf_6
Xfanout145 net81 VGND VGND VPWR VPWR net1052 sky130_fd_sc_hd__clkbuf_4
Xfanout123 net1031 VGND VGND VPWR VPWR net1030 sky130_fd_sc_hd__buf_2
Xfanout156 net940 VGND VGND VPWR VPWR net1063 sky130_fd_sc_hd__buf_4
XANTENNA_c95_A4 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_7_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c493_A3 net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc120 net45 net60 net63 net62 net66 net766 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__mux4_2
XANTENNA_c637_S0 net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc131 net57 net62 net1010 net68 clknet_1_0__leaf_net735 net789 VGND VGND VPWR VPWR
+ net80 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc142 net88 net910 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__and2b_2
Xc153 net94 net1017 net91 net100 net1065 net82 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__mux4_2
Xc175 net113 net934 net122 net933 net123 net724 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__mux4_1
Xc164 net935 net1021 net100 net108 net913 net102 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__mux4_2
Xc186 net976 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__clkbuf_2
Xc197 net145 net1056 net1038 net135 net753 clknet_1_0__leaf_net793 VGND VGND VPWR
+ VPWR net147 sky130_fd_sc_hd__mux4_1
XFILLER_0_34_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c552_SCE clknet_1_0__leaf_net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c684_A2 clknet_1_1__leaf_net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_99_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c205_A1 net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c221_B1 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone8 clknet_0_net271 VGND VGND VPWR VPWR net1093 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_93_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net174 clknet_0_net174 VGND VGND VPWR VPWR clknet_1_0__leaf_net174
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_A2 net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c59_S1 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout137_X net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_50_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge835_Q_N net738 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c488_A3 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s887_GATE_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_94_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net832 clknet_0_net832 VGND VGND VPWR VPWR clknet_1_1__leaf_net832
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c679_A2 net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_4_6_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c634_S1 net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input27_A in32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc91 net20 net1048 net1066 net1047 net955 VGND VGND VPWR VPWR net1002 sky130_fd_sc_hd__a41o_4
Xc80 net25 net19 net1092 net3 net22 net18 VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__mux4_1
XFILLER_0_85_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_output95_A net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c155_B1_N net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c320_D net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_1__f_net553_X clknet_1_1__leaf_net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc708 clknet_1_1__leaf_net474 clknet_1_1__leaf_net570 net597 clknet_1_0__leaf_net601
+ net828 net887 VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__mux4_4
Xc719 clknet_1_0__leaf_net474 clknet_1_0__leaf_net611 net1049 net1025 net787 clknet_1_0__leaf_net892
+ VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__mux4_4
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c735_S0 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s896_Q net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c112_A2 net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_89_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c676_A3 net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_1 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c586_A3 net723 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c309_Y net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc505 net278 net743 net977 net847 clknet_1_1__leaf_net850 clknet_1_0__leaf_net851
+ VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__mux4_4
Xc549 net1070 clknet_1_0__leaf_net445 net1054 net694 net720 net857 VGND VGND VPWR
+ VPWR net461 sky130_fd_sc_hd__mux4_2
Xc538 net1075 net695 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__xor2_4
XANTENNA_c83_S0 net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c465_S0 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_4_14_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput60 clknet_1_0__leaf_net967 VGND VGND VPWR VPWR out18 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c314_A0 net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput93 net1000 VGND VGND VPWR VPWR out5 sky130_fd_sc_hd__buf_2
Xoutput82 net989 VGND VGND VPWR VPWR out39 sky130_fd_sc_hd__buf_2
Xoutput71 net978 VGND VGND VPWR VPWR out28 sky130_fd_sc_hd__buf_2
XFILLER_0_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net504 clknet_0_net504 VGND VGND VPWR VPWR clknet_1_0__leaf_net504
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net548 clknet_0_net548 VGND VGND VPWR VPWR clknet_1_0__leaf_net548
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net559 clknet_0_net559 VGND VGND VPWR VPWR clknet_1_0__leaf_net559
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c208_A1 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net563_A net563 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c533_A net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c154_X net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s883_GCLK net793 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc302 net218 net239 net241 net1030 net946 clknet_1_1__leaf_net813 VGND VGND VPWR VPWR
+ net249 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_75_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc335 clknet_4_9_0_clk clknet_1_1__leaf_net254 net259 net1026 net1063 net1045 VGND
+ VGND VPWR VPWR net283 net282 sky130_fd_sc_hd__sdfbbn_2
Xc313 net141 net1018 net1014 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__o21a_1
Xc324 clknet_1_1__leaf_net269 net1024 net1061 clknet_1_0__leaf_net734 net811 VGND
+ VGND VPWR VPWR net271 sky130_fd_sc_hd__a41o_1
Xc368 net310 net997 net317 clknet_1_1__leaf_net314 net788 net819 VGND VGND VPWR VPWR
+ net319 sky130_fd_sc_hd__mux4_2
Xc346 clknet_1_0__leaf_net271 net278 net1048 net722 clknet_1_0__leaf_net969 net816
+ VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__mux4_1
Xc357 clknet_4_9_0_clk net283 net26 clknet_1_1__leaf_net172 net1047 net986 VGND VGND
+ VPWR VPWR net307 net306 sky130_fd_sc_hd__sdfbbn_1
XTAP_TAPCELL_ROW_86_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge812 net659 clknet_4_10_0_clk net52 VGND VGND VPWR VPWR net713 net712 sky130_fd_sc_hd__dlrbp_1
XFILLER_0_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge801 clknet_4_1_0_clk net353 net341 VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__dfstp_1
Xmerge823 net117 clknet_4_2_0_clk net700 VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__dlrtp_2
Xmerge834 clknet_4_8_0_clk net666 net155 VGND VGND VPWR VPWR net737 net736 sky130_fd_sc_hd__dfrbp_2
Xmerge845 clknet_4_12_0_clk net404 net405 VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__dfstp_1
Xs951 net571 clknet_4_5_0_clk VGND VGND VPWR VPWR net876 net875 sky130_fd_sc_hd__dlxbn_1
Xs940 net482 clknet_4_4_0_clk VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__dlxtp_1
Xmerge867 clknet_4_8_0_clk net190 net403 VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__dfrtp_4
Xmerge856 net300 net298 VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__xnor2_4
Xs962 clknet_4_7_0_clk net602 VGND VGND VPWR VPWR net890 sky130_fd_sc_hd__dfxtp_1
Xs973 net644 clknet_4_15_0_clk VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__lpflow_inputisolatch_1
XANTENNA_c309_B1 net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net490 net490 VGND VGND VPWR VPWR clknet_0_net490 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_11_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer4 clknet_0_net376 VGND VGND VPWR VPWR net1079 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net312 clknet_0_net312 VGND VGND VPWR VPWR clknet_1_0__leaf_net312
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net389 clknet_0_net389 VGND VGND VPWR VPWR clknet_1_0__leaf_net389
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c727_S1 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout102 net127 VGND VGND VPWR VPWR net1009 sky130_fd_sc_hd__clkbuf_4
Xfanout113 net93 VGND VGND VPWR VPWR net1020 sky130_fd_sc_hd__clkbuf_4
Xfanout146 net955 VGND VGND VPWR VPWR net1053 sky130_fd_sc_hd__buf_4
Xfanout124 net1032 VGND VGND VPWR VPWR net1031 sky130_fd_sc_hd__clkbuf_4
XANTENNA_input1_A in0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout157 net940 VGND VGND VPWR VPWR net1064 sky130_fd_sc_hd__buf_2
XANTENNA_c743_S0 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c462_S1 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c703_X net597 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c129_B1 net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc110 net713 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_2
Xc121 net62 net68 net58 net1065 net61 net67 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc143 net89 net90 net1052 net84 net1067 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__a41o_1
Xc154 net909 net933 net927 net1058 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__a31o_2
Xc132 net958 net931 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__nand2_1
Xc165 net104 net1019 net1058 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__o21bai_4
Xc176 net723 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__inv_1
Xc187 clknet_4_2_0_clk net107 net1065 net1016 net133 net1058 VGND VGND VPWR VPWR net136
+ net135 sky130_fd_sc_hd__sdfbbp_1
Xc198 net745 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_6
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input12_X net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c311_A1 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s962_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c547_S1 net857 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c205_A2 net1066 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_2_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net175 clknet_0_net175 VGND VGND VPWR VPWR clknet_1_0__leaf_net175
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net153 clknet_0_net153 VGND VGND VPWR VPWR clknet_1_0__leaf_net153
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net164 clknet_0_net164 VGND VGND VPWR VPWR clknet_1_0__leaf_net164
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c594_A3 clknet_1_0__leaf_net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net186 clknet_0_net186 VGND VGND VPWR VPWR clknet_1_0__leaf_net186
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c457_S1 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c115_A2 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input4_X net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c473_S0 net679 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s944_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_94_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c367_S1 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c695_A2 net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c216_A1 net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net164_X clknet_1_1__leaf_net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c232_A0 net30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c589_A3 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c468_S0 clknet_1_1__leaf_net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c126_A1 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc92 net25 net989 VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__and2b_1
Xc70 net2 net938 net13 VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__mux2_2
Xc81 net19 net923 net22 net1053 net1057 net26 VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__mux4_2
XFILLER_0_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s903_GATE_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_net308 net308 VGND VGND VPWR VPWR clknet_0_net308 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc709 clknet_1_1__leaf_net377 clknet_1_1__leaf_net553 net480 clknet_1_1__leaf_net814
+ net887 net888 VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__mux4_2
XFILLER_0_24_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c470_S1 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_10_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c303_A2 net1062 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_81_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_2 net516 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c213_A2 net1081 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_65_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout157_A net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout112_X net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc528 net351 net1011 net1050 net823 net1042 net827 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__mux4_4
Xc539 clknet_1_0__leaf_net447 net351 net1050 clknet_1_0__leaf_net450 net211 net344
+ VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__mux4_2
XANTENNA_c465_S1 net778 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c481_S0 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput61 clknet_1_1__leaf_net968 VGND VGND VPWR VPWR out19 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c357_RESET_B net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput83 clknet_1_1__leaf_net990 VGND VGND VPWR VPWR out4 sky130_fd_sc_hd__clkbuf_1
Xoutput72 net1023 VGND VGND VPWR VPWR out29 sky130_fd_sc_hd__buf_2
Xoutput94 net1001 VGND VGND VPWR VPWR out50 sky130_fd_sc_hd__buf_2
Xmerge764_1 net733 VGND VGND VPWR VPWR net1068 sky130_fd_sc_hd__clkinv_8
XFILLER_0_37_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c330_B1 clknet_1_0__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c391_S0 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c687_A3 net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net505 clknet_0_net505 VGND VGND VPWR VPWR clknet_1_0__leaf_net505
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c582_SCD clknet_1_1__leaf_net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net538 clknet_0_net538 VGND VGND VPWR VPWR clknet_1_0__leaf_net538
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c208_A2 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c505_A0 net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c597_A3 net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net290 clknet_0_net290 VGND VGND VPWR VPWR clknet_1_1__leaf_net290
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc303 net1030 net1062 net121 net1043 clknet_1_0__leaf_net813 VGND VGND VPWR VPWR net250
+ sky130_fd_sc_hd__a41oi_1
XFILLER_0_20_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc336 net11 clknet_1_1__leaf_net254 net972 clknet_1_0__leaf_net281 VGND VGND VPWR
+ VPWR net284 sky130_fd_sc_hd__a31oi_2
Xc314 net103 net260 net106 net1007 clknet_1_1__leaf_net250 net1063 VGND VGND VPWR
+ VPWR net261 sky130_fd_sc_hd__mux4_2
Xc325 net262 clknet_1_0__leaf_net263 net1093 net1007 net1015 clknet_1_0__leaf_net734
+ VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__mux4_1
XFILLER_0_60_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc358 net301 net972 clknet_1_1__leaf_net304 net1026 net151 VGND VGND VPWR VPWR net308
+ sky130_fd_sc_hd__a41oi_2
Xc369 clknet_1_1__leaf_net313 clknet_1_1__leaf_net314 net316 net267 net1001 net819
+ VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__mux4_4
Xc347 net151 clknet_1_1__leaf_net153 clknet_1_0__leaf_net295 net285 net759 net764
+ VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__mux4_4
XFILLER_0_99_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c173_Q net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_86_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge802 clknet_4_10_0_clk net48 net49 VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__dfstp_1
XFILLER_0_23_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge824 net641 net640 VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__xnor2_4
Xmerge835 clknet_4_7_0_clk net581 net508 VGND VGND VPWR VPWR net739 net738 sky130_fd_sc_hd__dfrbp_2
Xmerge846 net167 clknet_4_10_0_clk net73 VGND VGND VPWR VPWR net751 net750 sky130_fd_sc_hd__dlrbn_1
Xmerge813 net546 net331 VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__xnor2_1
Xs952 net572 clknet_4_5_0_clk VGND VGND VPWR VPWR net878 net877 sky130_fd_sc_hd__dlxbp_1
Xs941 net510 clknet_4_15_0_clk VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xs930 clknet_4_14_0_clk net425 VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_55_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge857 clknet_4_12_0_clk net705 net702 VGND VGND VPWR VPWR net763 net762 sky130_fd_sc_hd__edfxbp_1
Xmerge868 clknet_4_6_0_clk net468 net683 VGND VGND VPWR VPWR net774 net773 sky130_fd_sc_hd__dfsbp_2
Xs963 clknet_4_7_0_clk net604 VGND VGND VPWR VPWR net891 sky130_fd_sc_hd__dlclkp_1
Xs974 clknet_4_13_0_clk net645 VGND VGND VPWR VPWR net906 net905 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_70_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer5 net722 VGND VGND VPWR VPWR net1080 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c386_S0 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output70_A net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c210_A3 net1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net313 clknet_0_net313 VGND VGND VPWR VPWR clknet_1_0__leaf_net313
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net357 clknet_0_net357 VGND VGND VPWR VPWR clknet_1_0__leaf_net357
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c553_SET_B net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c69_B1_N net1053 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout103 net986 VGND VGND VPWR VPWR net1010 sky130_fd_sc_hd__clkbuf_4
Xfanout147 net953 VGND VGND VPWR VPWR net1054 sky130_fd_sc_hd__clkbuf_8
Xfanout114 net103 VGND VGND VPWR VPWR net1021 sky130_fd_sc_hd__clkbuf_4
Xfanout136 net812 VGND VGND VPWR VPWR net1043 sky130_fd_sc_hd__clkbuf_4
Xfanout125 net981 VGND VGND VPWR VPWR net1032 sky130_fd_sc_hd__clkbuf_4
Xfanout158 net919 VGND VGND VPWR VPWR net1065 sky130_fd_sc_hd__buf_4
XANTENNA_c743_S1 net787 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c264_X net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net891 clknet_0_net891 VGND VGND VPWR VPWR clknet_1_0__leaf_net891
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge783_CLK_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc111 net1065 net58 net26 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__o21bai_1
Xc100 net945 net44 net43 net1053 net16 net45 VGND VGND VPWR VPWR net986 sky130_fd_sc_hd__mux4_2
XFILLER_0_60_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc133 net921 net1065 net1052 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__a21o_2
Xc122 net737 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__clkinv_8
XANTENNA_c145_B1 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc144 net1052 net910 net88 net1065 net1022 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__a41o_1
Xc177 net12 net11 net10 net84 net107 net918 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__mux4_1
Xc155 net90 net936 net1063 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__o21bai_4
Xc166 net927 net104 net1058 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__a21o_1
Xc199 net745 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__clkbuf_1
Xc188 net119 net133 net1038 net1063 net132 net1009 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__mux4_1
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c205_A3 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c502_A1 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c221_A2 net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net165 clknet_0_net165 VGND VGND VPWR VPWR clknet_1_0__leaf_net165
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net176 clknet_0_net176 VGND VGND VPWR VPWR clknet_1_0__leaf_net176
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_clkbuf_1_0__f_net965_X clknet_1_0__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net198 clknet_0_net198 VGND VGND VPWR VPWR clknet_1_0__leaf_net198
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net187 clknet_0_net187 VGND VGND VPWR VPWR clknet_1_0__leaf_net187
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_34_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_50_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge871_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c754_S0 net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c473_S1 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c131_A2 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_83_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge862_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s880_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c383_S1 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c695_A3 net881 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c293_S1 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout142_X net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c749_S0 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c86_S1 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c407_A1 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c468_S1 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc60 net2 net4 net3 net6 net1055 net947 VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__mux4_2
Xc93 net955 net37 net1029 net1059 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__a31oi_4
Xc82 net24 net25 net28 net16 net26 net21 VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__mux4_2
Xc71 net944 net1048 net1058 net13 net16 net1055 VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__mux4_2
XFILLER_0_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c317_A1 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c337_SET_B clknet_1_0__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge835_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c333_B1 clknet_1_0__leaf_net794 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net631 clknet_0_net631 VGND VGND VPWR VPWR clknet_1_1__leaf_net631
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net620 clknet_0_net620 VGND VGND VPWR VPWR clknet_1_1__leaf_net620
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net653 clknet_0_net653 VGND VGND VPWR VPWR clknet_1_1__leaf_net653
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_60_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c227_A1 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout102_A net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c396_B net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net832 net832 VGND VGND VPWR VPWR clknet_0_net832 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c137_A1 net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_91_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c303_A3 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input32_A in37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c600_A1 clknet_1_0__leaf_net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_11_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_100_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c389_S0 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_20_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net461 clknet_0_net461 VGND VGND VPWR VPWR clknet_1_1__leaf_net461
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net472 clknet_0_net472 VGND VGND VPWR VPWR clknet_1_1__leaf_net472
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net450 clknet_0_net450 VGND VGND VPWR VPWR clknet_1_1__leaf_net450
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_1_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net494 clknet_0_net494 VGND VGND VPWR VPWR clknet_1_1__leaf_net494
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_65_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_77_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout105_X net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc529 net228 net698 VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c404_A2 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c559_X net473 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c420_A1 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c481_S1 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c148_A0 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c52_Y net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput84 net991 VGND VGND VPWR VPWR out41 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c314_A2 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput62 clknet_1_1__leaf_net969 VGND VGND VPWR VPWR out2 sky130_fd_sc_hd__clkbuf_1
Xoutput73 clknet_1_1__leaf_net980 VGND VGND VPWR VPWR out3 sky130_fd_sc_hd__clkbuf_1
Xoutput95 net1002 VGND VGND VPWR VPWR out51 sky130_fd_sc_hd__buf_2
XANTENNA_c611_A0 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c391_S1 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c208_A3 net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c224_A2 clknet_1_1__leaf_net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c147_Y net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s914_Q net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc315 net108 net122 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__xor2_1
Xc326 net255 net997 net1093 net1007 net1062 net753 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__mux4_4
Xc304 net242 clknet_1_0__leaf_net250 net1045 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__o21ai_1
Xc337 clknet_4_9_0_clk net268 net106 net1020 clknet_1_0__leaf_net281 clknet_1_0__leaf_net794
+ VGND VGND VPWR VPWR net286 net285 sky130_fd_sc_hd__sdfbbp_1
Xc359 clknet_1_1__leaf_net304 clknet_1_0__leaf_net308 clknet_1_1__leaf_net795 net803
+ net1044 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__a41oi_2
Xc348 net1016 net1092 clknet_1_0__leaf_net271 net1038 net1080 net816 VGND VGND VPWR
+ VPWR net297 sky130_fd_sc_hd__mux4_1
XANTENNA_c476_S1 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c492_S0 clknet_1_1__leaf_net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c431_A0 net946 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c150_A1 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge803 net661 net115 VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__xor2_1
XFILLER_0_95_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge836 clknet_4_15_0_clk net549 net718 VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__dfrtn_1
XFILLER_0_23_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge825 net541 net419 VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__xor2_1
Xmerge814 net545 net432 VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__xnor2_4
Xs942 clknet_4_6_0_clk net518 VGND VGND VPWR VPWR net864 net863 sky130_fd_sc_hd__dfxbp_1
Xmerge858 clknet_4_10_0_clk net292 net72 VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__edfxtp_1
Xmerge847 net687 clknet_4_2_0_clk net690 VGND VGND VPWR VPWR net753 net752 sky130_fd_sc_hd__dlrbn_1
Xs920 net392 clknet_4_3_0_clk VGND VGND VPWR VPWR net838 net837 sky130_fd_sc_hd__dlxbp_1
XFILLER_0_55_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs931 clknet_4_14_0_clk net429 VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__dlclkp_1
Xmerge869 clknet_4_12_0_clk net473 net726 VGND VGND VPWR VPWR net776 net775 sky130_fd_sc_hd__dfsbp_2
Xs964 clknet_4_7_0_clk net605 VGND VGND VPWR VPWR net892 sky130_fd_sc_hd__dlclkp_2
Xs975 clknet_4_15_0_clk net650 VGND VGND VPWR VPWR net908 net907 sky130_fd_sc_hd__dfxbp_1
Xs953 net575 clknet_4_5_0_clk VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__dlxtn_2
XANTENNA_c309_A2 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c606_A0 clknet_1_1__leaf_net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer6 net6 VGND VGND VPWR VPWR net1091 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output63_A net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net314 clknet_0_net314 VGND VGND VPWR VPWR clknet_1_0__leaf_net314
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_47_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c235_A1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout104 net339 VGND VGND VPWR VPWR net1011 sky130_fd_sc_hd__buf_4
Xfanout115 net92 VGND VGND VPWR VPWR net1022 sky130_fd_sc_hd__buf_4
Xfanout137 net983 VGND VGND VPWR VPWR net1044 sky130_fd_sc_hd__clkbuf_4
Xfanout159 net919 VGND VGND VPWR VPWR net1066 sky130_fd_sc_hd__clkbuf_2
Xfanout148 net948 VGND VGND VPWR VPWR net1055 sky130_fd_sc_hd__clkbuf_4
XANTENNA_s956_GATE clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net870 clknet_0_net870 VGND VGND VPWR VPWR clknet_1_0__leaf_net870
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net892 clknet_0_net892 VGND VGND VPWR VPWR clknet_1_0__leaf_net892
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c426_A0 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc101 clknet_4_8_0_clk net43 net39 net42 net1047 net1010 VGND VGND VPWR VPWR net47
+ net46 sky130_fd_sc_hd__sdfbbn_2
XANTENNA_c487_S0 net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc112 net58 net1023 net989 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__o21a_2
Xc123 net63 net70 net68 net58 net1066 net989 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__mux4_1
XANTENNA_c145_A1 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc145 net91 net90 net86 net1022 net1019 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__a41oi_4
Xc134 net141 net1052 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__and2b_2
Xc178 net928 net106 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__and2_2
Xc167 net83 net113 net934 net108 net110 net94 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__mux4_1
Xc156 net100 net958 net935 net1058 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__a31oi_4
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc189 net132 net922 net131 net1039 net928 net769 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__mux4_2
XANTENNA_c161_A0 net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_99_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc690 net228 net465 net480 net672 net739 net881 VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__mux4_2
XPHY_EDGE_ROW_3_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c502_A2 net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c221_A3 net1059 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net199 clknet_0_net199 VGND VGND VPWR VPWR clknet_1_0__leaf_net199
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout132_A net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c246_B1 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c754_S1 net853 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c412_A2 net1049 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_67_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c156_B1 net1058 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_94_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c306_A3 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_76_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c552_SET_B net1067 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c207_SCD net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net813 clknet_0_net813 VGND VGND VPWR VPWR clknet_1_1__leaf_net813
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c407_A2 net1050 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c423_A1 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c484_S1 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc61 net951 net1028 net947 net936 net922 net8 VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__mux4_2
Xc94 net16 net39 net1029 VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__mux2_1
Xc83 net5 net22 net26 net25 net1048 net16 VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__mux4_2
Xc72 net938 net5 net1028 net1091 net1026 VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__a41o_1
XFILLER_0_85_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c333_A1 net0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_60_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c243_A1 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c479_S1 net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c495_S0 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c434_B1 net679 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c153_A1 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c303_A4 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input25_A in30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c600_A2 net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge855_Q net760 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net462 clknet_0_net462 VGND VGND VPWR VPWR clknet_1_1__leaf_net462
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_1_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c238_A1 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c404_A3 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c420_A2 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput63 net970 VGND VGND VPWR VPWR out20 sky130_fd_sc_hd__clkbuf_4
Xoutput85 net992 VGND VGND VPWR VPWR out42 sky130_fd_sc_hd__buf_2
XANTENNA_c314_A3 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput74 net1032 VGND VGND VPWR VPWR out30 sky130_fd_sc_hd__buf_2
Xoutput96 net1003 VGND VGND VPWR VPWR out6 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c330_A2 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net529 clknet_0_net529 VGND VGND VPWR VPWR clknet_1_0__leaf_net529
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c505_A2 net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
.ends
