* NGSPICE file created from netlist_1.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_4 abstract view
.subckt sky130_fd_sc_hd__mux4_4 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_2 abstract view
.subckt sky130_fd_sc_hd__dlrtp_2 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_2 abstract view
.subckt sky130_fd_sc_hd__dlclkp_2 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_4 abstract view
.subckt sky130_fd_sc_hd__dlclkp_4 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbp_1 abstract view
.subckt sky130_fd_sc_hd__dlrbp_1 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_2 abstract view
.subckt sky130_fd_sc_hd__dlxtn_2 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_1 abstract view
.subckt sky130_fd_sc_hd__dfxbp_1 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_2 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_2 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbp_1 CLK D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q
+ Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_0 abstract view
.subckt sky130_fd_sc_hd__a21boi_0 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_1 abstract view
.subckt sky130_fd_sc_hd__a41oi_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_4 abstract view
.subckt sky130_fd_sc_hd__a41oi_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_1 abstract view
.subckt sky130_fd_sc_hd__dlxtn_1 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_1 abstract view
.subckt sky130_fd_sc_hd__dlxbn_1 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_4 abstract view
.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_1 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_2 abstract view
.subckt sky130_fd_sc_hd__a41o_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbp_2 abstract view
.subckt sky130_fd_sc_hd__dlrbp_2 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxbp_1 abstract view
.subckt sky130_fd_sc_hd__edfxbp_1 CLK D DE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_1 abstract view
.subckt sky130_fd_sc_hd__dfsbp_1 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtp_1 abstract view
.subckt sky130_fd_sc_hd__dlxtp_1 D GATE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_4 abstract view
.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_2 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_2 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_2 abstract view
.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxtp_1 abstract view
.subckt sky130_fd_sc_hd__edfxtp_1 CLK D DE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbp_1 abstract view
.subckt sky130_fd_sc_hd__dlxbp_1 D GATE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__lpflow_inputisolatch_1 abstract view
.subckt sky130_fd_sc_hd__lpflow_inputisolatch_1 D SLEEP_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_2 abstract view
.subckt sky130_fd_sc_hd__a41oi_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_2 abstract view
.subckt sky130_fd_sc_hd__dfstp_2 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_1 abstract view
.subckt sky130_fd_sc_hd__dlclkp_1 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_2 abstract view
.subckt sky130_fd_sc_hd__dfxbp_2 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_16 abstract view
.subckt sky130_fd_sc_hd__buf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_1 abstract view
.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_4 abstract view
.subckt sky130_fd_sc_hd__a41o_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_8 abstract view
.subckt sky130_fd_sc_hd__mux2_8 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_2 abstract view
.subckt sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_2 abstract view
.subckt sky130_fd_sc_hd__dlxbn_2 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_2 abstract view
.subckt sky130_fd_sc_hd__dfsbp_2 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfstp_1 abstract view
.subckt sky130_fd_sc_hd__sdfstp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_2 abstract view
.subckt sky130_fd_sc_hd__dfrbp_2 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfsbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfsbp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_2 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_4 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_4 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtn_1 abstract view
.subckt sky130_fd_sc_hd__dfrtn_1 CLK_N D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_4 abstract view
.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_4 abstract view
.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtn_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtn_1 CLK_N D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_4 abstract view
.subckt sky130_fd_sc_hd__dfstp_4 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_4 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_4 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_2 abstract view
.subckt sky130_fd_sc_hd__dlrtn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_1 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_1 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_4 abstract view
.subckt sky130_fd_sc_hd__dlrtn_4 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_1 abstract view
.subckt sky130_fd_sc_hd__dlrtn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_4 abstract view
.subckt sky130_fd_sc_hd__dlrtp_4 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfrbp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_4 abstract view
.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_2 abstract view
.subckt sky130_fd_sc_hd__dlrbn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_1 abstract view
.subckt sky130_fd_sc_hd__dlrbn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_1 abstract view
.subckt sky130_fd_sc_hd__dlrtp_1 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

.subckt netlist_1 VGND VPWR clk in0 in1 in10 in11 in12 in13 in14 in15 in16 in17 in18
+ in19 in2 in20 in21 in22 in23 in24 in25 in26 in27 in28 in29 in3 in30 in31 in32 in33
+ in34 in35 in36 in37 in38 in39 in4 in40 in41 in42 in43 in44 in45 in46 in47 in48 in49
+ in5 in50 in51 in52 in53 in54 in55 in56 in57 in58 in59 in6 in60 in61 in7 in8 in9
+ out0 out1 out10 out11 out12 out13 out14 out15 out16 out17 out18 out19 out2 out20
+ out21 out22 out23 out24 out25 out26 out27 out28 out29 out3 out30 out31 out32 out33
+ out34 out35 out36 out37 out38 out39 out4 out40 out41 out42 out43 out44 out45 out46
+ out47 out48 out49 out5 out50 out51 out52 out53 out54 out55 out56 out57 out58 out59
+ out6 out60 out61 out7 out8 out9 rst
XFILLER_0_94_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout162_A net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c249_B1 net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net766_X clknet_1_1__leaf_net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s899_GATE_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc327 net2 net246 net228 c327/A3 net725 net757 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__mux4_1
Xc316 clknet_1_0__leaf_net242 net880 net113 net200 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__a31oi_1
XFILLER_0_13_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s907_Q net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc305 net237 net225 net238 net993 net990 net778 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__mux4_4
Xc338 net1034 net268 net83 net996 net741 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__a41o_1
XFILLER_0_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc349 clknet_1_0__leaf_net280 net126 net272 net989 net713 net767 VGND VGND VPWR VPWR
+ net282 sky130_fd_sc_hd__mux4_1
XANTENNA_c134_A3 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c712_A0 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c431_A1 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c150_A2 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge815 net504 net632 VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__xor2_4
Xmerge826 net691 clknet_4_2_0_clk net376 VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__dlrtp_2
Xs910 clknet_4_9_0_clk net372 VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__dlclkp_2
Xmerge804 net400 net419 VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__xnor2_2
Xmerge837 clknet_4_12_0_clk net681 net281 VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__dfrtp_2
Xs943 clknet_4_2_0_clk net572 VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__dlclkp_4
Xmerge848 net683 clknet_4_8_0_clk net662 VGND VGND VPWR VPWR net732 net731 sky130_fd_sc_hd__dlrbp_1
Xs932 net463 clknet_4_1_0_clk VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__dlxtn_2
Xs921 clknet_4_11_0_clk net397 VGND VGND VPWR VPWR net931 net817 sky130_fd_sc_hd__dfxbp_1
Xmerge859 clknet_4_14_0_clk net192 net412 VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__sdlclkp_2
Xs954 clknet_4_8_0_clk net617 VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net471 net471 VGND VGND VPWR VPWR clknet_0_net471 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c606_A1 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c622_A0 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c341_A1 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_47_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c577_S1 net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout138 net425 VGND VGND VPWR VPWR net998 sky130_fd_sc_hd__clkbuf_4
Xfanout127 net360 VGND VGND VPWR VPWR net987 sky130_fd_sc_hd__buf_2
Xfanout149 net108 VGND VGND VPWR VPWR net1009 sky130_fd_sc_hd__buf_4
XFILLER_0_38_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout165_X net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c707_A0 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c426_A1 net861 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc102 net26 net12 net34 VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__o21ba_1
Xc124 clknet_4_15_0_clk net52 net58 net1068 net963 net1003 VGND VGND VPWR VPWR net60
+ net59 sky130_fd_sc_hd__sdfbbp_1
Xc113 net11 net896 net914 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__a21boi_0
Xc135 net906 net69 net870 net872 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__a31oi_4
Xc157 net689 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__clkinv_4
Xc168 net107 net87 net68 net1009 net1011 net1043 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__mux4_2
Xc146 net69 net76 net73 net906 net1015 net868 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__mux4_1
Xc179 net874 net126 net108 net110 net900 net905 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__mux4_2
XANTENNA_c442_A0 net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c161_A1 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c617_A0 net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c336_A1 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c352_A0 net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc680 clknet_1_0__leaf_net544 net540 clknet_1_1__leaf_net545 clknet_1_0__leaf_net547
+ net549 VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__a41oi_1
Xc691 net453 net980 net538 net1049 net979 net829 VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__mux4_4
XFILLER_0_75_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c221_A4 net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s938_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net156 clknet_0_net156 VGND VGND VPWR VPWR clknet_1_0__leaf_net156
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net145 clknet_0_net145 VGND VGND VPWR VPWR clknet_1_0__leaf_net145
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c588_S0 net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout125_A net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_6_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c112_A net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c262_A0 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input55_A in58 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c172_B1 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c207_SCE net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c322_A3 net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net803 clknet_0_net803 VGND VGND VPWR VPWR clknet_1_1__leaf_net803
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s946_GATE clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c257_A0 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c685_SCE net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input2_X net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc84 net6 net896 net919 net903 net9 VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__a41oi_4
Xc73 net910 net7 net1036 VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__o21ai_4
Xc62 net867 net884 net902 net2 net909 net1037 VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__mux4_2
XFILLER_0_97_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc95 net12 net14 net17 VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__a21boi_2
XFILLER_0_97_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c317_A3 net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xwire144 net341 VGND VGND VPWR VPWR net1004 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_33_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c428_SCE net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c691_S0 net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_60_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c585_S1 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c243_A2 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_68_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c106_S0 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net801 net801 VGND VGND VPWR VPWR clknet_0_net801 sky130_fd_sc_hd__clkbuf_16
XANTENNA_s937_Q net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_223 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c137_A3 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c715_A0 net550 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c153_A2 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c450_A0 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input18_A in24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c609_A1 net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c328_A2 net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c360_A0 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net485 clknet_0_net485 VGND VGND VPWR VPWR clknet_1_1__leaf_net485
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net496 clknet_0_net496 VGND VGND VPWR VPWR clknet_1_1__leaf_net496
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_37_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net766_X clknet_1_0__leaf_net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c596_S0 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c254_A1 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c121_CLK_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c63_A0 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput64 net924 VGND VGND VPWR VPWR out1 sky130_fd_sc_hd__buf_2
Xoutput75 clknet_1_0__leaf_net935 VGND VGND VPWR VPWR out2 sky130_fd_sc_hd__clkbuf_1
Xoutput86 net946 VGND VGND VPWR VPWR out31 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput97 clknet_1_1__leaf_net957 VGND VGND VPWR VPWR out41 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c180_B1 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c611_A2 net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c330_A3 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net519 clknet_0_net519 VGND VGND VPWR VPWR clknet_1_0__leaf_net519
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c339_A1 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c355_A0 net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold26_A net757 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net293 clknet_0_net293 VGND VGND VPWR VPWR clknet_1_1__leaf_net293
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c249_A1 net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_8_0_clk_X clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c265_B1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc317 clknet_1_1__leaf_net242 net246 clknet_1_0__leaf_net245 net996 net648 net757
+ VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__mux4_2
Xc306 net238 net236 net104 net101 net234 net652 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__mux4_1
Xc339 net885 net263 net914 net767 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__a31oi_2
Xc328 clknet_1_1__leaf_net245 net105 net901 clknet_1_0__leaf_net249 net705 net725
+ VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__mux4_4
XFILLER_0_13_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c712_A1 net554 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c431_A2 net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c150_A3 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c159_A1 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge827 net179 net273 VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__xnor2_1
Xmerge805 net421 net639 VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__xor2_2
Xmerge816 net480 net654 VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__xor2_4
Xs900 net302 clknet_4_14_0_clk VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__dlxtn_2
Xs933 net466 clknet_4_3_0_clk VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__dlxtn_1
Xmerge849 net687 net506 VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__xor2_1
Xs922 clknet_4_9_0_clk net402 VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__dfxtp_1
Xs911 clknet_4_6_0_clk net373 VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__dlclkp_4
Xmerge838 clknet_4_9_0_clk net396 net382 VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__dfrtp_4
Xs955 clknet_4_10_0_clk net629 VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__dfxtp_2
Xs944 net575 clknet_4_8_0_clk VGND VGND VPWR VPWR net845 net844 sky130_fd_sc_hd__dlxbn_1
XTAP_TAPCELL_ROW_11_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c341_A2 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_74_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c593_S1 net710 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c532_A1 net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout139 net927 VGND VGND VPWR VPWR net999 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_85_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c145_X net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c707_A1 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c426_A2 net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc103 net914 net12 net896 net27 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__a31o_2
Xc114 net871 net896 net43 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__o21bai_4
Xc125 net60 net958 net55 net58 net11 net56 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__mux4_1
Xc136 net866 net872 net70 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__a21o_4
Xc158 net69 net102 net90 net100 net109 net1009 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__mux4_1
Xc169 net878 net101 net1009 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__mux2_2
Xc147 net1015 net71 net1006 net863 net1035 net1011 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__mux4_2
XANTENNA_s892_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c442_A1 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s915_GATE_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c617_A1 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net280 net280 VGND VGND VPWR VPWR clknet_0_net280 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c336_A2 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge770_A0 net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge865_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc681 net551 clknet_1_0__leaf_net547 clknet_1_0__leaf_net544 net1007 net1049 net709
+ VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__mux4_4
Xc670 clknet_4_0_0_clk net1018 net537 net314 net980 net1061 VGND VGND VPWR VPWR net540
+ net539 sky130_fd_sc_hd__sdfbbn_1
Xc692 net429 net453 net467 net557 net549 net1022 VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__mux4_1
XFILLER_0_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c112_B net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge856_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_s874_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c156_A2 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c453_A0 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input48_A in51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c603_A3 net734 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s898_GATE clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge765_B1 net690 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c689_S0 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge838_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c599_S0 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge829_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c412_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c720_A1 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc63 net911 net908 net916 net904 net901 net884 VGND VGND VPWR VPWR net0 sky130_fd_sc_hd__mux4_2
Xc74 net10 net874 net910 VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__mux2_4
Xc85 net18 net19 net13 VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__a21oi_1
Xc96 net1039 net26 net10 VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__o21bai_2
XANTENNA_c427_CLK_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_26_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c448_A0 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c68_Y net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c183_B1 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c614_A2 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net623 clknet_0_net623 VGND VGND VPWR VPWR clknet_1_1__leaf_net623
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c358_A0 net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c212_S0 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c227_A4 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net711_X clknet_1_0__leaf_net711 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_9_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout140_X net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net802 net802 VGND VGND VPWR VPWR clknet_0_net802 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_1_1__f_net956_X clknet_1_1__leaf_net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c137_A4 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c291_SCD net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c731_A0 net549 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold20 net700 VGND VGND VPWR VPWR net1065 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c450_A1 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c178_A0 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c625_A1 net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c686_S1 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_4_0_clk_X clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c175_X net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c420_A4 net757 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c429_A2 net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net621 net621 VGND VGND VPWR VPWR clknet_0_net621 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c445_A1 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput65 clknet_1_0__leaf_net925 VGND VGND VPWR VPWR out10 sky130_fd_sc_hd__clkbuf_1
Xoutput76 net936 VGND VGND VPWR VPWR out20 sky130_fd_sc_hd__buf_2
Xoutput98 net958 VGND VGND VPWR VPWR out42 sky130_fd_sc_hd__clkbuf_4
XANTENNA_merge868_Q_N net754 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput87 net947 VGND VGND VPWR VPWR out32 sky130_fd_sc_hd__buf_2
XANTENNA_input30_A in35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c611_A3 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c339_A2 net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c636_A0 clknet_1_0__leaf_net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_42_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c697_S0 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c355_A1 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net294 clknet_0_net294 VGND VGND VPWR VPWR clknet_1_1__leaf_net294
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_99_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout148_A net533 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c421_D net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc307 net237 net652 net685 net778 net779 VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__a41o_2
Xc318 net1038 net705 clknet_1_0__leaf_net711 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__mux2_1
XFILLER_0_13_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c415_A4 net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc329 net91 net911 net235 net1036 net705 net737 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__mux4_2
XANTENNA_c281_A0 net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c292_X net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c557_X net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge817 merge817/D clknet_4_7_0_clk net664 VGND VGND VPWR VPWR net97 net696 sky130_fd_sc_hd__dlrbp_2
Xmerge828 clknet_4_0_0_clk net546 net562 VGND VGND VPWR VPWR net709 net708 sky130_fd_sc_hd__edfxbp_1
Xmerge806 net497 net499 VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__xnor2_2
Xs901 net303 clknet_4_14_0_clk VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__dlxtn_2
XFILLER_0_95_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge839 clknet_4_3_0_clk net580 net655 VGND VGND VPWR VPWR net720 net719 sky130_fd_sc_hd__dfsbp_1
Xs934 net472 clknet_4_3_0_clk VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__dlxtp_1
Xs923 clknet_4_11_0_clk net405 VGND VGND VPWR VPWR net819 sky130_fd_sc_hd__dfxtp_4
Xs912 net375 clknet_4_9_0_clk VGND VGND VPWR VPWR net805 net804 sky130_fd_sc_hd__dlxbn_1
XANTENNA_c88_A net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs945 net578 clknet_4_2_0_clk VGND VGND VPWR VPWR net847 net846 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_36_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c310_S0 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c606_A3 net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c622_A2 clknet_1_0__leaf_net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout129 net938 VGND VGND VPWR VPWR net989 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c532_A2 net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c276_A0 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c707_A2 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c426_A3 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc104 net34 net36 net33 VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__a21boi_2
Xc126 net24 net58 net59 net54 net53 net663 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__mux4_1
Xc115 net1036 net24 net917 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__o21ai_1
XFILLER_0_60_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc159 net88 net993 net101 net89 net1016 net999 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__mux4_2
Xc148 net76 net906 net73 net1015 net71 net67 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__mux4_1
Xc137 net864 net1018 net1035 net1043 net71 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__a41oi_4
XFILLER_0_34_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c305_S0 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c186_A0 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c617_A2 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c336_A3 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge770_A1 net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_12_0_clk_X clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c352_A2 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc660 net1018 net1025 net826 VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__a21boi_4
Xc682 clknet_4_0_0_clk clknet_1_1__leaf_net545 net979 net315 net868 net1060 VGND VGND
+ VPWR VPWR net554 net553 sky130_fd_sc_hd__sdfbbp_1
Xc671 net537 net209 net539 net538 net979 net530 VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__mux4_4
Xc693 clknet_4_0_0_clk net467 net1062 net553 clknet_1_0__leaf_net563 net1035 VGND
+ VGND VPWR VPWR net567 net566 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_91_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net147 clknet_0_net147 VGND VGND VPWR VPWR clknet_1_0__leaf_net147
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net125 clknet_0_net125 VGND VGND VPWR VPWR clknet_1_0__leaf_net125
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c246_A3 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c543_A1 net309 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c125_S0 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c156_A3 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c734_A0 net550 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_36_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c172_A2 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_45_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c628_A1 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c679_SCD net309 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c347_A2 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_54_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c363_A1 net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc490 net386 net161 net950 net692 clknet_1_0__leaf_net939 net819 VGND VGND VPWR VPWR
+ net408 sky130_fd_sc_hd__mux4_4
XPHY_EDGE_ROW_63_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_0__f_net956_X clknet_1_0__leaf_net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_72_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c599_S1 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout130_A net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c108_Y net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c720_A2 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc64 net889 net916 net934 net901 net0 net907 VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__mux4_2
Xc75 net895 net5 net3 net10 net905 net915 VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__mux4_2
Xc86 net3 net18 net20 net10 net11 net15 VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__mux4_2
Xc97 net948 net30 net973 VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__a21bo_2
XTAP_TAPCELL_ROW_26_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_90_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c664_B1_N net734 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c183_A1 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input60_A in7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net613 clknet_0_net613 VGND VGND VPWR VPWR clknet_1_1__leaf_net613
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c630_A2 net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c194_B1_N net696 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c358_A1 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_60_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout178_A net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net803 net803 VGND VGND VPWR VPWR clknet_0_net803 sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout133_X net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_0_0_clk_X clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c284_B1 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c291_SCE net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c731_A1 net750 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold21 net235 VGND VGND VPWR VPWR net1066 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 net336 VGND VGND VPWR VPWR net1055 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c95_B1_N net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c178_A1 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c360_A2 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net498 clknet_0_net498 VGND VGND VPWR VPWR clknet_1_1__leaf_net498
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net476 clknet_0_net476 VGND VGND VPWR VPWR clknet_1_1__leaf_net476
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_37_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c369_A0 net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c238_A4 net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c551_A1 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c335_X net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c429_A3 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c63_A2 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_50_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s910_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c445_A2 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c461_A1 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput66 net983 VGND VGND VPWR VPWR out11 sky130_fd_sc_hd__buf_2
Xoutput88 net948 VGND VGND VPWR VPWR out33 sky130_fd_sc_hd__clkbuf_4
Xoutput99 net959 VGND VGND VPWR VPWR out43 sky130_fd_sc_hd__buf_2
Xoutput77 net995 VGND VGND VPWR VPWR out21 sky130_fd_sc_hd__buf_2
XANTENNA_input23_A in29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c339_A3 net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c355_A2 net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net251 clknet_0_net251 VGND VGND VPWR VPWR clknet_1_1__leaf_net251
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c249_A3 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c265_A2 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc308 net235 net234 net91 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__o21a_1
XFILLER_0_13_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc319 net755 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__clkinv_8
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge818 net627 net694 VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__xor2_4
Xmerge807 net508 net609 VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__xnor2_1
XANTENNA_c74_A1 net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge829 clknet_4_10_0_clk net487 net657 VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__edfxtp_1
Xs902 net327 clknet_4_4_0_clk VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__dlxtp_1
Xs913 net379 clknet_4_3_0_clk VGND VGND VPWR VPWR net807 net806 sky130_fd_sc_hd__dlxbn_1
Xs924 clknet_4_14_0_clk net406 VGND VGND VPWR VPWR net820 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs946 net582 clknet_4_2_0_clk VGND VGND VPWR VPWR net849 net848 sky130_fd_sc_hd__dlxbp_1
XFILLER_0_36_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs935 net473 clknet_4_3_0_clk VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__lpflow_inputisolatch_1
XANTENNA_c456_A1 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c310_S1 net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net485 net485 VGND VGND VPWR VPWR clknet_0_net485 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net496 net496 VGND VGND VPWR VPWR clknet_0_net496 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c90_B1 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c622_A3 net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input26_X net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge768_A1 net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c366_A1 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout119 net440 VGND VGND VPWR VPWR net979 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net841 clknet_0_net841 VGND VGND VPWR VPWR clknet_1_0__leaf_net841
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_s944_GATE_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout160_A net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c557_A0 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c411_S0 net716 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c426_A4 net735 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc127 net26 net58 net41 net53 net54 net59 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__mux4_1
Xc105 net32 net35 net31 net905 net914 net26 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__mux4_2
Xc116 net917 net45 net41 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__a21boi_1
XANTENNA_c292_B1 net949 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc149 net82 net922 net79 net1035 net73 net1001 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__mux4_2
Xc138 net870 net906 net863 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__a21oi_4
XANTENNA_c442_A3 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c186_A1 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net293 net293 VGND VGND VPWR VPWR clknet_0_net293 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_32_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c633_A2 net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c352_A3 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc661 net701 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__inv_6
Xc672 net540 net529 net1007 net1013 clknet_1_0__leaf_net743 VGND VGND VPWR VPWR net542
+ sky130_fd_sc_hd__a41oi_1
Xc683 net979 net992 net531 clknet_1_0__leaf_net552 net467 VGND VGND VPWR VPWR net555
+ sky130_fd_sc_hd__a41o_2
Xc694 net451 net567 net549 net746 net829 clknet_1_0__leaf_net842 VGND VGND VPWR VPWR
+ net568 sky130_fd_sc_hd__mux4_4
XANTENNA_c215_S1 clknet_1_0__leaf_net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net159 clknet_0_net159 VGND VGND VPWR VPWR clknet_1_0__leaf_net159
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout163_X net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c156_A4 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c453_A2 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c172_A3 net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_100_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c628_A2 net718 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c679_SCE net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c347_A3 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c363_A2 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc480 net276 clknet_1_0__leaf_net957 net717 clknet_1_1__leaf_net803 net813 net814
+ VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__mux4_1
Xc491 net39 net176 net936 net996 net31 net949 VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__mux4_2
XFILLER_0_87_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout123_A net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c554_A1 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c273_A2 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc65 net881 net921 net885 net871 net889 net1042 VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__mux4_2
Xc76 net11 net3 net12 VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__a21bo_1
Xc98 net896 net30 net948 net27 net887 VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__a41oi_2
Xc87 net20 net919 net886 net14 net21 net973 VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_26_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net490 clknet_0_net490 VGND VGND VPWR VPWR clknet_1_0__leaf_net490
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_34_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input53_A in56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net636 clknet_0_net636 VGND VGND VPWR VPWR clknet_1_1__leaf_net636
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c540_A3 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c549_A1 net440 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c565_A0 net359 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout126_X net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold22 net55 VGND VGND VPWR VPWR net1067 sky130_fd_sc_hd__dlygate4sd3_1
Xhold11 net747 VGND VGND VPWR VPWR net1056 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c450_A3 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c77_A1 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c459_A1 clknet_1_0__leaf_net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c178_A2 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c475_A0 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c194_A1 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c625_A3 net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input56_X net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c360_A3 clknet_1_1__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c287_Q_N net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c369_A1 net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c254_A4 net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c551_A2 net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net623 net623 VGND VGND VPWR VPWR clknet_0_net623 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c726_A2 net550 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s935_Q net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c461_A2 net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput67 net999 VGND VGND VPWR VPWR out12 sky130_fd_sc_hd__buf_2
XANTENNA_c287_SET_B net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput89 net949 VGND VGND VPWR VPWR out34 sky130_fd_sc_hd__buf_2
Xoutput78 net938 VGND VGND VPWR VPWR out22 sky130_fd_sc_hd__buf_2
XANTENNA_input16_A in22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c636_A2 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_42_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c355_A3 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge846_Q net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c371_A2 clknet_1_1__leaf_net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c218_S1 clknet_1_0__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net296 clknet_0_net296 VGND VGND VPWR VPWR clknet_1_1__leaf_net296
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c249_A4 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c546_A2 net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc309 net105 net91 clknet_1_1__leaf_net711 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__o21a_2
XFILLER_0_13_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input8_A in15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c278_X net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge808 clknet_4_7_0_clk net223 net231 VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__dfstp_2
XFILLER_0_67_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge819 net349 clknet_4_4_0_clk net355 VGND VGND VPWR VPWR net700 net699 sky130_fd_sc_hd__dlrbp_1
XANTENNA_c737_A1 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs914 net380 clknet_4_2_0_clk VGND VGND VPWR VPWR net809 net808 sky130_fd_sc_hd__dlxbp_1
Xs903 net331 clknet_4_0_0_clk VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xs925 clknet_4_11_0_clk net409 VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__dlclkp_1
XFILLER_0_75_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs947 net583 clknet_4_2_0_clk VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__dlxtn_1
Xs936 clknet_4_3_0_clk net477 VGND VGND VPWR VPWR net835 net834 sky130_fd_sc_hd__dfxbp_2
XTAP_TAPCELL_ROW_11_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c456_A2 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s895_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c472_A1 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge768_A2 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_19_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c366_A2 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge868_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold24_A net647 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net842 clknet_0_net842 VGND VGND VPWR VPWR clknet_1_0__leaf_net842
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c557_A1 net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge859_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s877_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c573_B1 net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc106 net35 net1003 net30 net7 net911 net37 VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__mux4_2
Xc117 net689 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_96_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc128 net57 net52 net58 net54 net26 net1052 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__mux4_1
XFILLER_0_79_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc139 net68 net866 net71 net73 net864 net1043 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__mux4_1
XANTENNA_c723_A3 net549 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c467_A1 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net294 net294 VGND VGND VPWR VPWR clknet_0_net294 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c633_A3 net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc662 net701 VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__buf_16
Xc673 net540 net537 net734 clknet_1_0__leaf_net743 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__a31oi_1
Xc695 net531 net556 net557 clknet_1_0__leaf_net561 net566 clknet_1_0__leaf_net841
+ VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__mux4_4
Xc684 net359 net538 net467 net553 net549 net998 VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__mux4_1
XFILLER_0_86_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c393_A0 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c143_X net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c141_S1 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c734_A2 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c453_A3 net982 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c478_A0 clknet_1_1__leaf_net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c628_A3 net738 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c363_A3 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c660_A1 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc470 net276 net126 net986 net755 net775 net806 VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__mux4_1
Xc481 net247 clknet_1_0__leaf_net957 clknet_1_1__leaf_net387 net768 clknet_1_1__leaf_net780
+ net814 VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__mux4_4
XFILLER_0_19_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc492 net126 net989 clknet_1_1__leaf_net407 clknet_1_1__leaf_net956 net791 net819
+ VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__mux4_1
XFILLER_0_59_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c570_A1 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc66 net908 net895 VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__nand2_1
Xc77 net908 net1034 net6 net3 net9 net4 VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__mux4_2
Xc88 net871 net10 VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__nor2b_1
Xc99 net899 net964 net32 net31 VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_26_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c298_B1 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c152_S0 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c167_A4 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c745_A1 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c464_A2 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input46_A in5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c358_A3 net724 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap169_X net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c437_D net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c565_A1 net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout119_X net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c581_A0 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_A3 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold23 net958 VGND VGND VPWR VPWR net1068 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c147_S0 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold12 net346 VGND VGND VPWR VPWR net1057 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge854_GATE clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_39_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c459_A2 net716 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_500 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c421_RESET_B net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c178_A3 net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c756_A0 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c475_A1 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c194_A2 net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c491_A0 net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c551_A3 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_9_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout183_A net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net613 net613 VGND VGND VPWR VPWR clknet_0_net613 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c576_B1 net735 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c295_A1 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c430_S0 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_78_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c592_X net487 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput68 net928 VGND VGND VPWR VPWR out13 sky130_fd_sc_hd__buf_2
Xoutput79 clknet_1_1__leaf_net939 VGND VGND VPWR VPWR out23 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c486_A0 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c636_A3 net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output77_A net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c412_SCD net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net242 clknet_0_net242 VGND VGND VPWR VPWR clknet_1_1__leaf_net242
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net297 clknet_0_net297 VGND VGND VPWR VPWR clknet_1_1__leaf_net297
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net275 clknet_0_net275 VGND VGND VPWR VPWR clknet_1_1__leaf_net275
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c332_SET_B clknet_1_1__leaf_net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c562_A2 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c403_SCD net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge809 net644 net645 VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__xnor2_1
XANTENNA_c438_X net359 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs904 clknet_4_4_0_clk net350 VGND VGND VPWR VPWR net795 net794 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs915 net381 clknet_4_6_0_clk VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__dlxtn_2
XANTENNA_c160_S0 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs948 net589 clknet_4_2_0_clk VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__dlxtn_2
Xs937 clknet_4_3_0_clk net478 VGND VGND VPWR VPWR net837 net836 sky130_fd_sc_hd__dfxbp_2
Xs926 clknet_4_11_0_clk net411 VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__dlclkp_2
XFILLER_0_90_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c456_A3 net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net498 net498 VGND VGND VPWR VPWR clknet_0_net498 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net476 net476 VGND VGND VPWR VPWR clknet_0_net476 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c90_A2 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c472_A2 clknet_1_1__leaf_net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c99_B1 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c335_S0 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge768_A3 net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c366_A3 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net843 clknet_0_net843 VGND VGND VPWR VPWR clknet_1_0__leaf_net843
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net821 clknet_0_net821 VGND VGND VPWR VPWR clknet_1_0__leaf_net821
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_54_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c557_A2 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c286_SET_B net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c573_A1 net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc107 net27 net7 net37 net997 VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__a31oi_4
Xc118 net28 net914 net50 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__a21o_1
XFILLER_0_5_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc129 net60 net51 net53 net663 net759 net762 VGND VGND VPWR VPWR net974 sky130_fd_sc_hd__mux4_2
XANTENNA_c139_S1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c155_S0 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge795_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c85_A2 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c467_A2 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c602_S1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net251 net251 VGND VGND VPWR VPWR clknet_0_net251 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c483_A1 net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc630 net522 clknet_1_1__leaf_net521 net929 net518 net771 net817 VGND VGND VPWR VPWR
+ net523 sky130_fd_sc_hd__mux4_1
Xc663 net529 net1018 net530 net314 net823 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__a41o_1
Xc685 clknet_4_2_0_clk net980 clknet_1_0__leaf_net552 net1007 net873 net1025 VGND
+ VGND VPWR VPWR net558 net557 sky130_fd_sc_hd__sdfbbn_1
Xc674 net542 net529 net539 net1025 net826 VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__a41oi_4
XANTENNA_c679_Q net550 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc696 net343 clknet_1_0__leaf_net568 net531 net566 net1025 clknet_1_0__leaf_net842
+ VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__mux4_2
XANTENNA_c332_Q_N net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c197_B1_N net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge861_D net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c584_A0 net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c96_A1 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_14_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c197_A2 net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c494_A0 net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_23_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c660_A2 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc460 net362 net370 net367 net706 net797 clknet_1_0__leaf_net803 VGND VGND VPWR VPWR
+ net380 sky130_fd_sc_hd__mux4_4
Xc482 net978 net356 clknet_1_1__leaf_net385 net722 net941 net817 VGND VGND VPWR VPWR
+ net401 sky130_fd_sc_hd__mux4_1
Xc471 clknet_1_1__leaf_net275 net246 clknet_1_0__leaf_net957 clknet_1_1__leaf_net387
+ net767 VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__a41o_4
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc493 net29 net403 net928 net990 net1003 net819 VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__mux4_2
XFILLER_0_79_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c669_B1 net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c554_A3 net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_41_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c273_A4 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c570_A2 net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc67 net0 net1036 net867 VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__mux2_8
XPHY_EDGE_ROW_50_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc78 net13 net12 net10 VGND VGND VPWR VPWR net973 sky130_fd_sc_hd__o21ba_2
Xc89 net10 net12 net901 net4 VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__a31oi_2
XTAP_TAPCELL_ROW_26_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net470 clknet_0_net470 VGND VGND VPWR VPWR clknet_1_0__leaf_net470
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_34_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s940_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c608_S0 net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input39_A in43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c327_S1 net757 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net605 clknet_0_net605 VGND VGND VPWR VPWR clknet_1_1__leaf_net605
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net616 clknet_0_net616 VGND VGND VPWR VPWR clknet_1_1__leaf_net616
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c489_A0 clknet_1_1__leaf_net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c685_SET_B net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c671_A1 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc290 net106 net104 net1041 net217 net220 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__a41oi_1
XANTENNA_c237_S1 net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c332_D net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_5_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c565_A2 net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s922_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c581_A1 net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c147_S1 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold13 net779 VGND VGND VPWR VPWR net1058 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 net647 VGND VGND VPWR VPWR net1069 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c459_A3 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c93_A2 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c240_CLK_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s904_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c551_A4 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout176_A net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c576_A1 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net636 net636 VGND VGND VPWR VPWR clknet_0_net636 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout131_X net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c742_A3 net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c158_S0 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput69 net929 VGND VGND VPWR VPWR out14 sky130_fd_sc_hd__buf_2
XANTENNA_c605_S1 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c340_S1 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input61_X net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s933_GATE_N clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c412_SCE net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_6_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c396_A1 net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c562_A3 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c403_SCE net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout179_X net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c737_A3 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs916 net388 clknet_4_9_0_clk VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__dlxtn_2
Xs905 clknet_4_6_0_clk net363 VGND VGND VPWR VPWR net797 net796 sky130_fd_sc_hd__dfxbp_1
XANTENNA_c441_S0 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c160_S1 net696 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs949 net591 clknet_4_2_0_clk VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__dlxtn_2
Xs938 clknet_4_3_0_clk net479 VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__dfxtp_1
Xs927 clknet_4_11_0_clk net415 VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_90_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c472_A3 clknet_1_0__leaf_net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c99_A1 net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input21_A in27 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_13_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c335_S1 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c497_A0 net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c351_S0 net755 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge851_Q net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c663_A2 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_97_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net822 clknet_0_net822 VGND VGND VPWR VPWR clknet_1_0__leaf_net822
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c200_B1 net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c557_A3 net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout139_A net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c573_A2 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc108 net36 net26 net40 net12 net997 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__a41oi_4
XANTENNA_c292_A3 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_96_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc119 net48 net11 net47 net50 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__a31o_1
XFILLER_0_13_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s890_Q net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c467_A3 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net296 net296 VGND VGND VPWR VPWR clknet_0_net296 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c483_A2 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc631 clknet_1_1__leaf_net501 net520 net1045 net934 net812 net837 VGND VGND VPWR VPWR
+ net524 sky130_fd_sc_hd__mux4_4
Xc620 net17 net984 net928 net161 net315 net798 VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__mux4_1
Xc664 net309 net1013 net734 VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__o21bai_4
Xc675 net530 clknet_1_1__leaf_net544 net538 net1007 net1013 VGND VGND VPWR VPWR net545
+ sky130_fd_sc_hd__a41oi_1
Xc697 net315 net429 clknet_1_0__leaf_net570 net566 net1010 clknet_1_1__leaf_net841
+ VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__mux4_4
Xc686 net556 net359 net1044 clknet_1_1__leaf_net552 net1046 net1022 VGND VGND VPWR
+ VPWR net559 sky130_fd_sc_hd__mux4_2
XANTENNA_c346_S0 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input24_X net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_80_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c303_SCD net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c690_A0 net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c568_A2 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c584_A1 net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c750_A3 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c478_A2 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c494_A1 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc472 clknet_1_0__leaf_net275 net1038 clknet_1_1__leaf_net957 clknet_1_0__leaf_net956
+ net798 net805 VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__mux4_1
Xc450 net113 net916 net354 net873 net1004 net1030 VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__mux4_2
Xc461 clknet_1_1__leaf_net374 net234 net103 net797 clknet_1_1__leaf_net802 net805
+ VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__mux4_2
XFILLER_0_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc483 net401 net983 net356 clknet_1_1__leaf_net385 net718 net810 VGND VGND VPWR VPWR
+ net402 sky130_fd_sc_hd__mux4_2
Xc494 net166 net234 clknet_1_1__leaf_net925 net984 net791 net819 VGND VGND VPWR VPWR
+ net411 sky130_fd_sc_hd__mux4_1
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_93_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_1_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc79 net1003 net910 net9 VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__a21o_2
Xc68 net4 net895 net1 VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__a21oi_4
XANTENNA_c714_S0 net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c298_A2 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_26_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c595_A0 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net471 clknet_0_net471 VGND VGND VPWR VPWR clknet_1_0__leaf_net471
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_34_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c464_A4 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c761_A2 net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net606 clknet_0_net606 VGND VGND VPWR VPWR clknet_1_1__leaf_net606
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc280 net86 net210 net206 net209 net994 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__a41oi_1
Xc291 clknet_4_5_0_clk net866 net222 net920 net995 net993 VGND VGND VPWR VPWR net225
+ net224 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_47_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s883_GATE_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge790 clknet_4_4_0_clk merge790/D net340 VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_31_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c581_A2 net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold14 net225 VGND VGND VPWR VPWR net1059 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 net208 VGND VGND VPWR VPWR net1070 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c444_S0 net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c475_A3 net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c491_A2 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input51_A in54 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge831_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c666_A2 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c279_A4 net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c711_S1 net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c576_A2 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c295_A3 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout124_X net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c439_S0 net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c235_Q net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c621_S1 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c486_A2 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c64_X net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input54_X net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net244 clknet_0_net244 VGND VGND VPWR VPWR clknet_1_1__leaf_net244
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net299 clknet_0_net299 VGND VGND VPWR VPWR clknet_1_1__leaf_net299
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_97_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s889_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c706_S1 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c159_X net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs906 clknet_4_9_0_clk net364 VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__dfxtp_4
XANTENNA_c441_S1 net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs928 net441 clknet_4_0_0_clk VGND VGND VPWR VPWR net824 net823 sky130_fd_sc_hd__dlxbn_1
Xs939 clknet_4_8_0_clk net502 VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__dfxtp_1
Xs917 net391 clknet_4_9_0_clk VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_90_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c753_A3 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c108_B1 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c99_A2 net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c616_S1 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input14_A in20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c497_A1 net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c207_CLK_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c688_A0 net554 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net801 clknet_0_net801 VGND VGND VPWR VPWR clknet_1_0__leaf_net801
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_85_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc109 net23 net997 net12 net41 net34 net40 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__mux4_1
XFILLER_0_79_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c292_A4 net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c717_S0 net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input6_A in13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s883_Q net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c748_A3 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c467_A4 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net242 net242 VGND VGND VPWR VPWR clknet_0_net242 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net297 net297 VGND VGND VPWR VPWR clknet_0_net297 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net275 net275 VGND VGND VPWR VPWR clknet_0_net275 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc610 net1000 net494 clknet_1_0__leaf_net385 net981 clknet_1_0__leaf_net498 clknet_1_0__leaf_net490
+ VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__mux4_2
Xc621 clknet_1_1__leaf_net501 net911 clknet_1_0__leaf_net299 net751 net786 net828
+ VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__mux4_4
Xc632 net266 net736 net741 net790 net1024 net828 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__mux4_1
Xc676 net979 clknet_1_0__leaf_net545 net980 net1049 clknet_1_0__leaf_net544 clknet_1_0__leaf_net743
+ VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__mux4_2
Xc687 net209 clknet_1_0__leaf_net552 net1049 net550 net980 net1025 VGND VGND VPWR
+ VPWR net560 sky130_fd_sc_hd__mux4_2
Xc698 net538 net343 clknet_1_0__leaf_net571 clknet_1_0__leaf_net570 net453 clknet_1_0__leaf_net842
+ VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__mux4_1
Xc665 net730 VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c627_S0 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c120_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input17_X net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c303_SCE net685 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c568_A3 net723 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout151_A net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_98_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c584_A2 net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c447_S0 clknet_1_0__leaf_net711 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c759_A2 net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c357_S0 clknet_1_1__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc451 net339 net113 net362 net987 net1020 net798 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__mux4_1
Xc462 net1053 net1004 net1073 net983 net767 VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__a41oi_1
Xc473 net17 net315 clknet_1_1__leaf_net383 net386 net989 net741 VGND VGND VPWR VPWR
+ net392 sky130_fd_sc_hd__mux4_4
Xc440 net200 net993 net916 net986 net338 net111 VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__mux4_4
Xc495 clknet_1_1__leaf_net407 net710 net949 net791 net819 clknet_1_0__leaf_net942
+ VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__mux4_4
Xc484 net996 net166 net1040 clknet_1_1__leaf_net299 net737 net815 VGND VGND VPWR VPWR
+ net403 sky130_fd_sc_hd__mux4_4
XFILLER_0_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_82_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc69 net883 net0 VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__and2_1
XANTENNA_c579_A2 net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c399_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c595_A1 net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net618 net1048 VGND VGND VPWR VPWR clknet_1_1__leaf_net618 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc281 net200 net207 net208 net994 net202 net670 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__mux4_1
Xc270 net201 net84 net1015 VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__a21boi_4
Xc292 net101 net218 net109 net697 net949 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__a41o_1
XANTENNA_s916_GATE_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c696_A0 net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c550_S0 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge791 clknet_4_14_0_clk merge791/D net304 VGND VGND VPWR VPWR net969 net305 sky130_fd_sc_hd__dfsbp_1
Xmerge780 net301 net290 VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__xor2_1
XFILLER_0_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c709_S1 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c196_Y net129 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold26 net757 VGND VGND VPWR VPWR net1071 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 net450 VGND VGND VPWR VPWR net1060 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c62_S1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c756_A3 net750 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net280 clknet_0_net280 VGND VGND VPWR VPWR clknet_1_0__leaf_net280
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c619_S1 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c491_A3 net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input44_A in48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge772_S0 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c635_S0 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c354_S1 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge857_DE net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c666_A3 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_90_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c545_S0 net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c264_S1 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net971 clknet_0_net971 VGND VGND VPWR VPWR clknet_1_1__leaf_net971
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_79_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c177_B1_N net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net605 net605 VGND VGND VPWR VPWR clknet_0_net605 sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_38_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c403_RESET_B net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_16_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net616 net616 VGND VGND VPWR VPWR clknet_0_net616 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_71_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c113_A1 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c190_S0 net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c349_S1 net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c422_CLK_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c365_S0 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net245 clknet_0_net245 VGND VGND VPWR VPWR clknet_1_1__leaf_net245
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c437_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_57_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c275_S0 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c722_S1 net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs907 clknet_4_6_0_clk net365 VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__dfxtp_4
Xs929 net443 clknet_4_0_0_clk VGND VGND VPWR VPWR net826 net825 sky130_fd_sc_hd__dlxbn_2
Xs918 net392 clknet_4_11_0_clk VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__dlxtp_1
XFILLER_0_90_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c185_S0 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c632_S1 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c663_A4 net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge837_Q net718 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge789_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c688_A1 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net802 clknet_0_net802 VGND VGND VPWR VPWR clknet_1_0__leaf_net802
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_85_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c200_A2 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout184_X net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s876_Q net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c436_X net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc611 net984 clknet_1_1__leaf_net498 net751 net813 net827 net839 VGND VGND VPWR VPWR
+ net506 sky130_fd_sc_hd__mux4_4
Xc622 net1041 net511 clknet_1_0__leaf_net925 net984 net786 net1024 VGND VGND VPWR
+ VPWR net517 sky130_fd_sc_hd__mux4_1
Xc600 clknet_1_1__leaf_net476 net492 net1032 net806 net818 net835 VGND VGND VPWR VPWR
+ net495 sky130_fd_sc_hd__mux4_1
Xc633 net525 net512 net741 net751 net786 net790 VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__mux4_1
Xc688 net554 net1010 net1014 net830 net1022 clknet_1_0__leaf_net841 VGND VGND VPWR
+ VPWR net561 sky130_fd_sc_hd__mux4_2
Xc677 clknet_1_1__leaf_net544 clknet_1_0__leaf_net545 net1013 net1007 net745 net793
+ VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__mux4_1
Xc666 net534 net209 net1007 net793 VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__a31o_1
Xc699 net451 clknet_1_0__leaf_net570 net566 net701 net746 clknet_1_0__leaf_net843
+ VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output113_A net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c301_A1 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net621 clknet_0_net621 VGND VGND VPWR VPWR clknet_1_0__leaf_net621
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s952_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_98_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c584_A3 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c65_S1 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c728_S0 net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c447_S1 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c105_A2 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c402_B1 net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s943_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c494_A3 net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc430 net205 net220 net348 net1004 net993 net346 VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__mux4_4
XFILLER_0_20_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc463 net246 net259 clknet_1_0__leaf_net956 net17 net804 VGND VGND VPWR VPWR net383
+ sky130_fd_sc_hd__a41o_1
Xc441 net354 net78 net1038 net246 net1011 net737 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__mux4_2
Xc452 net369 net247 net996 net735 net800 clknet_1_1__leaf_net801 VGND VGND VPWR VPWR
+ net372 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc496 net873 net161 net96 net989 net1031 net819 VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__mux4_4
Xc474 net356 net996 net1017 clknet_1_1__leaf_net387 clknet_1_1__leaf_net957 net813
+ VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__mux4_4
Xc485 net1017 net176 net996 net170 net1038 net791 VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__mux4_1
XANTENNA_c312_A0 net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c669_A3 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_82_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c548_S0 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c206_A1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_10_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c222_B1 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c579_A3 net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c298_A4 net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_26_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c595_A2 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout147_X net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c301_X net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c116_A1 net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net619 clknet_0_net619 VGND VGND VPWR VPWR clknet_1_1__leaf_net619
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c132_B1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_A3 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc260 clknet_1_0__leaf_net187 net180 clknet_1_1__leaf_net935 net773 net947 VGND VGND
+ VPWR VPWR net193 sky130_fd_sc_hd__a41oi_1
Xc271 net71 net874 net994 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__a21o_4
Xc293 net225 net197 net217 net993 net1016 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__a41oi_4
Xc282 net199 net208 net206 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__a21oi_1
XFILLER_0_46_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s907_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge770 net921 net985 net90 net89 net1037 net764 VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__mux4_2
Xmerge781 net408 net418 VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__xnor2_4
Xmerge792 net569 net555 VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__xnor2_1
XANTENNA_merge847_GATE clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_31_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c278_S0 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold27 net763 VGND VGND VPWR VPWR net1072 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold16 net734 VGND VGND VPWR VPWR net1061 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input37_A in41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge772_S1 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c635_S1 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c232_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_77_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c203_A2 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c545_S1 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net972 clknet_0_net972 VGND VGND VPWR VPWR clknet_1_1__leaf_net972
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net961 clknet_0_net961 VGND VGND VPWR VPWR clknet_1_1__leaf_net961
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_0_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c500_A0 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c561_S0 net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net606 net606 VGND VGND VPWR VPWR clknet_0_net606 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c576_A4 net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c428_D net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c592_A3 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c736_S0 net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c410_B1 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c304_A1 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c365_S1 net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c677_A3 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c556_S0 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net780 clknet_0_net780 VGND VGND VPWR VPWR clknet_1_1__leaf_net780
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs919 net393 clknet_4_11_0_clk VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xs908 clknet_4_6_0_clk net366 VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__dfxtp_2
XANTENNA_c324_SCD net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c319_Y net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_2_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c405_B1 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c185_S1 net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s937_Q_N net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output68_A net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_66_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net803 clknet_0_net803 VGND VGND VPWR VPWR clknet_1_0__leaf_net803
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_54_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c200_A3 net690 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_75_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_84_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c598_A2 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout177_X net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c171_Y net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_93_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net244 net244 VGND VGND VPWR VPWR clknet_0_net244 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_24_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net299 net299 VGND VGND VPWR VPWR clknet_0_net299 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc612 net5 net455 clknet_1_0__leaf_net501 net739 c612/S0 net753 VGND VGND VPWR VPWR
+ net507 sky130_fd_sc_hd__mux4_2
Xc601 net455 net1040 clknet_1_0__leaf_net490 clknet_1_0__leaf_net780 net807 net818
+ VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__mux4_4
XANTENNA_c135_B1 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc634 clknet_1_0__leaf_net521 net1019 clknet_1_1__leaf_net500 net738 net810 net840
+ VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__mux4_2
Xc623 net161 net1003 net513 net164 net736 net1028 VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__mux4_2
Xc689 clknet_1_0__leaf_net561 net1010 net979 net453 net1027 clknet_1_0__leaf_net841
+ VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__mux4_1
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc678 net543 clknet_1_1__leaf_net547 clknet_1_1__leaf_net545 net1007 net537 net709
+ VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__mux4_4
Xc667 net529 net745 net793 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__o21ai_1
XANTENNA_c301_A2 net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output106_A net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c674_A4 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c690_A3 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c105_A3 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge870_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c402_A1 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c546_X net440 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc420 net197 net1019 net196 net757 net774 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__a41o_1
XFILLER_0_20_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc453 net873 net369 net357 net982 net370 clknet_1_0__leaf_net802 VGND VGND VPWR VPWR
+ net373 sky130_fd_sc_hd__mux4_1
Xc442 net1001 net259 net348 net113 net1031 clknet_1_0__leaf_net711 VGND VGND VPWR
+ VPWR net363 sky130_fd_sc_hd__mux4_1
Xc464 net367 net1003 clknet_1_0__leaf_net383 net1032 clknet_1_1__leaf_net803 VGND
+ VGND VPWR VPWR net384 sky130_fd_sc_hd__a41o_1
Xc431 net222 net1035 net1001 net346 net336 net334 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__mux4_1
XFILLER_0_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge861_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc497 net96 net985 net736 clknet_1_0__leaf_net935 net819 clknet_1_0__leaf_net942 VGND
+ VGND VPWR VPWR net414 sky130_fd_sc_hd__mux4_2
Xc475 net1032 net1017 clknet_1_0__leaf_net957 net737 net776 net811 VGND VGND VPWR
+ VPWR net394 sky130_fd_sc_hd__mux4_1
Xc486 net990 net176 net1039 net693 net790 net816 VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__mux4_1
XANTENNA_input22_X net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c564_S0 net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c283_S1 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c579_A4 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net485 clknet_0_net485 VGND VGND VPWR VPWR clknet_1_0__leaf_net485
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c595_A3 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net496 clknet_0_net496 VGND VGND VPWR VPWR clknet_1_0__leaf_net496
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge843_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c474_S0 clknet_1_1__leaf_net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s945_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc250 clknet_1_0__leaf_net940 clknet_1_1__leaf_net971 net964 net690 net1072 VGND VGND
+ VPWR VPWR net185 sky130_fd_sc_hd__a41o_2
Xc261 clknet_1_1__leaf_net187 net1042 net663 net680 c261/S0 net773 VGND VGND VPWR
+ VPWR net194 sky130_fd_sc_hd__mux4_1
XANTENNA_merge834_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc272 net197 net862 net201 net77 net994 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__a41oi_4
XANTENNA_merge812_Q net690 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc294 net102 net215 net224 net990 net1002 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__a41oi_4
Xc283 net213 net1070 net207 net72 net198 net1025 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__mux4_1
XFILLER_0_46_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge771 clknet_1_1__leaf_net159 net42 net899 net1045 net11 net49 VGND VGND VPWR
+ VPWR net645 sky130_fd_sc_hd__mux4_2
XFILLER_0_7_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge782 net384 net390 VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_31_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge793 clknet_4_5_0_clk net211 net214 VGND VGND VPWR VPWR net670 net669 sky130_fd_sc_hd__dfsbp_2
XANTENNA_c559_S0 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold17 net558 VGND VGND VPWR VPWR net1062 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold28 net978 VGND VGND VPWR VPWR net1073 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c741_S1 net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net293 clknet_0_net293 VGND VGND VPWR VPWR clknet_1_0__leaf_net293
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_s949_Q net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c469_S0 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c318_A0 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_90_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net940 clknet_0_net940 VGND VGND VPWR VPWR clknet_1_1__leaf_net940
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c203_A3 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge814_GATE_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net618 net618 VGND VGND VPWR VPWR clknet_0_net618 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c361_X net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c404_SET_B net716 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c601_A0 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c556_S1 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c572_S0 net716 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net781 clknet_0_net781 VGND VGND VPWR VPWR clknet_1_1__leaf_net781
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_49_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout167_A net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs909 clknet_4_9_0_clk net368 VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__dlclkp_1
XANTENNA_c324_SCE net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout122_X net982 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c482_S0 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s882_Q_N net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net971 net971 VGND VGND VPWR VPWR clknet_0_net971 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c62_X net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_74_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_hold8_A net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c331_B1 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c111_B1_N net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_96_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c567_S0 net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c225_A1 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge846_Q_N net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_7_0_clk_X clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_A3 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net245 net245 VGND VGND VPWR VPWR clknet_0_net245 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c119_A2 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc613 clknet_1_0__leaf_net501 net455 net357 clknet_1_0__leaf_net498 net732 net753
+ VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__mux4_4
Xc602 net1032 net978 net934 net987 clknet_1_1__leaf_net471 net811 VGND VGND VPWR VPWR
+ net497 sky130_fd_sc_hd__mux4_1
Xc624 net927 clknet_1_0__leaf_net299 net710 net812 net1024 net840 VGND VGND VPWR VPWR
+ net977 sky130_fd_sc_hd__mux4_1
Xc635 net525 net161 net752 net785 net790 net828 VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__mux4_1
Xc679 clknet_4_0_0_clk net548 clknet_1_1__leaf_net547 net309 net980 net793 VGND VGND
+ VPWR VPWR net550 net549 sky130_fd_sc_hd__sdfbbn_2
Xc668 clknet_4_0_0_clk net432 net529 net309 net979 VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__sdfstp_1
XANTENNA_c151_A0 net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input12_A in19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c301_A3 net685 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge842_Q net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c211_A3 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net623 clknet_0_net623 VGND VGND VPWR VPWR clknet_1_0__leaf_net623
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c297_S0 net685 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input4_A in11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c402_A2 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc410 net317 net306 net314 net982 net1031 VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__a41o_1
Xc421 clknet_4_5_0_clk net876 net1002 net335 net334 net1058 VGND VGND VPWR VPWR net337
+ net336 sky130_fd_sc_hd__sdfbbp_1
Xc432 net326 net992 net347 net982 net1065 net735 VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__mux4_1
Xc454 net1010 net1040 net367 net353 clknet_1_0__leaf_net956 clknet_1_0__leaf_net802
+ VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__mux4_2
Xc443 net921 net1019 net362 net1004 net246 net728 VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__mux4_4
XFILLER_0_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc465 net916 net1012 net356 net1020 net775 clknet_1_0__leaf_net803 VGND VGND VPWR
+ VPWR net385 sky130_fd_sc_hd__mux4_1
Xc487 net4 net96 net984 net386 net1017 net791 VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__mux4_4
Xc476 clknet_1_0__leaf_net956 net126 clknet_1_0__leaf_net957 clknet_1_1__leaf_net387
+ net945 clknet_1_1__leaf_net803 VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__mux4_4
Xc498 clknet_1_1__leaf_net956 net166 net714 net717 net791 net819 VGND VGND VPWR VPWR
+ net943 sky130_fd_sc_hd__mux4_4
XFILLER_0_99_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c312_A2 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c206_A3 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c503_A1 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c564_S1 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c755_S0 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c413_A1 net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input7_X net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c474_S1 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c132_A2 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_79_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc251 net57 net47 clknet_1_0__leaf_net940 clknet_1_1__leaf_net181 net749 net761 VGND
+ VGND VPWR VPWR net976 sky130_fd_sc_hd__mux4_1
Xc262 net25 clknet_1_1__leaf_net187 net56 net680 c262/S0 net749 VGND VGND VPWR VPWR
+ net195 sky130_fd_sc_hd__mux4_2
Xc240 clknet_4_15_0_clk net40 clknet_1_0__leaf_net174 net647 net693 net771 VGND VGND
+ VPWR VPWR net176 net175 sky130_fd_sc_hd__sdfbbn_2
XANTENNA_c682_Q net554 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_15_0_clk_X clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc295 net222 net68 net102 net1039 net885 net685 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__mux4_1
Xc284 net198 net208 net994 net199 net1025 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__a41oi_4
Xc273 net863 net203 net994 net1002 net80 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__a41o_2
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge772 net430 net1049 net1007 net109 net986 net68 VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__mux4_1
XFILLER_0_7_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge794 net489 net493 VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__xnor2_2
Xmerge783 net377 net371 VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__xnor2_1
XFILLER_0_31_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold29 net762 VGND VGND VPWR VPWR net1074 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c437_RESET_B net333 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold18 net316 VGND VGND VPWR VPWR net1063 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout152_X net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net294 clknet_0_net294 VGND VGND VPWR VPWR clknet_1_0__leaf_net294
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c87_S1 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c469_S1 net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c127_A2 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c409_SCD net309 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c424_B1 net757 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c485_S0 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net407 clknet_0_net407 VGND VGND VPWR VPWR clknet_1_1__leaf_net407
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c334_B1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net619 net619 VGND VGND VPWR VPWR clknet_0_net619 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c685_D net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c752_S1 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c154_A0 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input42_A in46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c304_A3 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge820_GATE_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c601_A1 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c204_CLK_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c320_A2 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c329_A0 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c214_A3 net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c572_S1 net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net782 clknet_0_net782 VGND VGND VPWR VPWR clknet_1_1__leaf_net782
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_49_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_3_0_clk_X clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c569_X net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_net961 net961 VGND VGND VPWR VPWR clknet_0_net961 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net972 net972 VGND VGND VPWR VPWR clknet_0_net972 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c315_A2 net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input45_X net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c612_A0 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c392_S1 net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c331_A1 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_96_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c225_A2 net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c241_A1 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c157_Y net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s955_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c403_SET_B net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c758_S0 net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc603 net445 clknet_1_0__leaf_net496 clknet_1_1__leaf_net470 net734 clknet_1_1__leaf_net781
+ net812 VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__mux4_1
XFILLER_0_32_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c416_A1 net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c477_S1 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc625 net512 net17 clknet_1_0__leaf_net500 net751 net799 net839 VGND VGND VPWR VPWR
+ net519 sky130_fd_sc_hd__mux4_4
Xc636 clknet_1_0__leaf_net925 net944 net1019 net741 net798 net1024 VGND VGND VPWR
+ VPWR net527 sky130_fd_sc_hd__mux4_1
Xc614 clknet_1_1__leaf_net471 net495 net1020 clknet_1_1__leaf_net498 net811 net839
+ VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__mux4_1
Xc669 net536 net531 net1044 net1013 net314 VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__a41o_1
XANTENNA_c432_A0 net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c493_S0 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c151_A1 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c301_A4 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s928_GATE_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c607_A0 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net780 net780 VGND VGND VPWR VPWR clknet_0_net780 sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge773_Q_N net647 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c326_A1 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge835_Q net716 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output73_A net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_max_cap128_X net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net613 clknet_0_net613 VGND VGND VPWR VPWR clknet_1_0__leaf_net613
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_s937_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c578_S0 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout182_X net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc400 net672 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__clkinv_8
Xc411 net310 net319 net316 net1031 net716 net756 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__mux4_1
Xc433 net348 net326 net983 net226 c433/S0 net700 VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__mux4_1
Xc455 net1002 clknet_1_0__leaf_net122 net369 net1038 net797 clknet_1_0__leaf_net802
+ VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__mux4_4
Xc444 net348 net338 clknet_1_0__leaf_net122 net353 net728 net796 VGND VGND VPWR VPWR
+ net365 sky130_fd_sc_hd__mux4_4
Xc422 clknet_4_6_0_clk net337 net334 net335 net109 net333 VGND VGND VPWR VPWR net339
+ net338 sky130_fd_sc_hd__sdfbbn_1
XPHY_EDGE_ROW_8_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc466 net1004 net987 net989 net219 net945 VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__a41o_1
Xc477 net279 net928 clknet_1_0__leaf_net383 net259 net722 net813 VGND VGND VPWR VPWR
+ net396 sky130_fd_sc_hd__mux4_2
Xc488 net287 net990 net96 net861 net815 net819 VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__mux4_1
XFILLER_0_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc499 net166 clknet_1_0__leaf_net943 clknet_1_1__leaf_net407 net736 clknet_1_0__leaf_net935
+ clknet_1_0__leaf_net942 VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__mux4_1
XFILLER_0_35_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output111_A clknet_1_1__leaf_net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c337_B1 clknet_1_0__leaf_net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_93_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c206_A4 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c222_A3 net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net476 clknet_0_net476 VGND VGND VPWR VPWR clknet_1_0__leaf_net476
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net498 clknet_0_net498 VGND VGND VPWR VPWR clknet_1_0__leaf_net498
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout142_A net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c247_A0 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c710_A0 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c307_A3 net685 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc230 net160 clknet_1_0__leaf_net971 net19 net1041 clknet_1_1__leaf_net141 VGND VGND
+ VPWR VPWR net165 sky130_fd_sc_hd__a41oi_1
XTAP_TAPCELL_ROW_79_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc252 net58 net964 clknet_1_0__leaf_net181 net47 net748 clknet_1_0__leaf_net972 VGND
+ VGND VPWR VPWR net186 sky130_fd_sc_hd__mux4_2
Xc241 clknet_1_1__leaf_net174 net952 net175 net693 net764 net772 VGND VGND VPWR VPWR
+ net177 sky130_fd_sc_hd__mux4_4
Xc263 net970 clknet_1_1__leaf_net935 net763 net773 net947 VGND VGND VPWR VPWR net946
+ sky130_fd_sc_hd__a41oi_1
XANTENNA_c604_A1 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc296 net84 net225 net992 net105 net990 VGND VGND VPWR VPWR net967 sky130_fd_sc_hd__a41oi_4
Xc285 net84 net215 net213 net1043 net670 net1025 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__mux4_4
Xc274 net861 net76 net994 net1010 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__a31oi_2
XANTENNA_c323_A2 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c620_A0 net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge773 clknet_4_7_0_clk net118 merge773/RESET_B VGND VGND VPWR VPWR net123 net647
+ sky130_fd_sc_hd__dfrbp_2
XFILLER_0_7_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge784 net454 net459 VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__xnor2_1
Xmerge795 clknet_4_4_0_clk net330 net640 VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__dfstp_2
Xs890 clknet_4_7_0_clk net229 VGND VGND VPWR VPWR net962 sky130_fd_sc_hd__dfxtp_4
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c233_A2 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold19 net792 VGND VGND VPWR VPWR net1064 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c591_S0 net723 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net251 clknet_0_net251 VGND VGND VPWR VPWR clknet_1_0__leaf_net251
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout145_X net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c424_A1 net333 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c143_A2 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_98_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c440_A0 net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c615_A0 net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_90_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c395_S1 net949 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c350_A0 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net942 clknet_0_net942 VGND VGND VPWR VPWR clknet_1_1__leaf_net942
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net975 clknet_0_net975 VGND VGND VPWR VPWR clknet_1_1__leaf_net975
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_0_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c410_A3 net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c419_A1 net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c496_S0 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input35_A in4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net249 clknet_0_net249 VGND VGND VPWR VPWR clknet_1_1__leaf_net249
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c329_A1 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge865_Q net750 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c345_A0 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap158_X net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c230_A3 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c255_A0 net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c668_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c405_A3 net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net940 net940 VGND VGND VPWR VPWR clknet_0_net940 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c165_A0 net882 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_26_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge863_CLK_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c612_A1 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c331_A2 net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_44_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_62_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc604 clknet_1_0__leaf_net385 net455 clknet_1_1__leaf_net471 clknet_1_0__leaf_net490
+ clknet_1_0__leaf_net498 clknet_1_1__leaf_net781 VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__mux4_4
XFILLER_0_44_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc637 net234 net527 clknet_1_1__leaf_net519 net738 net786 net810 VGND VGND VPWR VPWR
+ net528 sky130_fd_sc_hd__mux4_2
Xc615 net987 clknet_1_0__leaf_net500 clknet_1_1__leaf_net498 net703 net768 net840
+ VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__mux4_2
Xc626 net514 clknet_1_0__leaf_net925 net911 net736 net771 net786 VGND VGND VPWR VPWR
+ net520 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_73_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s891_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c432_A1 net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_80_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net781 net781 VGND VGND VPWR VPWR clknet_0_net781 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c326_A2 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge864_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c623_A0 net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c684_S0 net549 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c342_A1 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output66_A net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net636 clknet_0_net636 VGND VGND VPWR VPWR clknet_1_0__leaf_net636
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c229_Q_N net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c578_S1 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s873_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_S0 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c252_A1 net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout175_X net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c162_X net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c708_A0 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc412 clknet_4_4_0_clk net307 net321 net1031 net991 net311 VGND VGND VPWR VPWR net326
+ net325 sky130_fd_sc_hd__sdfbbn_2
Xc401 clknet_4_4_0_clk net67 net203 net983 net1002 VGND VGND VPWR VPWR net312 net311
+ sky130_fd_sc_hd__sdfsbp_1
XFILLER_0_32_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc434 clknet_4_6_0_clk net334 net326 net200 net1057 VGND VGND VPWR VPWR net354 net353
+ sky130_fd_sc_hd__sdfsbp_1
Xc423 net87 net334 net1055 net234 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__a31o_1
XANTENNA_c443_A0 net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc445 clknet_1_0__leaf_net122 net1030 net988 net257 net796 net798 VGND VGND VPWR VPWR
+ net366 sky130_fd_sc_hd__mux4_1
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc456 net369 net978 net356 net985 net362 clknet_1_0__leaf_net801 VGND VGND VPWR VPWR
+ net376 sky130_fd_sc_hd__mux4_1
Xc478 clknet_1_1__leaf_net957 clknet_1_1__leaf_net385 net945 net804 net813 net814
+ VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__mux4_1
Xc467 net1 net246 net4 net989 clknet_1_1__leaf_net780 VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__a41o_1
Xc489 clknet_1_1__leaf_net956 clknet_1_1__leaf_net939 net791 net810 net819 net1024
+ VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__mux4_4
XFILLER_0_87_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output104_A net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c618_A0 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge837_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c503_A3 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c222_A4 net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge817_GATE clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_54_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c528_A0 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c589_S0 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c247_A1 net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout135_A net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge828_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c413_A3 net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c551_Y net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c544_X net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_552 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c438_A0 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc220 net110 net19 net934 net1042 clknet_1_1__leaf_net141 VGND VGND VPWR VPWR net156
+ sky130_fd_sc_hd__a41oi_4
XTAP_TAPCELL_ROW_79_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc242 net168 net1042 net58 net44 net724 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__a41o_1
Xc231 net137 net164 net38 net148 net764 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__a41o_2
Xc253 net184 clknet_1_0__leaf_net940 net917 clknet_1_1__leaf_net972 net960 VGND VGND
+ VPWR VPWR net975 sky130_fd_sc_hd__a41oi_2
Xc286 clknet_4_5_0_clk net98 net197 net874 net886 net876 VGND VGND VPWR VPWR net218
+ net217 sky130_fd_sc_hd__sdfbbp_1
Xc264 net86 net67 net208 net87 net670 net776 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__mux4_1
Xc275 net76 net202 net205 net1043 net203 net994 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__mux4_2
Xc297 net1059 net876 net209 net992 net685 net777 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__mux4_1
XANTENNA_c323_A3 net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A1 net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input20_X net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge785 net183 net188 VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__xnor2_1
Xmerge774 net535 net541 VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__or2b_1
XFILLER_0_28_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_31_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge796 net516 net515 VGND VGND VPWR VPWR net673 sky130_fd_sc_hd__xnor2_2
Xs880 net155 clknet_4_12_0_clk VGND VGND VPWR VPWR net768 net767 sky130_fd_sc_hd__dlxbn_2
XANTENNA_c679_CLK_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs891 clknet_4_6_0_clk net233 VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_11_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c233_A3 net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c530_A1 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput1 in0 VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_67_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net296 clknet_0_net296 VGND VGND VPWR VPWR clknet_1_0__leaf_net296
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout138_X net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge850_D net671 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c705_A1 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c424_A2 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c440_A1 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c528_S net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c78_X net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c334_A2 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c692_S0 net549 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net932 clknet_0_net932 VGND VGND VPWR VPWR clknet_1_1__leaf_net932
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_0_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net943 clknet_0_net943 VGND VGND VPWR VPWR clknet_1_1__leaf_net943
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_36_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c541_B1 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c410_A4 net982 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c419_A2 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c435_A1 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input28_A in33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c687_S0 net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c345_A1 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output96_A clknet_1_1__leaf_net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c230_A4 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c239_A2 net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net407 net407 VGND VGND VPWR VPWR clknet_0_net407 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c536_B1 net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c405_A4 net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c702_A2 net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c149_A2 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s884_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c446_A0 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c300_S0 net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c181_A0 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c331_A3 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c210_S0 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net570 clknet_0_net570 VGND VGND VPWR VPWR clknet_1_1__leaf_net570
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout120_X net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc616 net928 clknet_1_0__leaf_net925 net798 net1024 clknet_1_1__leaf_net821 net827
+ VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__mux4_4
Xc605 net220 clknet_1_1__leaf_net496 clknet_1_0__leaf_net498 clknet_1_0__leaf_net490
+ clknet_1_0__leaf_net385 net927 VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__mux4_2
Xc627 net227 net455 clknet_1_1__leaf_net519 net161 net931 clknet_1_1__leaf_net821
+ VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_73_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c713_A1 net550 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c151_A3 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c176_S net696 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c343_S net754 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net782 net782 VGND VGND VPWR VPWR clknet_0_net782 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c326_A3 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input50_X net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c623_A1 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c684_S1 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c342_A2 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c205_S0 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout168_X net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge791_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc402 net77 net872 net308 net983 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__a31oi_1
Xc413 net324 net326 net306 net314 net669 net756 VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__mux4_1
Xc435 net354 net1004 net348 net1029 net344 net666 VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__mux4_4
Xc424 net333 net1019 net1010 net685 net757 VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__a41oi_1
XANTENNA_c443_A1 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc446 net68 net258 net338 net796 net799 net800 VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__mux4_2
Xc468 net1040 net1020 clknet_1_1__leaf_net387 clknet_1_0__leaf_net939 net799 net810
+ VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__mux4_1
Xc457 clknet_1_0__leaf_net374 net356 net982 net370 net716 clknet_1_0__leaf_net802
+ VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__mux4_4
Xc479 clknet_1_0__leaf_net957 clknet_1_1__leaf_net385 net717 net811 net814 net816
+ VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__mux4_4
XFILLER_0_87_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input10_A in17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c618_A1 net861 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c337_A2 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_93_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge773_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c589_S1 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c528_A1 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c247_A2 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input2_A in1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c719_A0 net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c438_A1 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c72_B1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c454_A0 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc210 clknet_1_1__leaf_net120 net917 net131 net1042 net1032 clknet_1_0__leaf_net765
+ VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_79_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc221 clknet_1_1__leaf_net125 net137 net997 net29 clknet_1_0__leaf_net156 VGND VGND
+ VPWR VPWR net971 sky130_fd_sc_hd__a41oi_2
XANTENNA_input58_A in60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc232 clknet_4_15_0_clk net42 net948 net963 net161 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__sdfrtp_2
Xc254 net25 clknet_1_0__leaf_net975 net56 net748 net960 VGND VGND VPWR VPWR net187
+ sky130_fd_sc_hd__a41o_2
Xc243 clknet_1_1__leaf_net156 clknet_1_1__leaf_net971 net41 net974 net1045 net997
+ VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__mux4_2
XANTENNA_c173_A1 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc287 clknet_4_5_0_clk net218 net1016 net986 net1011 net920 VGND VGND VPWR VPWR net220
+ net219 sky130_fd_sc_hd__sdfbbn_2
Xc265 net863 net77 net1043 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__o21a_4
Xc276 net204 net84 net205 net86 net202 net67 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__mux4_1
Xc298 net228 net967 net197 net992 net993 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__a41o_1
XTAP_TAPCELL_ROW_5_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A2 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input13_X net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c629_A0 net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge766_B1 net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c202_S1 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge797 net243 net248 VGND VGND VPWR VPWR net674 sky130_fd_sc_hd__xor2_1
Xmerge786 net600 net601 VGND VGND VPWR VPWR net662 sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_31_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge775 clknet_4_1_0_clk net439 net641 VGND VGND VPWR VPWR net651 net650 sky130_fd_sc_hd__dfrbp_1
Xs881 net171 clknet_4_12_0_clk VGND VGND VPWR VPWR net770 net769 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs892 clknet_4_6_0_clk net240 VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__dfxtp_1
XANTENNA_c364_A0 net129 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c530_A2 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput2 in1 VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_67_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net242 clknet_0_net242 VGND VGND VPWR VPWR clknet_1_0__leaf_net242
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c193_B1_N net696 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net275 clknet_0_net275 VGND VGND VPWR VPWR clknet_1_0__leaf_net275
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net297 clknet_0_net297 VGND VGND VPWR VPWR clknet_1_0__leaf_net297
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_61_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c274_B1 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c424_A3 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input5_X net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c440_A2 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c449_A0 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c168_A1 net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c401_SET_B net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c409_Q net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c184_B1 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c692_S1 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c350_A2 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c359_A0 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c399_D net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout150_X net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c419_A3 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c716_A1 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_76_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c451_A1 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c170_A2 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_87_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c179_A0 net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c90_X net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c329_A3 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c687_S1 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c626_A1 clknet_1_0__leaf_net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c345_A2 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output89_A net949 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c361_A1 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s902_GATE clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_8_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c536_A1 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c255_A2 net724 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput60 in7 VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__buf_4
XANTENNA_c552_A0 net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s917_GATE_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c149_A3 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c64_A1 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net942 net942 VGND VGND VPWR VPWR clknet_0_net942 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net975 net975 VGND VGND VPWR VPWR clknet_0_net975 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c165_A2 net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c462_B1 net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input40_A in44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c181_A1 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge870_Q net757 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c698_S0 net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c637_A0 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c356_A1 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c74_S net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net571 clknet_0_net571 VGND VGND VPWR VPWR clknet_1_1__leaf_net571
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net593 clknet_0_net593 VGND VGND VPWR VPWR clknet_1_1__leaf_net593
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net249 net249 VGND VGND VPWR VPWR clknet_0_net249 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc606 clknet_1_1__leaf_net470 net1032 clknet_1_0__leaf_net385 net987 clknet_1_0__leaf_net498
+ net838 VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__mux4_1
Xc617 net17 net868 net790 net812 net1024 net1021 VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__mux4_1
Xc628 clknet_1_1__leaf_net500 net978 net718 net738 net790 net1021 VGND VGND VPWR VPWR
+ net522 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_73_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c432_A3 net982 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_84_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c75_A0 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c176_A1 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c607_A3 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c342_A3 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s900_GATE_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net616 clknet_0_net616 VGND VGND VPWR VPWR clknet_1_0__leaf_net616
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net605 clknet_0_net605 VGND VGND VPWR VPWR clknet_1_0__leaf_net605
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_98_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c367_A0 net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c124_SET_B net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c724_A1 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc403 clknet_4_4_0_clk net312 net921 net209 net1002 net310 VGND VGND VPWR VPWR net315
+ net314 sky130_fd_sc_hd__sdfbbn_2
Xc414 clknet_4_4_0_clk net324 net319 net325 net206 net792 VGND VGND VPWR VPWR net329
+ net328 sky130_fd_sc_hd__sdfbbn_2
Xc436 net339 net336 net1029 net735 net795 VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__a41o_2
Xc425 net335 net339 net1044 net334 net779 VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__a41o_1
Xc458 net370 net872 net369 net706 clknet_1_0__leaf_net803 net805 VGND VGND VPWR VPWR
+ net378 sky130_fd_sc_hd__mux4_2
Xc469 net271 net1038 clknet_1_1__leaf_net385 net1032 net989 net767 VGND VGND VPWR
+ VPWR net957 sky130_fd_sc_hd__mux4_1
Xc447 net985 net1030 net916 net872 clknet_1_0__leaf_net711 net799 VGND VGND VPWR VPWR
+ net368 sky130_fd_sc_hd__mux4_4
XANTENNA_c162_A3 net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c740_A0 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s930_Q_N net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_28_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c306_S0 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c187_A0 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c618_A2 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c337_A3 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c634_A1 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output71_A net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c560_A0 net861 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c229_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout180_X net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c272_Y net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c401_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_59_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c324_CLK_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c693_SET_B net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c735_A0 net554 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c454_A1 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc200 net132 net19 net690 net764 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_79_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc211 net127 net143 net132 net1017 net1005 net1032 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__mux4_1
Xc233 net30 net167 net1042 net166 net1017 net764 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__mux4_1
Xc244 net44 net57 net47 net41 net749 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__a41oi_4
Xc222 net38 clknet_1_1__leaf_net152 net964 net39 net997 VGND VGND VPWR VPWR net157
+ sky130_fd_sc_hd__a41oi_2
XANTENNA_c173_A2 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_68_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc255 net917 clknet_1_1__leaf_net187 net724 net749 net761 clknet_1_1__leaf_net972
+ VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__mux4_4
Xc288 net1037 net219 net209 net91 net87 net697 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__mux4_1
Xc277 clknet_4_5_0_clk net207 net202 net206 net994 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__sdfrtp_4
Xc266 net72 net863 net861 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__a21boi_4
Xc299 net967 net202 net224 net226 net1037 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__a41o_1
XFILLER_0_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A3 net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c629_A1 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge787 clknet_4_15_0_clk net61 net66 VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__dfrtp_2
Xmerge765 clknet_1_1__leaf_net141 clknet_1_1__leaf_net152 clknet_1_0__leaf_net159
+ net665 net690 VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__a41o_4
XFILLER_0_43_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge776 clknet_4_7_0_clk net239 net230 VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__dfrtn_1
Xs882 net172 clknet_4_13_0_clk VGND VGND VPWR VPWR net772 net771 sky130_fd_sc_hd__dlxbp_1
Xmerge798 net638 net626 VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__xnor2_4
Xs893 clknet_4_12_0_clk net260 VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__dlclkp_1
XANTENNA_c364_A1 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput3 in10 VGND VGND VPWR VPWR net863 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_93_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout140_A net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c705_A3 net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c274_A1 net861 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c424_A4 net685 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c290_B1 net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c440_A3 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c67_A1 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c449_A1 net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c168_A2 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c83_A0 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c465_A0 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c631_A2 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net956 clknet_0_net956 VGND VGND VPWR VPWR clknet_1_1__leaf_net956
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c359_A1 net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c286_Q_N net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c244_A4 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_4_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c269_A1 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout143_X net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c435_A3 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c170_A3 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s935_SLEEP_B clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c179_A1 net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c626_A2 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c361_A2 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net742 clknet_0_net742 VGND VGND VPWR VPWR clknet_1_1__leaf_net742
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput50 in53 VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__buf_2
XFILLER_0_12_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput61 in8 VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c552_A1 net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c271_A2 net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c64_A2 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net932 net932 VGND VGND VPWR VPWR clknet_0_net932 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net943 net943 VGND VGND VPWR VPWR clknet_0_net943 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c165_A3 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s894_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c181_A2 net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input33_A in38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge863_Q net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c356_A2 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge867_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c67_S net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net561 clknet_0_net561 VGND VGND VPWR VPWR clknet_1_1__leaf_net561
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_22_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c547_A1 net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge858_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s876_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc607 net990 clknet_1_1__leaf_net498 clknet_1_0__leaf_net501 net813 net818 net827
+ VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__mux4_2
Xc618 net911 net861 net771 net1024 net839 net840 VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_73_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc629 net17 net911 net927 net936 net790 net1024 VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__mux4_2
XANTENNA_c713_A3 net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_40_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge794_Y net671 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c75_A1 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c457_A1 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_51_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c91_B1 net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c473_A0 net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_12_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c623_A3 net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge769_A1 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net606 clknet_0_net606 VGND VGND VPWR VPWR clknet_1_0__leaf_net606
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c367_A1 net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s915_Q net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc415 net319 net324 net328 net325 net1064 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__a41o_1
Xc437 clknet_4_4_0_clk net988 net333 net348 net666 net700 VGND VGND VPWR VPWR net358
+ net357 sky130_fd_sc_hd__sdfbbn_2
Xc404 clknet_4_4_0_clk net310 net87 net983 net314 net716 VGND VGND VPWR VPWR net317
+ net316 sky130_fd_sc_hd__sdfbbn_2
Xc426 net861 net921 net1004 net735 net1028 VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__a41oi_4
Xc459 clknet_1_0__leaf_net378 clknet_1_0__leaf_net956 net716 net798 net800 clknet_1_0__leaf_net803
+ VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__mux4_1
Xc448 net993 net258 net367 net797 net799 net800 VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__mux4_2
XANTENNA_c443_A3 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c468_A0 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c337_A4 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net570 net570 VGND VGND VPWR VPWR clknet_0_net570 sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge771_A2 net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c353_A3 net718 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge826_Q net706 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c216_S1 clknet_1_0__leaf_net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c267_B1_N net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c560_A1 net982 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c288_A0 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c719_A2 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c142_S0 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c438_A3 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc201 net689 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__inv_8
Xc212 net910 net4 clknet_1_1__leaf_net120 net132 net1003 clknet_1_0__leaf_net765 VGND
+ VGND VPWR VPWR net147 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_79_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc234 net19 net37 net163 net168 net38 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__a41o_1
Xc245 net964 net158 net663 net754 clknet_1_1__leaf_net766 VGND VGND VPWR VPWR net181
+ sky130_fd_sc_hd__a41oi_2
Xc223 net955 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__buf_1
XANTENNA_c751_A0 net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc256 net57 clknet_1_0__leaf_net187 clknet_1_0__leaf_net975 clknet_1_0__leaf_net940
+ net749 net960 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__mux4_1
Xc267 net862 net72 net1010 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__a21bo_1
Xc278 net206 net68 net208 net197 net1006 net1016 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__mux4_2
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c470_A1 net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc289 net1016 net862 net991 net697 net775 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__a41oi_4
XTAP_TAPCELL_ROW_5_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c629_A2 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output102_A net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c348_A3 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge788 net94 net92 VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__xor2_1
Xmerge777 net277 net270 VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__or2b_4
Xmerge766 net210 net306 net995 net308 net983 VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__a41o_1
Xs872 clknet_4_15_0_clk net63 VGND VGND VPWR VPWR net760 net759 sky130_fd_sc_hd__dfxbp_1
Xmerge799 net133 net154 VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__xor2_4
Xs883 net177 clknet_4_14_0_clk VGND VGND VPWR VPWR net966 sky130_fd_sc_hd__dlxtn_2
Xs894 clknet_4_9_0_clk net284 VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__dlclkp_2
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_67_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput4 in11 VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_530 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net244 clknet_0_net244 VGND VGND VPWR VPWR clknet_1_0__leaf_net244
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c258_A3 net724 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net299 clknet_0_net299 VGND VGND VPWR VPWR clknet_1_0__leaf_net299
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout133_A net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_0_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_5_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge829_D net487 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s897_Q_N net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c465_A1 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c481_A0 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c631_A3 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s888_Q_N net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net935 clknet_0_net935 VGND VGND VPWR VPWR clknet_1_1__leaf_net935
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net957 clknet_0_net957 VGND VGND VPWR VPWR clknet_1_1__leaf_net957
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge853_GATE clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c359_A2 net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_16_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c541_A3 net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_87_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c566_A0 net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_96_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c285_A1 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout136_X net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c451_A3 net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c179_A2 net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_500 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c476_A0 clknet_1_0__leaf_net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c361_A3 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net765 clknet_0_net765 VGND VGND VPWR VPWR clknet_1_1__leaf_net765
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net743 clknet_0_net743 VGND VGND VPWR VPWR clknet_1_1__leaf_net743
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_49_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c505_S0 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c536_A3 net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput40 in44 VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_71_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput51 in54 VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__buf_4
Xinput62 in9 VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__buf_1
XFILLER_0_12_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c552_A2 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net971_X clknet_1_1__leaf_net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c296_B1 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c64_A3 net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c727_A2 net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c150_S0 net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c505_X net421 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c462_A2 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c181_A3 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c89_B1 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input26_A in31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c356_A3 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c219_S1 clknet_1_0__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c563_A1 net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc608 net981 clknet_1_0__leaf_net498 clknet_1_0__leaf_net496 clknet_1_1__leaf_net378
+ net445 clknet_1_0__leaf_net501 VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__mux4_1
Xc619 net455 net937 clknet_1_1__leaf_net500 net1045 net1024 net828 VGND VGND VPWR
+ VPWR net514 sky130_fd_sc_hd__mux4_1
XFILLER_0_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_84_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c173_B1_N net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c457_A2 net982 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c754_A0 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c91_A1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c473_A1 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c192_A2 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge769_A2 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net618 clknet_0_net618 VGND VGND VPWR VPWR clknet_1_0__leaf_net618
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_wire171_X net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c558_A1 net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c574_B1 net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc416 net321 net326 net306 net328 net672 net792 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__mux4_1
Xc405 net306 net317 net995 net314 net776 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__a41oi_4
Xc427 clknet_4_6_0_clk net1002 net988 net337 net334 net1004 VGND VGND VPWR VPWR net345
+ net344 sky130_fd_sc_hd__sdfbbn_1
Xc438 net1006 net356 net353 net219 net699 net756 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__mux4_2
Xc449 net868 net103 net257 net799 net800 clknet_1_1__leaf_net801 VGND VGND VPWR VPWR
+ net956 sky130_fd_sc_hd__mux4_2
XANTENNA_c740_A2 net550 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c468_A1 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c187_A2 net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c484_A0 net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net593 net593 VGND VGND VPWR VPWR clknet_0_net593 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net571 net571 VGND VGND VPWR VPWR clknet_0_net571 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge771_A3 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c634_A3 net738 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c97_B1_N net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c394_A0 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c544_A3 net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c560_A2 net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c569_A0 net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c153_X net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c288_A1 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net971 clknet_0_net971 VGND VGND VPWR VPWR clknet_1_0__leaf_net971
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_81_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c72_A3 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc202 net872 net917 net112 net21 net115 net1034 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_79_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc224 clknet_1_1__leaf_net144 net647 clknet_1_0__leaf_net972 VGND VGND VPWR VPWR net159
+ sky130_fd_sc_hd__o21ai_1
Xc235 clknet_4_13_0_clk net167 clknet_1_0__leaf_net159 net997 net166 net1050 VGND
+ VGND VPWR VPWR net952 net170 sky130_fd_sc_hd__sdfbbn_2
Xc213 clknet_4_13_0_clk clknet_1_0__leaf_net145 net146 net138 net1012 clknet_1_0__leaf_net147
+ VGND VGND VPWR VPWR net149 net148 sky130_fd_sc_hd__sdfbbn_1
XTAP_TAPCELL_ROW_92_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc257 net905 clknet_1_1__leaf_net187 clknet_1_0__leaf_net975 clknet_1_1__leaf_net940
+ net763 net960 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__mux4_2
Xc246 net180 net47 net1042 net749 net754 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__a41oi_1
Xc268 net72 net197 net71 net198 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__a31oi_4
Xc279 net208 net206 net201 net202 net994 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__a41oi_2
XANTENNA_c470_A2 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c317_S1 net757 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge766_A3 net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c629_A3 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge778 net584 net595 VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__nand2b_4
Xmerge767 net428 net998 net430 net981 net432 net1056 VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__mux4_1
Xs873 clknet_4_15_0_clk net64 VGND VGND VPWR VPWR net762 net761 sky130_fd_sc_hd__dfxbp_1
Xmerge789 clknet_4_13_0_clk net157 net165 VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__dfrtp_2
Xs884 net186 clknet_4_15_0_clk VGND VGND VPWR VPWR net960 sky130_fd_sc_hd__dlxtn_2
Xs895 clknet_4_14_0_clk net285 VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_24_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c364_A3 clknet_1_1__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput5 in12 VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c243_S0 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net245 clknet_0_net245 VGND VGND VPWR VPWR clknet_1_0__leaf_net245
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c553_CLK_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout126_A net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s896_GATE_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c290_A2 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c299_B1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c535_X net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c449_A3 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c83_A2 net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c465_A2 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c762_A0 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input56_A in59 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net925 clknet_0_net925 VGND VGND VPWR VPWR clknet_1_1__leaf_net925
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_input11_X net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c359_A3 clknet_1_1__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout129_X net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c732_A3 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c179_A3 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c94_A1 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c611_S0 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c476_A1 net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c330_S1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c492_A0 net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_467 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_net711 clknet_0_net711 VGND VGND VPWR VPWR clknet_1_1__leaf_net711
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net766 clknet_0_net766 VGND VGND VPWR VPWR clknet_1_1__leaf_net766
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput30 in35 VGND VGND VPWR VPWR net890 sky130_fd_sc_hd__buf_1
XFILLER_0_71_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput41 in45 VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__clkbuf_4
Xinput52 in55 VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__buf_1
XFILLER_0_52_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c552_A3 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c727_A3 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net956 net956 VGND VGND VPWR VPWR clknet_0_net956 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c743_A2 net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c80_A3 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input19_A in25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c487_A0 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c637_A3 net738 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c372_A3 clknet_1_1__leaf_net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net574 clknet_0_net574 VGND VGND VPWR VPWR clknet_1_1__leaf_net574
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net563 clknet_0_net563 VGND VGND VPWR VPWR clknet_1_1__leaf_net563
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net552 clknet_0_net552 VGND VGND VPWR VPWR clknet_1_1__leaf_net552
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c547_A3 net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc609 clknet_1_0__leaf_net501 net445 clknet_1_0__leaf_net387 clknet_1_1__leaf_net498
+ clknet_1_0__leaf_net780 net839 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__mux4_1
XANTENNA_c563_A2 net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s888_Q net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c100_B1 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c161_S0 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net742 net742 VGND VGND VPWR VPWR clknet_0_net742 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_23_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c192_A3 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c336_S0 net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net619 clknet_0_net619 VGND VGND VPWR VPWR clknet_1_0__leaf_net619
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c664_A1 net309 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap161_X net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c680_B1 net549 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge821_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c558_A2 net440 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c574_A1 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc417 net319 net318 net982 net672 net756 net792 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__mux4_1
Xc406 net306 net311 net308 net314 net995 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__a41oi_4
Xc428 clknet_4_5_0_clk net104 net334 net345 net876 net109 VGND VGND VPWR VPWR net347
+ net346 sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_13_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c590_A0 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc439 net215 net358 net356 net1038 net325 net699 VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_28_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c187_A3 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c484_A1 net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net561 net561 VGND VGND VPWR VPWR clknet_0_net561 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input41_X net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c394_A1 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c704_S0 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c288_A2 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net972 clknet_0_net972 VGND VGND VPWR VPWR clknet_1_0__leaf_net972
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_81_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net961 clknet_0_net961 VGND VGND VPWR VPWR clknet_1_0__leaf_net961
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout159_X net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c585_A0 net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c418_Y net333 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c313_X net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_28_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc203 net132 net115 net877 net110 net135 net1027 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__mux4_2
Xc236 net163 net160 net167 clknet_1_1__leaf_net144 clknet_1_1__leaf_net971 net166
+ VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__mux4_1
Xc225 net895 net29 net1050 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__a21boi_1
Xc214 net146 clknet_1_0__leaf_net141 net148 net126 net1 clknet_1_1__leaf_net765 VGND
+ VGND VPWR VPWR net150 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_79_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc247 net952 net964 net1037 clknet_1_0__leaf_net181 net1012 net763 VGND VGND VPWR
+ VPWR net940 sky130_fd_sc_hd__mux4_4
Xc258 clknet_1_0__leaf_net975 clknet_1_1__leaf_net940 clknet_1_0__leaf_net187 net724
+ net749 net773 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__mux4_1
XANTENNA_c751_A2 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc269 net920 net863 net999 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__o21bai_4
XANTENNA_c470_A3 net755 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c614_S0 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c437_Q net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge768 net980 net1035 net979 net823 net825 VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__a41oi_1
Xmerge779 net468 net474 VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__xnor2_4
XFILLER_0_55_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs874 clknet_4_15_0_clk net65 VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__dfxtp_2
Xs885 net190 clknet_4_15_0_clk VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_83_579 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c428_SET_B net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs896 net289 clknet_4_14_0_clk VGND VGND VPWR VPWR net784 net783 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput6 in13 VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__buf_2
XANTENNA_s929_GATE_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c243_S1 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c529_B1_N net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout119_A net440 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c571_A2 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c290_A3 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c270_Y net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c299_A1 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c528_X net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net780 clknet_0_net780 VGND VGND VPWR VPWR clknet_1_0__leaf_net780
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c465_A3 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c66_B net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input49_A in52 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge830_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c566_A2 net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c223_A net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c285_A3 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c582_A1 net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c429_S0 net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s912_GATE_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c492_A1 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge803_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c291_SET_B net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput31 in36 VGND VGND VPWR VPWR net891 sky130_fd_sc_hd__buf_1
XFILLER_0_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput20 in26 VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__clkbuf_2
Xinput53 in56 VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__buf_1
Xinput42 in46 VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_101_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c712_S0 net549 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c577_A1 net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout141_X net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c593_A0 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net957_X clknet_1_1__leaf_net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net957 net957 VGND VGND VPWR VPWR clknet_0_net957 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net935 net935 VGND VGND VPWR VPWR clknet_0_net935 sky130_fd_sc_hd__clkbuf_16
XANTENNA_s879_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c400_Y net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c80_A4 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c462_A4 net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c487_A1 net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c81_X net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c563_A3 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c183_Y net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c176_X net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c588_A0 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c442_S0 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c161_S1 net696 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_0_net765 net765 VGND VGND VPWR VPWR clknet_0_net765 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net743 net743 VGND VGND VPWR VPWR clknet_0_net743 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_23_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c754_A2 net738 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input31_A in36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c336_S1 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c498_A0 clknet_1_1__leaf_net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output118_A net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c352_S0 net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge861_Q net745 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net383 clknet_0_net383 VGND VGND VPWR VPWR clknet_1_1__leaf_net383
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c558_A3 net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout149_A net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c574_A2 clknet_1_0__leaf_net711 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c293_A3 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc418 net730 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__inv_2
Xc407 net315 net317 net319 net716 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__a31oi_4
XFILLER_0_13_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap161 net833 VGND VGND VPWR VPWR net1021 sky130_fd_sc_hd__buf_4
Xc429 net1038 net337 net326 net990 net343 net346 VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__mux4_2
XFILLER_0_40_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c398_Y net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c484_A2 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c347_S0 net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c287_SCD net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c691_A0 net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c569_A2 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c288_A3 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net940 clknet_0_net940 VGND VGND VPWR VPWR clknet_1_0__leaf_net940
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_81_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c585_A1 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c720_S0 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc204 clknet_4_13_0_clk net112 net21 net131 net934 net5 VGND VGND VPWR VPWR net139
+ net138 sky130_fd_sc_hd__sdfbbn_1
Xc215 net21 net16 net1033 net138 clknet_1_0__leaf_net144 clknet_1_0__leaf_net766 VGND
+ VGND VPWR VPWR net151 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_79_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc226 net955 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_92_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc248 clknet_1_1__leaf_net181 clknet_1_0__leaf_net940 net58 net749 net1072 VGND VGND
+ VPWR VPWR net183 sky130_fd_sc_hd__a41oi_2
Xc259 net47 net180 clknet_1_0__leaf_net187 clknet_1_0__leaf_net975 clknet_1_0__leaf_net940
+ net762 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__mux4_4
Xc237 clknet_1_0__leaf_net162 net167 net170 clknet_1_0__leaf_net971 net665 net764
+ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__mux4_2
XFILLER_0_40_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c332_Q net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c495_A1 net710 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge769 net255 net247 net1034 net114 clknet_1_1__leaf_net249 net648 VGND VGND VPWR
+ VPWR net643 sky130_fd_sc_hd__mux4_1
XANTENNA_c630_S0 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xs875 clknet_4_7_0_clk net95 VGND VGND VPWR VPWR net965 sky130_fd_sc_hd__dfxtp_1
Xs886 net191 clknet_4_15_0_clk VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__dlxtp_1
Xs897 net291 clknet_4_10_0_clk VGND VGND VPWR VPWR net786 net785 sky130_fd_sc_hd__dlxbn_2
XFILLER_0_63_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c213_CLK_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc760 net631 net702 net744 net750 net845 net849 VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__mux4_4
Xinput7 in14 VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c540_S0 net982 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c571_A3 net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c290_A4 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c299_A2 net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net781 clknet_0_net781 VGND VGND VPWR VPWR clknet_1_0__leaf_net781
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c450_S0 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c481_A3 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c625_S0 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c344_S1 net129 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_1_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc590 net988 clknet_1_0__leaf_net470 net1044 clknet_1_0__leaf_net476 net836 net838
+ VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__mux4_1
XANTENNA_c414_SCD net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_35_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c566_A3 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_65_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c63_S0 net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c427_SET_B net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c103_A1 net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_74_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c757_A2 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_98_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input61_A in8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c355_S0 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_92_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_49_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c667_A2 net745 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput21 in27 VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__clkbuf_1
Xinput10 in17 VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__buf_2
XANTENNA_c683_A1 net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput43 in47 VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__clkbuf_2
Xinput54 in57 VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__clkbuf_4
Xinput32 in37 VGND VGND VPWR VPWR net892 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c333_A net755 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c296_A3 net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net925 net925 VGND VGND VPWR VPWR clknet_0_net925 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c226_Y net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c159_S1 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c89_A3 net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c487_A2 net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c412_Q net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c74_X net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net510 clknet_0_net510 VGND VGND VPWR VPWR clknet_1_1__leaf_net510
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net521 clknet_0_net521 VGND VGND VPWR VPWR clknet_1_1__leaf_net521
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net587 clknet_0_net587 VGND VGND VPWR VPWR clknet_1_1__leaf_net587
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net598 clknet_0_net598 VGND VGND VPWR VPWR clknet_1_1__leaf_net598
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net576 clknet_0_net576 VGND VGND VPWR VPWR clknet_1_1__leaf_net576
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_55 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c707_S1 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c169_X net103 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c723_S0 net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_84_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c442_S1 clknet_1_0__leaf_net711 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c336_X net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net711 net711 VGND VGND VPWR VPWR clknet_0_net711 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net766 net766 VGND VGND VPWR VPWR clknet_0_net766 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_23_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c617_S1 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input24_A in3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge770_S0 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge850_GATE_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c498_A1 net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge854_Q net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output92_A net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c293_A4 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc408 net312 net307 net318 net306 net1063 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__a41oi_2
Xc419 net87 net1038 net988 net1071 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__a31oi_4
XANTENNA_c718_S0 net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c590_A2 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_6_0_clk_X clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c293_Y net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c599_A0 net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s942_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net552 net552 VGND VGND VPWR VPWR clknet_0_net552 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net574 net574 VGND VGND VPWR VPWR clknet_0_net574 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net563 net563 VGND VGND VPWR VPWR clknet_0_net563 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c484_A3 clknet_1_1__leaf_net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c628_S0 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input27_X net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c363_S0 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net407 clknet_0_net407 VGND VGND VPWR VPWR clknet_1_0__leaf_net407
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s885_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c394_A3 net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c287_SCE net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c691_A1 net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_10_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c212_A0 net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net181 clknet_0_net181 VGND VGND VPWR VPWR clknet_1_1__leaf_net181
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c569_A3 net685 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c585_A2 clknet_1_0__leaf_net711 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s924_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc216 clknet_1_1__leaf_net147 net1033 net148 net135 clknet_1_0__leaf_net144 clknet_1_0__leaf_net766
+ VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__mux4_4
Xc205 clknet_1_1__leaf_net121 net915 net1003 net1036 net1012 clknet_1_0__leaf_net765
+ VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_79_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc227 net1017 clknet_1_0__leaf_net125 clknet_1_0__leaf_net156 net4 net764 VGND VGND
+ VPWR VPWR net162 sky130_fd_sc_hd__a41oi_4
XFILLER_0_13_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s906_Q net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_92_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc249 net914 clknet_1_0__leaf_net940 net873 net997 net748 VGND VGND VPWR VPWR net184
+ sky130_fd_sc_hd__a41oi_2
Xc238 net158 clknet_1_1__leaf_net162 net167 net164 net771 VGND VGND VPWR VPWR net173
+ sky130_fd_sc_hd__a41oi_2
XANTENNA_c448_S0 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c106_A1 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c479_A3 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c325_Q net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c495_A2 net949 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs876 clknet_4_7_0_clk net99 VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__dfxtp_4
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs898 net292 clknet_4_14_0_clk VGND VGND VPWR VPWR net788 net787 sky130_fd_sc_hd__dlxbp_1
Xs887 net212 clknet_4_5_0_clk VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__lpflow_inputisolatch_1
XANTENNA_c358_S0 net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge823_GATE clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc750 clknet_1_1__leaf_net613 clknet_1_0__leaf_net621 clknet_1_1__leaf_net593 net1026
+ net837 net845 VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__mux4_1
Xc761 net739 net744 net751 net840 net844 net860 VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__mux4_1
Xinput8 in15 VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__buf_4
XFILLER_0_36_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c686_A1 net359 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c540_S1 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s906_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_2_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c596_A1 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net782 clknet_0_net782 VGND VGND VPWR VPWR clknet_1_0__leaf_net782
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_37_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c450_S1 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c178_S0 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net939 clknet_0_net939 VGND VGND VPWR VPWR clknet_1_1__leaf_net939
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_95_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_14_0_clk_X clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c672_A3 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc591 clknet_1_1__leaf_net470 clknet_1_1__leaf_net485 net220 clknet_1_0__leaf_net476
+ net723 net758 VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__mux4_2
Xc580 clknet_1_0__leaf_net470 net988 net1029 net873 net728 VGND VGND VPWR VPWR net475
+ sky130_fd_sc_hd__a41oi_1
XFILLER_0_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c697_A0 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_35_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout124_A net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c582_A3 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c63_S1 net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c445_S1 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c71_B net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c492_A3 clknet_1_1__leaf_net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input54_A in57 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c636_S0 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c355_S1 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c332_SCD net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput11 in18 VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__clkbuf_2
Xinput22 in28 VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__dlymetal6s2s_1
XANTENNA_c683_A2 net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput44 in48 VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__buf_1
Xinput33 in38 VGND VGND VPWR VPWR net893 sky130_fd_sc_hd__clkbuf_1
Xinput55 in58 VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__buf_1
XFILLER_0_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c399_SCD net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c577_A3 net735 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c281_S0 net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c296_A4 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout127_X net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c682_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c114_A1 net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input1_X net861 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c434_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c191_S0 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c67_X net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input57_X net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c366_S0 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net500 clknet_0_net500 VGND VGND VPWR VPWR clknet_1_1__leaf_net500
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net544 clknet_0_net544 VGND VGND VPWR VPWR clknet_1_1__leaf_net544
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net588 clknet_0_net588 VGND VGND VPWR VPWR clknet_1_1__leaf_net588
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net577 clknet_0_net577 VGND VGND VPWR VPWR clknet_1_1__leaf_net577
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c553_SCD net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c276_S0 net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_2_0_clk_X clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c231_X net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c329_X net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c109_A1 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c186_S0 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input17_A in23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge770_S1 net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c633_S1 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output85_A net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c689_A1 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c543_S1 net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net374 clknet_0_net374 VGND VGND VPWR VPWR clknet_1_1__leaf_net374
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net385 clknet_0_net385 VGND VGND VPWR VPWR clknet_1_1__leaf_net385
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c574_A4 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc409 clknet_4_4_0_clk net321 net983 net309 net306 net318 VGND VGND VPWR VPWR net978
+ net322 sky130_fd_sc_hd__sdfbbp_1
XANTENNA_input9_A in16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c734_S0 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c111_A2 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c628_S1 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge860_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c302_A1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c229_RESET_B net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c554_S0 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c212_A1 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_53_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net942 clknet_0_net942 VGND VGND VPWR VPWR clknet_1_0__leaf_net942
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_81_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net975 clknet_0_net975 VGND VGND VPWR VPWR clknet_1_0__leaf_net975
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc217 net139 clknet_1_1__leaf_net140 net1033 clknet_1_1__leaf_net144 net148 clknet_1_1__leaf_net765
+ VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__mux4_1
Xc206 net905 net21 net1005 net19 clknet_1_0__leaf_net765 VGND VGND VPWR VPWR net141
+ sky130_fd_sc_hd__a41oi_2
XTAP_TAPCELL_ROW_79_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc228 net689 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__inv_1
Xc239 net167 net40 net164 clknet_1_1__leaf_net156 net693 net764 VGND VGND VPWR VPWR
+ net174 sky130_fd_sc_hd__mux4_1
XANTENNA_merge842_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs877 clknet_4_13_0_clk net136 VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__dlclkp_1
XFILLER_0_36_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net383 net383 VGND VGND VPWR VPWR clknet_0_net383 sky130_fd_sc_hd__clkbuf_16
Xs888 clknet_4_5_0_clk net216 VGND VGND VPWR VPWR net776 net775 sky130_fd_sc_hd__dfxbp_2
Xs899 net295 clknet_4_14_0_clk VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_23_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c358_S1 clknet_1_1__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc740 net1020 clknet_1_0__leaf_net510 net550 clknet_1_0__leaf_net613 net855 net858
+ VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__mux4_2
Xc751 net75 clknet_1_0__leaf_net623 net315 clknet_1_0__leaf_net821 net837 net856 VGND
+ VGND VPWR VPWR net625 sky130_fd_sc_hd__mux4_1
Xc762 net873 net610 clknet_1_0__leaf_net299 net635 net744 net750 VGND VGND VPWR VPWR
+ net636 sky130_fd_sc_hd__mux4_2
XANTENNA_merge833_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c313_B1 net757 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_10_0_clk_X clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput9 in16 VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__buf_1
Xclkbuf_1_0__f_net249 clknet_0_net249 VGND VGND VPWR VPWR clknet_1_0__leaf_net249
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c686_A2 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c549_S0 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s901_GATE_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c299_A4 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c596_A2 net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout157_X net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c144_X net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c437_Q_N net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c178_S1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c133_B1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c97_X net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c308_B1 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c369_S0 net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc570 net464 net209 net465 net435 net829 net830 VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__mux4_4
Xc581 net1030 net465 net358 clknet_1_1__leaf_net470 net832 net833 VGND VGND VPWR VPWR
+ net476 sky130_fd_sc_hd__mux4_2
Xc592 net483 clknet_1_1__leaf_net485 net703 net810 net1023 net832 VGND VGND VPWR VPWR
+ net487 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c697_A1 net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_35_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput110 net970 VGND VGND VPWR VPWR out56 sky130_fd_sc_hd__buf_2
XFILLER_0_100_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_87_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c189_S0 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input47_A in50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput12 in19 VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__clkbuf_8
XANTENNA_c332_SCE net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput45 in49 VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__buf_4
Xinput23 in29 VGND VGND VPWR VPWR net883 sky130_fd_sc_hd__clkbuf_1
Xinput34 in39 VGND VGND VPWR VPWR net894 sky130_fd_sc_hd__buf_1
Xinput56 in59 VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__buf_2
XFILLER_0_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c399_SCE net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c501_A0 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c220_A1 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c562_S0 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c319_A net755 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c593_A3 net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c277_RESET_B net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c411_A0 net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c472_S0 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c191_S1 net647 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c198_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c366_S1 net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net501 clknet_0_net501 VGND VGND VPWR VPWR clknet_1_1__leaf_net501
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c321_B1 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net545 clknet_0_net545 VGND VGND VPWR VPWR clknet_1_1__leaf_net545
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c678_A3 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c694_A2 net549 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c231_B1 net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout184_A net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c406_B1 net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c186_S1 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c316_B1 net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output78_A net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c689_A2 net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c682_RESET_B net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c303_D net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net925_X clknet_1_0__leaf_net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c599_A2 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c750_S0 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net510 net510 VGND VGND VPWR VPWR clknet_0_net510 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net521 net521 VGND VGND VPWR VPWR clknet_0_net521 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c325_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net587 net587 VGND VGND VPWR VPWR clknet_0_net587 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net576 net576 VGND VGND VPWR VPWR clknet_0_net576 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net598 net598 VGND VGND VPWR VPWR clknet_0_net598 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c427_RESET_B net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c675_A4 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net932 clknet_0_net932 VGND VGND VPWR VPWR clknet_1_0__leaf_net932
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_53_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net943 clknet_0_net943 VGND VGND VPWR VPWR clknet_1_0__leaf_net943
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_15_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout147_A net533 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c555_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc218 clknet_1_0__leaf_net140 clknet_1_1__leaf_net151 net135 net690 clknet_1_1__leaf_net765
+ clknet_1_0__leaf_net972 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__mux4_2
Xc207 clknet_4_13_0_clk net134 net1051 net985 net986 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__sdfrtn_1
XFILLER_0_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_92_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc229 clknet_4_15_0_clk net42 net1017 net163 clknet_1_1__leaf_net159 net1069 VGND
+ VGND VPWR VPWR net936 net164 sky130_fd_sc_hd__sdfbbp_1
XANTENNA_c106_A3 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c745_S0 net710 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c480_S0 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_101_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xs878 clknet_4_13_0_clk net150 VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__dlclkp_2
XANTENNA_c213_Q net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs889 clknet_4_7_0_clk net221 VGND VGND VPWR VPWR net949 net777 sky130_fd_sc_hd__dfxbp_2
XFILLER_0_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc730 clknet_1_0__leaf_net387 net1020 net567 net550 clknet_1_0__leaf_net781 clknet_1_1__leaf_net843
+ VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__mux4_2
Xc741 clknet_1_1__leaf_net605 net611 net594 clknet_1_0__leaf_net613 net740 net852
+ VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__mux4_2
Xc763 clknet_1_0__leaf_net519 net1045 clknet_1_1__leaf_net636 net702 clknet_1_0__leaf_net821
+ net860 VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__mux4_2
Xc752 net518 clknet_1_1__leaf_net490 net315 clknet_1_1__leaf_net623 clknet_1_1__leaf_net821
+ net1021 VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__mux4_2
XFILLER_0_86_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c77_S1 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c475_S0 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net181 net181 VGND VGND VPWR VPWR clknet_0_net181 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c324_RESET_B net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc571 net461 net451 net1030 net465 net830 net1023 VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__mux4_2
Xc582 net258 net984 clknet_1_0__leaf_net476 net810 net1023 net832 VGND VGND VPWR VPWR
+ net477 sky130_fd_sc_hd__mux4_2
Xc560 net861 net982 net991 net450 c560/S0 net756 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__mux4_1
Xc593 net1030 clknet_1_1__leaf_net476 clknet_1_1__leaf_net485 net465 net703 net710
+ VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__mux4_4
XPHY_EDGE_ROW_16_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_25_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput100 net960 VGND VGND VPWR VPWR out45 sky130_fd_sc_hd__buf_2
XFILLER_0_30_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput111 clknet_1_1__leaf_net971 VGND VGND VPWR VPWR out57 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c295_S0 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_87_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net570 clknet_0_net570 VGND VGND VPWR VPWR clknet_1_0__leaf_net570
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_43_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_98_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c144_B1 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_61_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput13 in2 VGND VGND VPWR VPWR net873 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_40_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput24 in3 VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__buf_2
Xinput35 in4 VGND VGND VPWR VPWR net895 sky130_fd_sc_hd__clkbuf_4
Xinput46 in5 VGND VGND VPWR VPWR net906 sky130_fd_sc_hd__buf_2
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput57 in6 VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__buf_2
XFILLER_0_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c501_A1 net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c562_S1 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c220_A2 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net939 net939 VGND VGND VPWR VPWR clknet_0_net939 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_43_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c753_S0 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_97_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c130_A2 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c139_A0 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c602_A0 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net568 clknet_0_net568 VGND VGND VPWR VPWR clknet_1_1__leaf_net568
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout177_A net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s954_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout132_X net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c109_A3 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c483_S0 net718 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c232_SCE net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge826_GATE clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c393_S0 clknet_1_1__leaf_net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c689_A3 net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net387 clknet_0_net387 VGND VGND VPWR VPWR clknet_1_1__leaf_net387
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s936_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c242_B1 net724 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c599_A3 net861 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c174_Y net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s947_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c334_X net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net500 net500 VGND VGND VPWR VPWR clknet_0_net500 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net544 net544 VGND VGND VPWR VPWR clknet_0_net544 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net588 net588 VGND VGND VPWR VPWR clknet_0_net588 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net577 net577 VGND VGND VPWR VPWR clknet_0_net577 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c478_S0 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c152_A0 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input22_A in28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c327_A0 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge852_Q net735 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output90_A net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net140 clknet_0_net140 VGND VGND VPWR VPWR clknet_1_1__leaf_net140
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net151 clknet_0_net151 VGND VGND VPWR VPWR clknet_1_1__leaf_net151
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net162 clknet_0_net162 VGND VGND VPWR VPWR clknet_1_1__leaf_net162
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_53_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s909_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_81_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc208 net135 net139 net1032 net22 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__a31o_1
XFILLER_0_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc219 clknet_1_0__leaf_net151 clknet_1_0__leaf_net144 net1033 net135 clknet_1_1__leaf_net145
+ clknet_1_0__leaf_net972 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_5_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs879 clknet_4_13_0_clk net153 VGND VGND VPWR VPWR net972 sky130_fd_sc_hd__dlclkp_4
Xclkbuf_0_net374 net374 VGND VGND VPWR VPWR clknet_0_net374 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c318_S clknet_1_0__leaf_net711 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net385 net385 VGND VGND VPWR VPWR clknet_0_net385 sky130_fd_sc_hd__clkbuf_16
Xc731 net549 net750 clknet_1_0__leaf_net781 net811 net844 net854 VGND VGND VPWR VPWR
+ net605 sky130_fd_sc_hd__mux4_1
Xc720 net567 net315 net1012 net727 net1022 net851 VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__mux4_2
Xc742 net615 clknet_1_0__leaf_net605 net740 net809 net856 net857 VGND VGND VPWR VPWR
+ net616 sky130_fd_sc_hd__mux4_4
Xc753 clknet_1_0__leaf_net299 net622 net610 net998 net1026 net854 VGND VGND VPWR VPWR
+ net627 sky130_fd_sc_hd__mux4_2
Xc764 net635 clknet_1_0__leaf_net636 clknet_1_1__leaf_net623 net702 net706 net738
+ VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__mux4_4
XANTENNA_c313_A2 net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input25_X net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c610_A0 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c671_S0 net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_467 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c504_A1 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c475_S1 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c491_S0 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c308_A2 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c605_A0 net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc572 net465 net981 clknet_1_0__leaf_net378 net712 net716 net1023 VGND VGND VPWR VPWR
+ net468 sky130_fd_sc_hd__mux4_1
Xc550 net992 net426 net978 net991 net1035 net666 VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__mux4_4
Xc561 net326 net982 net998 net446 net453 net450 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__mux4_1
Xc583 clknet_1_0__leaf_net471 net320 net987 net872 net719 net834 VGND VGND VPWR VPWR
+ net478 sky130_fd_sc_hd__mux4_1
Xc594 net455 clknet_1_1__leaf_net476 net987 clknet_1_1__leaf_net387 net776 clknet_1_1__leaf_net781
+ VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__mux4_4
XFILLER_0_47_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput101 clknet_1_1__leaf_net961 VGND VGND VPWR VPWR out46 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput112 clknet_1_1__leaf_net972 VGND VGND VPWR VPWR out59 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c234_A1 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c295_S1 net685 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout162_X net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net593 clknet_0_net593 VGND VGND VPWR VPWR clknet_1_0__leaf_net593
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net571 clknet_0_net571 VGND VGND VPWR VPWR clknet_1_0__leaf_net571
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c486_S0 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c160_A0 net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput36 in40 VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__clkbuf_4
Xinput14 in20 VGND VGND VPWR VPWR net874 sky130_fd_sc_hd__clkbuf_4
Xinput25 in30 VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__clkbuf_2
Xinput47 in50 VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__buf_1
Xinput58 in60 VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__buf_1
XFILLER_0_12_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_48_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c220_A3 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout122_A net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c245_B1 clknet_1_1__leaf_net766 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c130_A3 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c629_X net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_159 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s897_GATE_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input52_A in55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c305_A3 net993 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c240_SET_B net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c602_A1 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net547 clknet_0_net547 VGND VGND VPWR VPWR clknet_1_1__leaf_net547
+ sky130_fd_sc_hd__clkbuf_16
Xfanout180 net1041 VGND VGND VPWR VPWR net1040 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_44_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c231_A2 net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_7_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_84_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout125_X net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s890_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c764_S0 net706 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c483_S1 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c403_Q net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c65_X net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c316_A2 net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s880_GATE_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmax_cap166 net772 VGND VGND VPWR VPWR net1026 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_96_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s872_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net501 net501 VGND VGND VPWR VPWR clknet_0_net501 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_net545 net545 VGND VGND VPWR VPWR clknet_0_net545 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c136_A2 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input15_A in21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c608_A0 net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c327_A1 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net141 clknet_0_net141 VGND VGND VPWR VPWR clknet_1_1__leaf_net141
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net152 clknet_0_net152 VGND VGND VPWR VPWR clknet_1_1__leaf_net152
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net174 clknet_0_net174 VGND VGND VPWR VPWR clknet_1_1__leaf_net174
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_81_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net956 clknet_0_net956 VGND VGND VPWR VPWR clknet_1_0__leaf_net956
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c332_CLK_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc209 net16 net134 net138 clknet_1_0__leaf_net141 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__a31oi_2
XTAP_TAPCELL_ROW_92_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input7_A in14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c284_Y net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c700_A1 net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc710 net1007 clknet_1_0__leaf_net485 clknet_1_1__leaf_net570 net708 net834 net848
+ VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__mux4_2
Xc721 clknet_1_0__leaf_net485 net1047 net727 net848 net850 net851 VGND VGND VPWR VPWR
+ net595 sky130_fd_sc_hd__mux4_2
Xc743 clknet_1_0__leaf_net510 net740 net809 clknet_1_1__leaf_net843 net847 net857
+ VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__mux4_2
Xc732 net602 net758 clknet_1_0__leaf_net781 net811 net853 net854 VGND VGND VPWR VPWR
+ net606 sky130_fd_sc_hd__mux4_2
Xc754 net315 clknet_1_0__leaf_net299 net738 net753 clknet_1_1__leaf_net821 net849
+ VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__mux4_4
XANTENNA_clkbuf_4_15_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c313_A3 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c679_Q_N net549 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_582 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c338_B1 net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_78_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c581_S1 net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_38_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net742 clknet_0_net742 VGND VGND VPWR VPWR clknet_1_0__leaf_net742
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout152_A net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c133_A3 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge822_GATE_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c430_A1 net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c491_S1 net949 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc540 net427 net318 net433 net998 net982 net1000 VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__mux4_1
Xc573 net465 net1027 net1023 VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__a21o_1
Xc562 net451 net446 net1000 net357 net998 net827 VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__mux4_1
Xc551 net1006 net343 net1029 net1019 net795 VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__a41oi_4
Xc595 net5 net220 net928 net1040 clknet_1_0__leaf_net780 net931 VGND VGND VPWR VPWR
+ net490 sky130_fd_sc_hd__mux4_1
Xc584 net320 net445 net987 net810 net832 net836 VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__mux4_1
XANTENNA_merge808_Q net685 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c218_A3 net690 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput113 net973 VGND VGND VPWR VPWR out6 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput102 net962 VGND VGND VPWR VPWR out47 sky130_fd_sc_hd__buf_2
XFILLER_0_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge776_CLK_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c592_S0 net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net561 clknet_0_net561 VGND VGND VPWR VPWR clknet_1_0__leaf_net561
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c142_X net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s934_GATE clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c113_B1_N net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput37 in41 VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__buf_1
Xinput26 in31 VGND VGND VPWR VPWR net886 sky130_fd_sc_hd__clkbuf_4
Xinput15 in21 VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_12_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c616_A0 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput48 in51 VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__buf_1
Xinput59 in61 VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c677_S0 net745 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c335_A1 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc370 clknet_1_0__leaf_net296 net161 net899 clknet_1_1__leaf_net782 net788 net789
+ VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__mux4_1
Xc392 net41 net985 clknet_1_1__leaf_net940 clknet_1_1__leaf_net975 net924 net748 VGND
+ VGND VPWR VPWR net304 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_48_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c220_A4 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_4_3_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c245_A1 net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c411_A3 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c531_Y net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_500 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c155_A1 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input45_A in49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c235_SCD net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c171_B1 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c602_A2 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout181 net891 VGND VGND VPWR VPWR net1041 sky130_fd_sc_hd__buf_4
XANTENNA_c321_A3 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c670_CLK_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c685_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c346_A0 net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_84_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c105_X net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c764_S1 net738 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge809_A net644 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c229_Q net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_49_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c316_A3 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c613_A1 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_58_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net378 clknet_0_net378 VGND VGND VPWR VPWR clknet_1_1__leaf_net378
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_71_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s913_GATE_N clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c584_S1 net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c242_A2 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout182_A net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c105_S0 net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge790_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net568 net568 VGND VGND VPWR VPWR clknet_0_net568 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c417_A2 net982 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c433_A1 net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_11_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c624_A0 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge838_Q net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c343_A1 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output76_A net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net120 clknet_0_net120 VGND VGND VPWR VPWR clknet_1_1__leaf_net120
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net935 clknet_0_net935 VGND VGND VPWR VPWR clknet_1_0__leaf_net935
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_81_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net957 clknet_0_net957 VGND VGND VPWR VPWR clknet_1_0__leaf_net957
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c409_RESET_B net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_92_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c534_B1 net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c670_D net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout185_X net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge845_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c147_A2 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net387 net387 VGND VGND VPWR VPWR clknet_0_net387 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c62_A0 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc711 net567 net315 net557 net992 net708 net809 VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__mux4_1
Xc722 net758 net1027 net846 net850 net851 net852 VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__mux4_1
Xc700 net531 net343 clknet_1_0__leaf_net570 net830 clknet_1_1__leaf_net841 clknet_1_1__leaf_net842
+ VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__mux4_2
XANTENNA_c163_A1 net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc744 clknet_1_0__leaf_net616 net868 clknet_1_0__leaf_net613 net731 net856 net859
+ VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__mux4_2
Xc755 net624 clknet_1_0__leaf_net519 net702 clknet_1_0__leaf_net821 net1021 net845
+ VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__mux4_2
Xc733 net567 net550 net750 net753 net758 net849 VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__mux4_1
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_98_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c619_A0 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c338_A1 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c504_A3 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_hold16_A net734 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net743 clknet_0_net743 VGND VGND VPWR VPWR clknet_1_0__leaf_net743
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net765 clknet_0_net765 VGND VGND VPWR VPWR clknet_1_0__leaf_net765
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout145_A net129 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c711_A1 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c439_A0 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net140 net140 VGND VGND VPWR VPWR clknet_0_net140 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net151 net151 VGND VGND VPWR VPWR clknet_0_net151 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net162 net162 VGND VGND VPWR VPWR clknet_0_net162 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c174_B1 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc530 net872 net1000 net423 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__a21oi_4
Xc541 net433 net428 net429 net427 net923 VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__a41oi_4
Xc563 net444 net995 net979 net1006 net450 net445 VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__mux4_1
Xc552 net445 net358 net1040 net1000 net359 net1028 VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__mux4_2
Xc574 net357 clknet_1_0__leaf_net711 net719 net1027 net1023 VGND VGND VPWR VPWR net932
+ sky130_fd_sc_hd__a41oi_4
Xc585 net981 net1040 clknet_1_0__leaf_net711 clknet_1_0__leaf_net780 net807 net837
+ VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__mux4_2
Xc596 clknet_1_1__leaf_net378 net999 net445 clknet_1_1__leaf_net476 net219 clknet_1_1__leaf_net387
+ VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__mux4_4
XANTENNA_c621_A1 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c340_A2 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c535_B1_N net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_35_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_586 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s886_GATE clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput114 net974 VGND VGND VPWR VPWR out60 sky130_fd_sc_hd__clkbuf_4
Xoutput103 net963 VGND VGND VPWR VPWR out48 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c531_A1 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c668_SET_B net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c250_A2 clknet_1_1__leaf_net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c407_Y net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c144_A3 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c441_A1 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_21_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c160_A2 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c95_Y net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput27 in32 VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_12_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput16 in22 VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__clkbuf_2
Xinput49 in52 VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput38 in42 VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__dlymetal6s2s_1
XANTENNA_c616_A1 clknet_1_0__leaf_net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc360 net268 clknet_1_0__leaf_net971 net997 clknet_1_1__leaf_net972 clknet_1_1__leaf_net782
+ net783 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__mux4_1
Xc371 clknet_1_0__leaf_net296 clknet_1_1__leaf_net297 clknet_1_1__leaf_net299 clknet_1_1__leaf_net925
+ net680 net789 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__mux4_4
XANTENNA_c632_A0 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc393 net204 clknet_1_0__leaf_net961 net969 net970 clknet_1_1__leaf_net766 net960
+ VGND VGND VPWR VPWR net968 sky130_fd_sc_hd__mux4_2
XANTENNA_c351_A1 net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge870 clknet_4_7_0_clk net232 net674 VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__dfstp_4
XFILLER_0_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c587_S1 net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c261_A1 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c70_B1 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c235_SCE net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input38_A in42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c602_A3 net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout182 net887 VGND VGND VPWR VPWR net1042 sky130_fd_sc_hd__clkbuf_8
Xfanout160 net128 VGND VGND VPWR VPWR net1020 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_17_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c627_A0 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge868_Q net755 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c688_S0 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c346_A1 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c362_A0 net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc190 net902 clknet_1_1__leaf_net122 clknet_1_0__leaf_net120 net1005 net128 c190/S1
+ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__mux4_4
XFILLER_0_85_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s939_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c598_S0 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c406_A4 net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c703_A2 net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c447_A0 net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c166_A1 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c422_SET_B net333 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_72_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c613_A2 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold5 net665 VGND VGND VPWR VPWR net1050 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c690_S1 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c211_S0 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout175_A net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net547 net547 VGND VGND VPWR VPWR clknet_0_net547 sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout130_X net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c433_A2 net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_4_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input60_X net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output69_A net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net121 clknet_0_net121 VGND VGND VPWR VPWR clknet_1_1__leaf_net121
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net187 clknet_0_net187 VGND VGND VPWR VPWR clknet_1_1__leaf_net187
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net925 clknet_0_net925 VGND VGND VPWR VPWR clknet_1_0__leaf_net925
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_33_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_61_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c668_SCE net309 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c595_S1 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_92_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c550_A0 net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout178_X net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_77_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c62_A1 net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_86_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc712 net2 net554 clknet_1_0__leaf_net576 net1008 net549 net848 VGND VGND VPWR VPWR
+ net586 sky130_fd_sc_hd__mux4_2
Xc701 clknet_1_0__leaf_net574 net573 clknet_1_0__leaf_net563 net1008 net566 clknet_1_1__leaf_net842
+ VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__mux4_1
Xc734 net550 clknet_1_0__leaf_net387 net868 clknet_1_1__leaf_net510 net1020 net607
+ VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__mux4_2
Xc723 net596 clknet_1_1__leaf_net588 net1008 net549 net809 net851 VGND VGND VPWR VPWR
+ net597 sky130_fd_sc_hd__mux4_1
Xc745 clknet_1_1__leaf_net606 net998 clknet_1_0__leaf_net618 clknet_1_0__leaf_net616
+ net710 net859 VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__mux4_2
Xc756 net998 net628 clknet_1_0__leaf_net623 net750 net849 net860 VGND VGND VPWR VPWR
+ net630 sky130_fd_sc_hd__mux4_1
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input20_A in26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_95_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c610_A3 net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c619_A1 net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output107_A net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c314_B1_N net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c338_A2 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c696_S0 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge850_Q net734 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c354_A1 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_78_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net711 clknet_0_net711 VGND VGND VPWR VPWR clknet_1_0__leaf_net711
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net766 clknet_0_net766 VGND VGND VPWR VPWR clknet_1_0__leaf_net766
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c529_A1 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout138_A net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net956_A net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c430_A3 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c439_A1 net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c73_B1 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net141 net141 VGND VGND VPWR VPWR clknet_0_net141 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net174 net174 VGND VGND VPWR VPWR clknet_0_net174 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net152 net152 VGND VGND VPWR VPWR clknet_0_net152 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c455_A0 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc531 net1000 net424 net328 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__o21bai_4
Xc542 net432 net426 net427 net424 net423 net747 VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__mux4_1
Xc564 net426 net429 net981 net446 net453 net827 VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__mux4_4
Xc553 clknet_4_1_0_clk net446 net431 net357 net345 net987 VGND VGND VPWR VPWR net448
+ net447 sky130_fd_sc_hd__sdfbbn_1
Xc597 net234 clknet_1_0__leaf_net385 net734 net738 clknet_1_1__leaf_net781 net818
+ VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__mux4_1
Xc586 clknet_1_0__leaf_net476 clknet_1_0__leaf_net471 clknet_1_0__leaf_net470 net798
+ net832 net838 VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__mux4_4
Xc575 clknet_1_0__leaf_net251 net1029 net999 net775 net807 VGND VGND VPWR VPWR net470
+ sky130_fd_sc_hd__a41oi_2
XFILLER_0_47_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c340_A3 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_35_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c349_A1 net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c203_S1 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c365_A0 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput104 net964 VGND VGND VPWR VPWR out49 sky130_fd_sc_hd__clkbuf_4
Xoutput115 clknet_1_1__leaf_net975 VGND VGND VPWR VPWR out61 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c250_A3 net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net552 clknet_0_net552 VGND VGND VPWR VPWR clknet_1_0__leaf_net552
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net563 clknet_0_net563 VGND VGND VPWR VPWR clknet_1_0__leaf_net563
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net574 clknet_0_net574 VGND VGND VPWR VPWR clknet_1_0__leaf_net574
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c425_A3 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c144_A4 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c722_A1 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c441_A2 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c160_A3 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c68_B1 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput17 in23 VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__buf_1
XFILLER_0_91_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput28 in33 VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_12_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput39 in43 VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__buf_2
XANTENNA_c616_A2 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c335_A3 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc350 net268 clknet_1_1__leaf_net152 net877 net725 clknet_1_0__leaf_net972 net768
+ VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__mux4_2
Xc361 net267 net31 net268 net4 net737 net966 VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__mux4_2
Xc372 clknet_1_1__leaf_net297 clknet_1_1__leaf_net296 clknet_1_1__leaf_net925 clknet_1_1__leaf_net299
+ net748 net788 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__mux4_4
Xc394 net252 net967 c394/A2 net748 clknet_1_0__leaf_net972 net962 VGND VGND VPWR VPWR
+ net305 sky130_fd_sc_hd__mux4_1
XANTENNA_c351_A2 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c214_S0 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge871 clknet_4_2_0_clk net695 merge871/SET_B VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__dfstp_1
Xmerge860 clknet_4_0_0_clk net649 net579 VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__sdlclkp_4
XFILLER_0_70_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout160_X net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s893_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c452_A1 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout172 net142 VGND VGND VPWR VPWR net1032 sky130_fd_sc_hd__clkbuf_4
Xfanout183 net1044 VGND VGND VPWR VPWR net1043 sky130_fd_sc_hd__clkbuf_8
Xfanout150 net1012 VGND VGND VPWR VPWR net1010 sky130_fd_sc_hd__buf_4
XFILLER_0_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_17_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c627_A1 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge866_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c412_Q_N net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc180 net107 net85 net110 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__o21ai_1
Xc191 net913 clknet_1_0__leaf_net120 clknet_1_1__leaf_net122 net116 net110 net647
+ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__mux4_4
XFILLER_0_85_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c537_A1 net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_S1 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge857_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c403_Q_N net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s875_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge835_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge819_GATE clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c65_A1 net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c447_A1 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input50_A in53 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold6 net139 VGND VGND VPWR VPWR net1051 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_58_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c357_A1 net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c211_S1 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge839_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmax_cap158 net70 VGND VGND VPWR VPWR net1018 sky130_fd_sc_hd__buf_4
XFILLER_0_0_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap169 net346 VGND VGND VPWR VPWR net1029 sky130_fd_sc_hd__buf_2
XANTENNA_fanout168_A net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c548_A0 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c267_A1 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout123_X net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c714_A2 net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c433_A3 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c730_A1 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c312_S0 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s914_GATE clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c70_Y net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c624_A2 net710 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net144 clknet_0_net144 VGND VGND VPWR VPWR clknet_1_1__leaf_net144
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net122 clknet_0_net122 VGND VGND VPWR VPWR clknet_1_1__leaf_net122
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_92_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c253_A3 net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c709_A2 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c116_B1_N net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net378 net378 VGND VGND VPWR VPWR clknet_0_net378 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc702 clknet_1_1__leaf_net561 clknet_1_0__leaf_net574 net429 clknet_1_0__leaf_net570
+ net729 clknet_1_0__leaf_net843 VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__mux4_1
Xc713 net558 net550 net1008 net314 net808 clknet_1_0__leaf_net843 VGND VGND VPWR VPWR
+ net587 sky130_fd_sc_hd__mux4_2
XFILLER_0_31_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc724 net1047 net1012 net594 clknet_1_0__leaf_net593 net726 net851 VGND VGND VPWR
+ VPWR net598 sky130_fd_sc_hd__mux4_4
Xc735 net554 clknet_1_0__leaf_net387 clknet_1_1__leaf_net598 net594 net750 net855
+ VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__mux4_1
Xc746 clknet_1_1__leaf_net619 clknet_1_1__leaf_net616 net703 clknet_1_0__leaf_net781
+ net853 net859 VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__mux4_2
XANTENNA_c266_B1_N net861 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c163_A3 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc757 clknet_1_1__leaf_net593 net513 net1026 clknet_1_0__leaf_net821 net1021 net860
+ VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__mux4_2
XFILLER_0_98_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input13_A in2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c338_A3 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c635_A1 net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge843_Q net724 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c354_A2 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output81_A net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c370_A1 net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c404_D net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c561_A0 net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input5_A in12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c711_A3 net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c439_A2 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net120 net120 VGND VGND VPWR VPWR clknet_0_net120 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c736_A0 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c73_A1 net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc543 net433 net309 net423 net424 net428 net310 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__mux4_2
Xc554 net345 net978 net446 net445 net1000 net447 VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__mux4_1
Xc532 net310 net325 net747 VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__o21a_1
Xc565 net359 net358 net445 net424 net712 net829 VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__mux4_1
Xc587 clknet_1_0__leaf_net470 clknet_1_0__leaf_net471 net448 net712 net832 net836
+ VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__mux4_1
Xc598 net360 clknet_1_1__leaf_net378 net5 net422 net768 net799 VGND VGND VPWR VPWR
+ net493 sky130_fd_sc_hd__mux4_1
Xc576 net1030 net111 clknet_1_0__leaf_net470 net884 net735 VGND VGND VPWR VPWR net471
+ sky130_fd_sc_hd__a41o_1
XANTENNA_c399_Q net309 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c471_B1 net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c621_A3 net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge767_A1 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input16_X net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_63_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput116 net976 VGND VGND VPWR VPWR out7 sky130_fd_sc_hd__clkbuf_1
Xoutput105 net1027 VGND VGND VPWR VPWR out5 sky130_fd_sc_hd__buf_2
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c250_A4 net690 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout150_A net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c275_A1 net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c706_A3 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input8_X net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c664_Y net533 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c441_A3 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c68_A1 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c466_B1 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput18 in24 VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_12_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput29 in34 VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__buf_1
XFILLER_0_91_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc340 net228 net22 net268 net1034 net725 net768 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__mux4_1
Xc362 net996 net692 net718 net770 clknet_1_0__leaf_net782 net788 VGND VGND VPWR VPWR
+ net293 sky130_fd_sc_hd__mux4_1
XANTENNA_c632_A2 net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc351 net282 net901 net247 net741 net755 clknet_1_1__leaf_net780 VGND VGND VPWR VPWR
+ net284 sky130_fd_sc_hd__mux4_2
Xc373 net288 net263 clknet_1_1__leaf_net299 clknet_1_0__leaf_net297 net175 net787
+ VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__mux4_1
Xc395 net204 net887 net950 c395/A3 net947 net949 VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c351_A3 net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_86_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge861 clknet_4_8_0_clk net438 net630 VGND VGND VPWR VPWR net745 net744 sky130_fd_sc_hd__dfrbp_2
Xmerge850 net671 clknet_4_1_0_clk net442 VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__dlrtn_2
XFILLER_0_43_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c245_A4 net754 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c401_SCD net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c140_X net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net383 clknet_0_net383 VGND VGND VPWR VPWR clknet_1_0__leaf_net383
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c436_A3 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c70_A2 net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c733_A1 net550 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c452_A2 net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout140 net422 VGND VGND VPWR VPWR net1000 sky130_fd_sc_hd__buf_4
Xfanout151 net1012 VGND VGND VPWR VPWR net1011 sky130_fd_sc_hd__buf_2
Xfanout173 net142 VGND VGND VPWR VPWR net1033 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout162 net1023 VGND VGND VPWR VPWR net1022 sky130_fd_sc_hd__buf_4
Xfanout184 net1045 VGND VGND VPWR VPWR net1044 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c315_S0 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c346_A3 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc181 net78 net1005 net910 net1041 net911 net764 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__mux4_2
Xc170 net85 net100 net1042 net1002 net81 net920 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__mux4_2
XANTENNA_c362_A2 net718 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc192 net907 net117 net113 net110 net647 clknet_1_1__leaf_net711 VGND VGND VPWR VPWR
+ net125 sky130_fd_sc_hd__mux4_4
XFILLER_0_18_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_34_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c272_A2 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c195_Y net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c65_A2 net885 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c447_A2 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c81_A1 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c463_A1 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_18_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input43_A in47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold7 net760 VGND VGND VPWR VPWR net1052 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_58_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_83_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c357_A2 net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap166_X net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c373_A1 net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge775_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c714_A3 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c76_A1 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c195_B1_N net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c458_A1 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c177_A2 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c312_S1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c474_A0 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net145 clknet_0_net145 VGND VGND VPWR VPWR clknet_1_1__leaf_net145
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net156 clknet_0_net156 VGND VGND VPWR VPWR clknet_1_1__leaf_net156
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c368_A1 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c253_A4 clknet_1_1__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c550_A2 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout180_A net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c559_A0 net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c278_A1 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c294_B1 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c62_A3 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc703 clknet_1_1__leaf_net574 clknet_1_1__leaf_net570 net992 net746 clknet_1_1__leaf_net841
+ clknet_1_1__leaf_net842 VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__mux4_4
Xc747 clknet_1_1__leaf_net616 clknet_1_1__leaf_net618 clknet_1_0__leaf_net619 net620
+ net858 net859 VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__mux4_2
Xc714 net585 clknet_1_0__leaf_net587 net809 net1022 net836 net848 VGND VGND VPWR VPWR
+ net588 sky130_fd_sc_hd__mux4_2
Xc725 net581 clknet_1_0__leaf_net598 net1047 clknet_1_1__leaf_net563 c725/S0 net854
+ VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__mux4_2
Xc736 net868 net602 net706 net751 net836 net855 VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__mux4_1
XFILLER_0_31_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc758 clknet_1_0__leaf_net623 net702 net752 net837 net852 net860 VGND VGND VPWR VPWR
+ net632 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_4_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c188_A1 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c619_A3 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c338_A4 net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge772_A2 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c354_A3 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_78_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_output74_A net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c370_A2 net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c233_S0 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_clk_X clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s920_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c264_A3 net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c561_A1 net982 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_9_0_clk_X clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c170_X net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout183_X net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s875_Q net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c289_B1 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c143_S0 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c439_A3 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net121 net121 VGND VGND VPWR VPWR clknet_0_net121 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c73_A2 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net187 net187 VGND VGND VPWR VPWR clknet_0_net187 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s911_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc500 net31 net404 clknet_1_0__leaf_net407 clknet_1_0__leaf_net943 net714 clknet_1_0__leaf_net822
+ VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_9_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc544 net423 net430 net437 net981 net991 net998 VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__mux4_2
Xc555 clknet_4_1_0_clk net449 net980 net446 net447 net982 VGND VGND VPWR VPWR net451
+ net450 sky130_fd_sc_hd__sdfbbp_1
Xc533 net329 net426 net423 VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__a21bo_2
Xc566 net991 net424 net980 net1040 net1035 net829 VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__mux4_1
Xc577 net448 net320 clknet_1_0__leaf_net470 net735 net1028 net1023 VGND VGND VPWR
+ VPWR net472 sky130_fd_sc_hd__mux4_1
Xc588 net422 clknet_1_0__leaf_net470 clknet_1_0__leaf_net251 clknet_1_0__leaf_net801
+ net833 net838 VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__mux4_1
Xc599 net358 clknet_1_1__leaf_net932 net422 net861 net1027 net768 VGND VGND VPWR VPWR
+ net494 sky130_fd_sc_hd__mux4_4
XANTENNA_c199_B1 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output112_A clknet_1_1__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c349_A3 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput106 net966 VGND VGND VPWR VPWR out50 sky130_fd_sc_hd__buf_2
Xoutput117 net977 VGND VGND VPWR VPWR out8 sky130_fd_sc_hd__clkbuf_1
Xclkbuf_1_0__f_net510 clknet_0_net510 VGND VGND VPWR VPWR clknet_1_0__leaf_net510
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net521 clknet_0_net521 VGND VGND VPWR VPWR clknet_1_0__leaf_net521
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net576 clknet_0_net576 VGND VGND VPWR VPWR clknet_1_0__leaf_net576
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout143_A net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net587 clknet_0_net587 VGND VGND VPWR VPWR clknet_1_0__leaf_net587
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net598 clknet_0_net598 VGND VGND VPWR VPWR clknet_1_0__leaf_net598
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c572_A0 net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c68_A2 net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c466_A1 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput19 in25 VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_12_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c482_A0 net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc330 net202 net220 net1005 net252 clknet_1_0__leaf_net152 net962 VGND VGND VPWR VPWR
+ net264 sky130_fd_sc_hd__mux4_2
Xc352 net263 clknet_1_0__leaf_net971 net911 net1019 net39 net770 VGND VGND VPWR VPWR
+ net285 sky130_fd_sc_hd__mux4_4
Xc363 clknet_1_0__leaf_net293 net149 net7 net1003 net962 clknet_1_1__leaf_net782 VGND
+ VGND VPWR VPWR net925 sky130_fd_sc_hd__mux4_1
XANTENNA_c632_A3 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc341 net252 net1012 clknet_1_0__leaf_net742 net754 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__a31oi_4
XFILLER_0_20_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc396 net995 net669 net774 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_48_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge862 clknet_4_1_0_clk net332 net668 VGND VGND VPWR VPWR net747 net746 sky130_fd_sc_hd__dfrbp_1
Xmerge840 net505 net488 VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__xor2_2
Xmerge851 net398 clknet_4_11_0_clk net417 VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__dlrtn_2
XFILLER_0_28_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c392_A0 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c401_SCE net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout146_X net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c436_A4 net735 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c733_A2 net750 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c452_A3 net735 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c171_A4 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout130 net227 VGND VGND VPWR VPWR net990 sky130_fd_sc_hd__clkbuf_8
XANTENNA_c79_A1 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout174 net919 VGND VGND VPWR VPWR net1034 sky130_fd_sc_hd__clkbuf_4
Xfanout141 net81 VGND VGND VPWR VPWR net1001 sky130_fd_sc_hd__clkbuf_4
Xfanout152 net75 VGND VGND VPWR VPWR net1012 sky130_fd_sc_hd__clkbuf_8
Xfanout163 net831 VGND VGND VPWR VPWR net1023 sky130_fd_sc_hd__buf_4
Xclkbuf_1_1__f_net519 clknet_0_net519 VGND VGND VPWR VPWR clknet_1_1__leaf_net519
+ sky130_fd_sc_hd__clkbuf_16
Xfanout185 net875 VGND VGND VPWR VPWR net1045 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_69_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c315_S1 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c196_A1 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c627_A3 net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc160 net93 net102 net91 net104 net105 net696 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__mux4_1
Xc171 net1009 net878 net888 net999 net104 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__a41oi_4
XFILLER_0_85_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc193 net107 net1043 net696 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__a21boi_4
Xc182 net114 net115 net130 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__a21bo_2
XFILLER_0_18_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c241_S0 net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclone4 net1014 VGND VGND VPWR VPWR net1049 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c65_A3 net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net181 clknet_0_net181 VGND VGND VPWR VPWR clknet_1_0__leaf_net181
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c447_A3 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c744_A1 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c463_A2 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input36_A in40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c204_SET_B net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold8 net259 VGND VGND VPWR VPWR net1053 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_58_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c357_A3 net724 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c373_A2 clknet_1_1__leaf_net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c236_S0 clknet_1_1__leaf_net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c548_A2 net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c427_D net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c564_A1 net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c580_B1 net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c730_A3 net550 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c739_A1 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c92_A1 net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c474_A1 net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c193_A2 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c404_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input39_X net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net939 clknet_0_net939 VGND VGND VPWR VPWR clknet_1_0__leaf_net939
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c368_A2 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_0_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c550_A3 net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c559_A1 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_46_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc704 clknet_1_1__leaf_net570 clknet_1_1__leaf_net577 net567 clknet_1_1__leaf_net563
+ net1022 net835 VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__mux4_2
XANTENNA_s918_Q net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc737 net607 net1020 clknet_1_0__leaf_net781 net811 clknet_1_1__leaf_net843 net856
+ VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__mux4_1
Xc715 net550 clknet_1_0__leaf_net563 clknet_1_0__leaf_net588 net701 net808 net848
+ VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__mux4_4
XFILLER_0_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc726 net567 clknet_1_0__leaf_net593 net550 clknet_1_0__leaf_net387 clknet_1_1__leaf_net781
+ net848 VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__mux4_4
Xc748 clknet_1_0__leaf_net621 net732 net752 net1026 clknet_1_0__leaf_net821 net856
+ VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__mux4_2
Xc759 clknet_1_1__leaf_net490 clknet_1_0__leaf_net299 net425 clknet_1_1__leaf_net623
+ net739 net860 VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_55_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c460_A3 net706 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c469_A1 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c188_A2 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_80_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c323_S1 net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_64_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c485_A0 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge772_A3 net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c635_A3 net785 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_73_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge829_Q net710 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output67_A net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c233_S1 net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c395_A0 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c545_A3 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_91_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c561_A2 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout176_X net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c268_Y net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c143_S1 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net122 net122 VGND VGND VPWR VPWR clknet_0_net122 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net144 net144 VGND VGND VPWR VPWR clknet_0_net144 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c736_A2 net706 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c455_A3 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc501 net952 net938 clknet_1_0__leaf_net943 clknet_1_1__leaf_net742 clknet_1_1__leaf_net935
+ clknet_1_1__leaf_net822 VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_9_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc545 net436 net437 net308 net1000 net980 net923 VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__mux4_1
Xc534 net427 net329 net995 VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__a21oi_4
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc567 net458 net1010 net446 net440 net828 net829 VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__mux4_1
Xc556 net424 net451 net987 net426 net1040 net1029 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__mux4_4
Xc589 net934 net982 net1000 net923 net799 net837 VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__mux4_1
Xc578 net1006 net358 clknet_1_0__leaf_net378 net465 net1030 net775 VGND VGND VPWR
+ VPWR net473 sky130_fd_sc_hd__mux4_2
XANTENNA_c471_A2 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c190_A3 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c98_B1 net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c287_Q net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s948_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c199_A1 net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge767_A3 net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_362 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output105_A net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c365_A3 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput107 net967 VGND VGND VPWR VPWR out53 sky130_fd_sc_hd__buf_2
Xoutput118 net978 VGND VGND VPWR VPWR out9 sky130_fd_sc_hd__buf_2
XFILLER_0_49_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_wire144_X net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net500 clknet_0_net500 VGND VGND VPWR VPWR clknet_1_0__leaf_net500
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_53_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net544 clknet_0_net544 VGND VGND VPWR VPWR clknet_1_0__leaf_net544
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net577 clknet_0_net577 VGND VGND VPWR VPWR clknet_1_0__leaf_net577
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net588 clknet_0_net588 VGND VGND VPWR VPWR clknet_1_0__leaf_net588
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c235_CLK_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c556_A2 net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout136_A net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c275_A3 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_443 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c572_A1 net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c466_A2 net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c185_A3 net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c482_A1 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc320 net116 net105 net962 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_75_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc353 clknet_1_0__leaf_net152 net175 net170 net718 net769 clknet_1_0__leaf_net782
+ VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__mux4_1
Xc342 net143 net989 net1032 net266 clknet_1_0__leaf_net742 clknet_1_0__leaf_net972
+ VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__mux4_2
Xc331 net886 net149 net872 net1038 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__a31o_1
Xc364 net129 net268 net176 clknet_1_1__leaf_net972 clknet_1_0__leaf_net782 net787
+ VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__mux4_4
Xc397 net672 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__inv_1
XANTENNA_clkbuf_4_13_0_clk_X clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmerge830 clknet_4_7_0_clk net124 net119 VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__sdlclkp_1
XFILLER_0_74_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge863 clknet_4_14_0_clk net182 net300 VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__dfrtn_1
XFILLER_0_67_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge841 clknet_4_3_0_clk net677 net389 VGND VGND VPWR VPWR net723 net722 sky130_fd_sc_hd__dfsbp_2
Xmerge852 net342 clknet_4_6_0_clk net361 VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__dlrtn_2
XFILLER_0_99_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge869_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c392_A1 net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s931_GATE_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c567_A1 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net385 clknet_0_net385 VGND VGND VPWR VPWR clknet_1_0__leaf_net385
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net374 clknet_0_net374 VGND VGND VPWR VPWR clknet_1_0__leaf_net374
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c133_Y net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout139_X net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s878_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s900_Q net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout120 net435 VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__clkbuf_4
Xfanout131 net196 VGND VGND VPWR VPWR net991 sky130_fd_sc_hd__buf_4
XANTENNA_c79_A2 net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout153 net1014 VGND VGND VPWR VPWR net1013 sky130_fd_sc_hd__buf_8
Xfanout164 net820 VGND VGND VPWR VPWR net1024 sky130_fd_sc_hd__clkbuf_4
Xfanout142 net78 VGND VGND VPWR VPWR net1002 sky130_fd_sc_hd__buf_4
Xfanout175 net865 VGND VGND VPWR VPWR net1035 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_96_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c477_A1 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c196_A2 net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c493_A0 net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc161 net105 net79 net106 net88 net886 net696 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__mux4_1
Xc172 net100 net1037 net1001 net102 net104 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__a41oi_2
Xc150 net82 net77 net83 net79 net1001 net76 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__mux4_2
XFILLER_0_85_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc194 net91 net126 net696 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__o21ba_1
Xc183 net862 net116 net1005 VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__a21oi_4
XFILLER_0_47_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c272_A4 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c578_A0 net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c297_A1 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c728_A3 net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c269_B1_N net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c463_A3 clknet_1_0__leaf_net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold9 net669 VGND VGND VPWR VPWR net1054 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input29_A in34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c326_S1 net986 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_output97_A clknet_1_1__leaf_net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap128 net318 VGND VGND VPWR VPWR net988 sky130_fd_sc_hd__buf_2
XFILLER_0_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c236_S1 net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c252_S0 net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c564_A2 net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_1_0_clk_X clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c146_S1 net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c739_A2 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c332_RESET_B net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c458_A3 net706 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c92_A2 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c474_A2 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c490_A1 net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net125 clknet_0_net125 VGND VGND VPWR VPWR clknet_1_1__leaf_net125
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_7_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net147 clknet_0_net147 VGND VGND VPWR VPWR clknet_1_1__leaf_net147
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c368_A3 net724 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c286_SCD net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xwire170 net347 VGND VGND VPWR VPWR net1030 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_0_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c247_S0 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge855_GATE clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c559_A2 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_101_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c294_A2 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout121_X net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc738 clknet_1_1__leaf_net588 clknet_1_0__leaf_net606 clknet_1_0__leaf_net387 net731
+ clknet_1_0__leaf_net781 net852 VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__mux4_2
Xc727 clknet_1_1__leaf_net598 clknet_1_0__leaf_net387 net809 net811 net835 net849
+ VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__mux4_4
Xc716 clknet_1_1__leaf_net563 net2 net720 net808 net836 net850 VGND VGND VPWR VPWR
+ net590 sky130_fd_sc_hd__mux4_4
Xc705 clknet_1_1__leaf_net571 net111 clknet_1_0__leaf_net570 net992 clknet_1_1__leaf_net576
+ net1022 VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__mux4_1
XFILLER_0_31_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc749 net518 clknet_1_1__leaf_net613 clknet_1_1__leaf_net490 clknet_1_1__leaf_net621
+ net752 clknet_1_0__leaf_net821 VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_4_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c87_A2 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s903_SLEEP_B clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c620_S0 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input51_X net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c676_A0 net979 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c395_A1 net887 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c303_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c280_A4 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c289_A2 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_65_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net145 net145 VGND VGND VPWR VPWR clknet_0_net145 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net156 net156 VGND VGND VPWR VPWR clknet_0_net156 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s950_GATE clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c736_A3 net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s930_Q net828 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c403_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_s881_GATE_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c752_A2 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc502 clknet_1_1__leaf_net383 clknet_1_0__leaf_net407 net717 net736 clknet_1_1__leaf_net742
+ clknet_1_0__leaf_net822 VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_9_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc546 net437 net991 net436 net432 net651 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__a41o_1
XFILLER_0_32_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc535 net428 net426 net1025 VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__a21bo_2
XANTENNA_c670_SCD net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc568 net461 net450 net455 net723 net829 net830 VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__mux4_1
Xc579 net469 net465 net981 net357 net832 VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__a41o_1
Xc557 net1019 net325 net1006 net991 net756 net794 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__mux4_2
XFILLER_0_99_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c615_S0 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input11_A in18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c199_A2 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c496_A0 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c350_S0 clknet_1_0__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge841_Q net723 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput108 net968 VGND VGND VPWR VPWR out54 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput90 net950 VGND VGND VPWR VPWR out35 sky130_fd_sc_hd__buf_2
XFILLER_0_37_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net501 clknet_0_net501 VGND VGND VPWR VPWR clknet_1_0__leaf_net501
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_53_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net545 clknet_0_net545 VGND VGND VPWR VPWR clknet_1_0__leaf_net545
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout129_A net938 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input3_A in10 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c404_SCD net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s880_Q net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c273_X net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c466_A3 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c763_A1 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc310 net241 net238 net117 net114 net204 net985 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__mux4_1
Xc321 clknet_1_1__leaf_net249 clknet_1_1__leaf_net251 net1034 net246 VGND VGND VPWR
+ VPWR net254 sky130_fd_sc_hd__a31oi_2
XFILLER_0_32_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input59_A in61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc354 net37 net1017 net1037 net1027 net769 net966 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__mux4_1
Xc332 clknet_4_12_0_clk net874 net985 net219 net999 clknet_1_1__leaf_net766 VGND VGND
+ VPWR VPWR net928 net266 sky130_fd_sc_hd__sdfbbn_2
Xc343 net271 net252 net754 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__mux2_1
XANTENNA_c329_S1 net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc365 net7 clknet_1_0__leaf_net293 net288 net950 net771 net785 VGND VGND VPWR VPWR
+ net295 sky130_fd_sc_hd__mux4_1
Xc398 net206 net67 net306 VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__a21boi_2
XANTENNA_input14_X net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge820 net642 clknet_4_0_0_clk net565 VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__dlrtn_4
XFILLER_0_23_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge864 clknet_4_15_0_clk net178 net185 VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_67_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge842 clknet_4_1_0_clk net679 net434 VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__dfstp_2
Xmerge831 clknet_4_4_0_clk merge831/GATE net660 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__sdlclkp_2
Xmerge853 net413 clknet_4_10_0_clk net673 VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__dlrtp_2
XFILLER_0_99_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer1 net1014 VGND VGND VPWR VPWR net1046 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c239_S1 net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c583_A1 net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c149_S1 net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout121 net431 VGND VGND VPWR VPWR net981 sky130_fd_sc_hd__buf_2
Xfanout143 net973 VGND VGND VPWR VPWR net1003 sky130_fd_sc_hd__clkbuf_8
Xfanout132 net226 VGND VGND VPWR VPWR net992 sky130_fd_sc_hd__clkbuf_4
Xfanout154 net532 VGND VGND VPWR VPWR net1014 sky130_fd_sc_hd__buf_6
Xfanout165 net774 VGND VGND VPWR VPWR net1025 sky130_fd_sc_hd__clkbuf_8
Xfanout176 net865 VGND VGND VPWR VPWR net1036 sky130_fd_sc_hd__buf_4
XANTENNA_c165_S0 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc162 net890 net100 net88 net87 net102 net696 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__mux4_2
Xc151 net1001 net83 net82 net1006 net70 net69 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__mux4_2
Xc140 net922 net1015 net71 net70 net67 net73 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__mux4_2
Xc184 net904 net913 net934 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__a21oi_2
Xc195 net909 net898 net2 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__a21boi_4
Xc173 net920 net1039 net886 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__o21bai_4
XANTENNA_merge787_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_99_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s951_SLEEP_B clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c684_A0 net359 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c578_A1 net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c432_S1 net735 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c297_A2 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout151_X net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c594_A0 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c463_A4 net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c607_S1 net827 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c488_A1 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c342_S1 clknet_1_0__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap161_A net833 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net841 clknet_0_net841 VGND VGND VPWR VPWR clknet_1_1__leaf_net841
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c252_S1 clknet_1_0__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net519 net519 VGND VGND VPWR VPWR clknet_0_net519 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c580_A2 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c193_Y net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c589_A0 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c443_S0 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c162_S1 net696 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s941_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c490_A2 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input41_A in45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c499_A0 net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net159 clknet_0_net159 VGND VGND VPWR VPWR clknet_1_1__leaf_net159
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c286_SCE net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire171 net322 VGND VGND VPWR VPWR net1031 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_56_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c202_A0 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout159_A net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_526 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c575_A2 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc717 clknet_1_0__leaf_net588 net585 net1008 net726 net833 net851 VGND VGND VPWR VPWR
+ net591 sky130_fd_sc_hd__mux4_4
Xc728 net594 net758 net808 net811 net833 net849 VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__mux4_1
Xc706 clknet_1_1__leaf_net568 net475 clknet_1_0__leaf_net485 net1044 clknet_1_1__leaf_net743
+ net1022 VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__mux4_2
XFILLER_0_31_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc739 clknet_1_1__leaf_net587 net1020 net1027 clknet_1_0__leaf_net781 net855 net858
+ VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__mux4_2
XFILLER_0_97_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge805_A net421 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c469_A3 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c620_S1 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c485_A2 net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c348_S0 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c395_A2 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s905_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c692_A0 net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c705_S1 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net490 clknet_0_net490 VGND VGND VPWR VPWR clknet_1_1__leaf_net490
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_37_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c289_A3 net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_65_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c149_X net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c440_S1 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc503 net954 net928 clknet_1_1__leaf_net407 net941 clknet_1_0__leaf_net942 clknet_1_1__leaf_net822
+ VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__mux4_2
XANTENNA_c107_B1 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc536 net998 net423 net429 net310 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__a31o_1
XFILLER_0_32_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c168_S0 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c670_SCE net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc547 net437 net981 net432 net991 net651 net745 VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__mux4_4
Xc569 net445 net464 net1030 net685 net776 net830 VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__mux4_2
Xc558 net452 net981 net440 net343 net666 net1028 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__mux4_1
XANTENNA_c422_SCE net109 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c496_A1 net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c350_S1 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput109 net969 VGND VGND VPWR VPWR out55 sky130_fd_sc_hd__buf_2
XFILLER_0_23_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput80 clknet_1_1__leaf_net940 VGND VGND VPWR VPWR out24 sky130_fd_sc_hd__clkbuf_1
Xoutput91 net951 VGND VGND VPWR VPWR out36 sky130_fd_sc_hd__buf_2
XFILLER_0_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c687_A0 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net568 clknet_0_net568 VGND VGND VPWR VPWR clknet_1_0__leaf_net568
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c716_S0 net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c404_SCE net314 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout181_X net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c597_A0 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c451_S0 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c170_S1 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c466_A4 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc311 net117 net226 net1005 clknet_1_1__leaf_net711 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__a31oi_1
XFILLER_0_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc300 net967 net990 net224 net652 net697 net777 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_75_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc344 net22 clknet_1_1__leaf_net152 net267 net272 net1033 net129 VGND VGND VPWR VPWR
+ net277 sky130_fd_sc_hd__mux4_1
Xc322 net130 net900 net996 net757 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__a31o_1
Xc333 net755 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__buf_1
Xc355 net901 net989 net29 net936 net1026 net966 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__mux4_2
Xc366 clknet_1_0__leaf_net294 net4 net989 net950 net1026 net785 VGND VGND VPWR VPWR
+ net296 sky130_fd_sc_hd__mux4_2
XANTENNA_c626_S0 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc399 clknet_4_4_0_clk net983 net307 net209 net200 net1054 VGND VGND VPWR VPWR net309
+ net308 sky130_fd_sc_hd__sdfbbp_1
XANTENNA_c345_S1 net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c361_S0 net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c300_A0 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge821 net194 clknet_4_15_0_clk net661 VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__dlrtn_1
XANTENNA_merge846_GATE_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge810 net503 net675 VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__xnor2_1
Xmerge843 clknet_4_15_0_clk net62 net286 VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__dfstp_2
Xmerge854 net262 clknet_4_12_0_clk net656 VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__dlrtp_4
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge832 clknet_4_9_0_clk net658 net399 VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__sdlclkp_4
Xmerge865 clknet_4_8_0_clk net604 net625 VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_99_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer2 net1014 VGND VGND VPWR VPWR net1047 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_23_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c255_S1 clknet_1_1__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c567_A3 net440 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net387 clknet_0_net387 VGND VGND VPWR VPWR clknet_1_0__leaf_net387
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_88_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c226_A net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c583_A2 net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout122 net320 VGND VGND VPWR VPWR net982 sky130_fd_sc_hd__buf_2
Xfanout133 net103 VGND VGND VPWR VPWR net993 sky130_fd_sc_hd__buf_4
Xfanout155 net74 VGND VGND VPWR VPWR net1015 sky130_fd_sc_hd__buf_4
XANTENNA_c446_S0 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout177 net899 VGND VGND VPWR VPWR net1037 sky130_fd_sc_hd__buf_4
XANTENNA_c165_S1 net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c181_S0 net911 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c477_A3 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c493_A2 net928 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc130 net50 net52 net11 net1036 net759 net761 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__mux4_1
Xc163 net90 net93 net102 net109 net107 c163/S1 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__mux4_1
Xc141 net73 net863 net71 net922 net1015 net872 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__mux4_2
Xc152 net83 net84 net869 net82 net1002 net85 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__mux4_2
Xc196 net1042 net108 net907 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__o21bai_4
Xc185 net130 net116 net112 net1034 net986 net1001 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__mux4_1
Xc174 net73 net1015 net1042 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__a21oi_4
XANTENNA_c356_S0 clknet_1_1__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net140 clknet_0_net140 VGND VGND VPWR VPWR clknet_1_0__leaf_net140
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net151 clknet_0_net151 VGND VGND VPWR VPWR clknet_1_0__leaf_net151
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c297_A3 net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net162 clknet_0_net162 VGND VGND VPWR VPWR clknet_1_0__leaf_net162
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_50_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c760_A3 net750 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c115_B1 net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c623_S1 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c488_A2 net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net842 clknet_0_net842 VGND VGND VPWR VPWR clknet_1_1__leaf_net842
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c708_S1 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c580_A3 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c589_A1 net982 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c179_X net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c443_S1 net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c101_A2 net901 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge771_S0 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input34_A in39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c634_S0 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc90 net903 net867 net882 VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__a21o_2
XFILLER_0_85_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c555_SET_B net982 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c544_S0 net991 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c202_A1 net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c575_A3 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c294_A4 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc729 clknet_1_0__leaf_net598 net553 clknet_1_1__leaf_net588 net844 net847 net853
+ VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__mux4_1
Xc718 clknet_1_0__leaf_net576 net558 net585 clknet_1_0__leaf_net588 net1023 net851
+ VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__mux4_2
Xc707 net2 net1045 net1007 net566 clknet_1_1__leaf_net743 net1022 VGND VGND VPWR VPWR
+ net581 sky130_fd_sc_hd__mux4_1
XANTENNA_c591_A2 net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge841_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c454_S0 clknet_1_0__leaf_net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c629_S0 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge832_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c676_A2 net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_51_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c692_A1 net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_60_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c289_A4 net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_65_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net147 net147 VGND VGND VPWR VPWR clknet_0_net147 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net125 net125 VGND VGND VPWR VPWR clknet_0_net125 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s916_Q net811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc537 net991 net428 net308 VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__o21ba_1
Xc504 net950 net175 net941 net820 clknet_1_0__leaf_net822 VGND VGND VPWR VPWR net420
+ sky130_fd_sc_hd__a41oi_4
XANTENNA_c168_S1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc548 net203 net428 net979 net437 net776 net824 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__mux4_1
Xc559 net325 net1031 net1040 net344 net1028 net779 VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__mux4_2
XANTENNA_c631_S1 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c496_A2 net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput70 net930 VGND VGND VPWR VPWR out15 sky130_fd_sc_hd__buf_2
XANTENNA_output65_A clknet_1_0__leaf_net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput81 net941 VGND VGND VPWR VPWR out25 sky130_fd_sc_hd__buf_2
Xoutput92 net952 VGND VGND VPWR VPWR out37 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_62_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net547 clknet_0_net547 VGND VGND VPWR VPWR clknet_1_0__leaf_net547
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout174_X net1034 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c451_S1 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc312 net880 net235 net1005 clknet_1_0__leaf_net244 net234 net962 VGND VGND VPWR VPWR
+ net245 sky130_fd_sc_hd__mux4_2
Xc301 net91 net880 net685 net962 net778 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__a41o_4
XTAP_TAPCELL_ROW_75_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc334 net218 net1034 net962 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__a21o_2
Xc323 clknet_1_1__leaf_net244 clknet_1_0__leaf_net242 net252 net1001 net253 net985
+ VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__mux4_4
XFILLER_0_60_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc345 net986 net266 net252 clknet_1_0__leaf_net152 net725 net767 VGND VGND VPWR VPWR
+ net278 sky130_fd_sc_hd__mux4_1
Xc356 net288 net7 net997 net1012 clknet_1_1__leaf_net972 clknet_1_1__leaf_net782 VGND
+ VGND VPWR VPWR net289 sky130_fd_sc_hd__mux4_2
Xc367 net149 net887 clknet_1_1__leaf_net294 clknet_1_1__leaf_net925 net166 clknet_1_0__leaf_net782
+ VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__mux4_2
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c300_A1 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c361_S1 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge811 net528 net526 VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__xnor2_4
Xmerge800 net462 net484 VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__xnor2_1
Xmerge844 clknet_4_12_0_clk net254 net653 VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__dfstp_2
Xmerge822 net678 clknet_4_10_0_clk net517 VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__dlrtn_1
Xmerge855 net491 clknet_4_9_0_clk net524 VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__dlrtp_2
Xmerge833 clknet_4_12_0_clk net410 net278 VGND VGND VPWR VPWR net714 net713 sky130_fd_sc_hd__dfrbp_1
XFILLER_0_82_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs950 net592 clknet_4_2_0_clk VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__dlxtp_1
Xmerge866 clknet_4_8_0_clk merge866/D net721 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_11_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c673_A3 net734 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer3 clknet_0_net618 VGND VGND VPWR VPWR net1048 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c552_S0 net359 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c210_A1 net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout134_A net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c583_A3 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout145 net129 VGND VGND VPWR VPWR net1005 sky130_fd_sc_hd__clkbuf_4
Xfanout123 net926 VGND VGND VPWR VPWR net983 sky130_fd_sc_hd__clkbuf_4
Xfanout156 net74 VGND VGND VPWR VPWR net1016 sky130_fd_sc_hd__buf_2
Xfanout134 net995 VGND VGND VPWR VPWR net994 sky130_fd_sc_hd__buf_4
Xfanout167 net965 VGND VGND VPWR VPWR net1027 sky130_fd_sc_hd__buf_4
Xfanout178 net1039 VGND VGND VPWR VPWR net1038 sky130_fd_sc_hd__clkbuf_4
XANTENNA_merge852_GATE_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c758_A3 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c181_S1 net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s880_Q_N net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge770_X net644 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_7_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c493_A3 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc120 clknet_4_15_0_clk net46 net44 net52 net51 VGND VGND VPWR VPWR net958 net53 sky130_fd_sc_hd__sdfrbp_1
XFILLER_0_33_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc131 net55 net28 net58 net1052 net1074 net1072 VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__mux4_1
Xc153 net1018 net870 net83 net86 net67 net81 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__mux4_2
Xc142 net869 net72 net920 net76 net1010 net71 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__mux4_2
Xc186 net110 net111 net112 net117 net1043 net1034 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__mux4_1
Xc164 net89 net1009 net894 net100 net697 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__a41o_1
Xc175 net894 net69 net84 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__mux2_4
Xc197 net1009 net128 net1034 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__a21bo_1
XANTENNA_c372_S0 net748 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c240_SCD net647 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c578_A3 net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net141 clknet_0_net141 VGND VGND VPWR VPWR clknet_1_0__leaf_net141
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_66_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net174 clknet_0_net174 VGND VGND VPWR VPWR clknet_1_0__leaf_net174
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net152 clknet_0_net152 VGND VGND VPWR VPWR clknet_1_0__leaf_net152
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_A2 net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout137_X net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c75_S0 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c115_A1 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c457_S0 net716 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c192_S0 net647 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c488_A3 net861 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c84_Y net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s930_GATE clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_94_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c367_S0 net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net821 clknet_0_net821 VGND VGND VPWR VPWR clknet_1_1__leaf_net821
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net843 clknet_0_net843 VGND VGND VPWR VPWR clknet_1_1__leaf_net843
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_6_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c580_A4 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c589_A2 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c101_A3 net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge817_Q_N net696 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net972_X clknet_1_1__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input27_A in32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc91 net1041 net903 net887 VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__o21a_4
Xc80 net15 net912 net1003 net905 net14 VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__a41oi_4
XFILLER_0_85_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge857_Q net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output95_A net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c681_A3 net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c544_S1 net998 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c575_A4 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc719 net992 clknet_1_0__leaf_net587 net1027 net808 net851 net853 VGND VGND VPWR VPWR
+ net593 sky130_fd_sc_hd__mux4_4
XANTENNA_c682_SCD net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc708 net111 net1047 clknet_1_0__leaf_net577 net566 clknet_1_1__leaf_net576 net1020
+ VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__mux4_4
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c296_Y net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c434_SCD net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c735_S0 net750 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c470_S0 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net841 net841 VGND VGND VPWR VPWR clknet_0_net841 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_89_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net470 clknet_0_net470 VGND VGND VPWR VPWR clknet_1_1__leaf_net470
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_37_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c586_A3 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net159 net159 VGND VGND VPWR VPWR clknet_0_net159 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c107_A2 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc505 clknet_1_0__leaf_net407 net420 clknet_1_1__leaf_net956 clknet_1_0__leaf_net943
+ net941 clknet_1_1__leaf_net742 VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__mux4_4
Xc549 net432 net440 net437 net322 net923 net824 VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__mux4_1
Xc538 net650 VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__buf_6
XFILLER_0_12_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c465_S0 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c320_B1_N net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c496_A3 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_14_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput71 net931 VGND VGND VPWR VPWR out16 sky130_fd_sc_hd__buf_2
Xoutput93 net953 VGND VGND VPWR VPWR out38 sky130_fd_sc_hd__buf_2
Xoutput82 clknet_1_1__leaf_net942 VGND VGND VPWR VPWR out26 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_70_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c224_B1 clknet_1_0__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c597_A2 net734 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout167_X net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c426_Y net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge812_GATE_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c179_S1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc302 net1037 net224 net652 net777 net778 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__a41oi_4
XTAP_TAPCELL_ROW_75_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc313 net900 net202 net1 net757 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__a31o_4
Xc335 net115 net252 clknet_1_0__leaf_net152 net268 net217 net266 VGND VGND VPWR VPWR
+ net269 sky130_fd_sc_hd__mux4_1
Xc324 clknet_4_6_0_clk net253 net128 net1005 net914 net705 VGND VGND VPWR VPWR net258
+ net257 sky130_fd_sc_hd__sdfbbn_1
Xc357 net288 net985 net161 net724 clknet_1_1__leaf_net972 net783 VGND VGND VPWR VPWR
+ net290 sky130_fd_sc_hd__mux4_1
Xc368 clknet_1_0__leaf_net297 net268 net950 net724 net784 net789 VGND VGND VPWR VPWR
+ net298 sky130_fd_sc_hd__mux4_4
Xc346 net149 net1 net272 net246 net266 net713 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__mux4_1
XFILLER_0_87_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge812 net676 clknet_4_13_0_clk net686 VGND VGND VPWR VPWR net690 net689 sky130_fd_sc_hd__dlrbn_2
XFILLER_0_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge801 net637 net634 VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__xnor2_4
Xmerge834 clknet_4_15_0_clk merge834/D net193 VGND VGND VPWR VPWR net970 net195 sky130_fd_sc_hd__dfrbp_1
Xmerge845 net590 clknet_4_2_0_clk net586 VGND VGND VPWR VPWR net727 net726 sky130_fd_sc_hd__dlrbn_1
Xmerge823 net486 clknet_4_3_0_clk net684 VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__dlrtp_1
XFILLER_0_55_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge856 clknet_4_8_0_clk net614 net698 VGND VGND VPWR VPWR net740 net739 sky130_fd_sc_hd__edfxbp_1
Xs951 net597 clknet_4_2_0_clk VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xmerge867 clknet_4_10_0_clk net733 net688 VGND VGND VPWR VPWR net753 net752 sky130_fd_sc_hd__dfsbp_2
Xs940 clknet_4_8_0_clk net509 VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_11_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net490 net490 VGND VGND VPWR VPWR clknet_0_net490 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c698_A1 net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c552_S1 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net378 clknet_0_net378 VGND VGND VPWR VPWR clknet_1_0__leaf_net378
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_1_1__f_net299_X clknet_1_1__leaf_net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout146 net80 VGND VGND VPWR VPWR net1006 sky130_fd_sc_hd__buf_4
Xfanout124 net926 VGND VGND VPWR VPWR net984 sky130_fd_sc_hd__clkbuf_2
Xfanout135 net996 VGND VGND VPWR VPWR net995 sky130_fd_sc_hd__buf_4
Xfanout179 net893 VGND VGND VPWR VPWR net1039 sky130_fd_sc_hd__buf_4
Xfanout157 net9 VGND VGND VPWR VPWR net1017 sky130_fd_sc_hd__buf_4
Xfanout168 net965 VGND VGND VPWR VPWR net1028 sky130_fd_sc_hd__clkbuf_4
XANTENNA_input1_A in0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c271_X net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_53_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c693_CLK_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc110 net896 net963 net26 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__mux2_1
XFILLER_0_33_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc121 clknet_4_15_0_clk net51 net958 net24 net44 net52 VGND VGND VPWR VPWR net55 net54
+ sky130_fd_sc_hd__sdfbbn_1
Xc154 net993 net101 net1009 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__mux2_1
Xc143 net71 net864 net1018 net1015 net1010 net77 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__mux4_2
Xc132 net864 net920 net1043 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__a21o_4
XANTENNA_input57_A in6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc165 net882 net98 net1001 net104 net91 net697 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__mux4_1
Xc187 net79 net130 net910 net911 net648 clknet_1_1__leaf_net711 VGND VGND VPWR VPWR
+ net120 sky130_fd_sc_hd__mux4_1
Xc176 net85 net999 net696 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__mux2_4
XANTENNA_c637_S1 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc198 clknet_4_13_0_clk net915 net112 net16 net128 VGND VGND VPWR VPWR net132 net131
+ sky130_fd_sc_hd__sdfrbp_1
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input12_X net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c547_S1 net745 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c205_A2 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net120 clknet_0_net120 VGND VGND VPWR VPWR clknet_1_0__leaf_net120
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_clkbuf_1_0__f_net972_X clknet_1_0__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_2_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s953_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_50_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s882_GATE clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c473_S0 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c322_B1 net757 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net822 clknet_0_net822 VGND VGND VPWR VPWR clknet_1_1__leaf_net822
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge825_GATE clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c213_SCE net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c589_A3 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c101_A4 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c86_S0 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c468_S0 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c407_B1 net716 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c204_SCE net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc70 net897 net899 net1036 VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__a21oi_4
Xc81 net15 net916 net13 VGND VGND VPWR VPWR net964 sky130_fd_sc_hd__mux2_4
Xc92 net884 net25 net903 VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__o21ai_2
XFILLER_0_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge848_GATE clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_s908_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c227_B1 net764 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c288_S0 net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c682_SCE net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc709 clknet_1_0__leaf_net485 clknet_1_1__leaf_net570 net1045 net720 clknet_1_1__leaf_net743
+ net1022 VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__mux4_1
XFILLER_0_12_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c434_SCE net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s889_Q net949 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c751_S0 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c449_X net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net842 net842 VGND VGND VPWR VPWR clknet_0_net842 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_50_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_10_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_5_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold28_A net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net471 clknet_0_net471 VGND VGND VPWR VPWR clknet_1_1__leaf_net471
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_65_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc528 net1006 net77 net314 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__mux2_2
XFILLER_0_12_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc539 net650 VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__inv_4
XANTENNA_c83_S1 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput72 clknet_1_0__leaf_net932 VGND VGND VPWR VPWR out17 sky130_fd_sc_hd__clkbuf_1
Xoutput83 clknet_1_1__leaf_net943 VGND VGND VPWR VPWR out27 sky130_fd_sc_hd__clkbuf_1
Xoutput94 net954 VGND VGND VPWR VPWR out39 sky130_fd_sc_hd__buf_2
XFILLER_0_37_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c330_A0 net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c687_A3 net550 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c566_S0 net1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c285_S1 net1025 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c597_A3 net738 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c325_SCD net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s921_Q net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c118_A2 net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc303 clknet_4_7_0_clk net68 net1066 net967 net685 net1071 VGND VGND VPWR VPWR net237
+ net236 sky130_fd_sc_hd__sdfbbp_1
Xc314 net130 net999 net204 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__o21bai_2
Xc336 net877 net5 net268 net1036 net202 net1019 VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__mux4_2
Xc325 clknet_4_12_0_clk net255 clknet_1_0__leaf_net249 net202 net725 VGND VGND VPWR
+ VPWR net259 sky130_fd_sc_hd__sdfrtp_2
Xc358 net263 net986 net692 net724 net737 clknet_1_1__leaf_net972 VGND VGND VPWR VPWR
+ net291 sky130_fd_sc_hd__mux4_2
XANTENNA_c476_S0 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc369 net39 net126 clknet_1_1__leaf_net293 net680 net785 net789 VGND VGND VPWR VPWR
+ net299 sky130_fd_sc_hd__mux4_1
Xc347 net274 net272 net999 net1017 net263 clknet_1_0__leaf_net742 VGND VGND VPWR VPWR
+ net280 sky130_fd_sc_hd__mux4_4
XFILLER_0_99_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge802 net482 net481 VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__xnor2_1
Xmerge846 net256 clknet_4_12_0_clk net682 VGND VGND VPWR VPWR net728 net955 sky130_fd_sc_hd__dlrbn_2
Xmerge824 net643 net283 VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__xor2_2
Xmerge813 net603 net633 VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__xor2_1
Xmerge835 clknet_4_4_0_clk net659 net313 VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__dfrtn_1
Xmerge868 clknet_4_12_0_clk net704 net707 VGND VGND VPWR VPWR net755 net754 sky130_fd_sc_hd__dfsbp_2
Xs952 clknet_4_8_0_clk net608 VGND VGND VPWR VPWR net856 net855 sky130_fd_sc_hd__dfxbp_2
Xs941 clknet_4_0_0_clk net560 VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__dlclkp_1
Xs930 net457 clknet_4_3_0_clk VGND VGND VPWR VPWR net828 net827 sky130_fd_sc_hd__dlxbp_1
Xmerge857 clknet_4_10_0_clk net523 net269 VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__edfxtp_1
XANTENNA_c309_A1 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c210_A3 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c553_SET_B net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout125 net953 VGND VGND VPWR VPWR net985 sky130_fd_sc_hd__clkbuf_4
Xfanout147 net533 VGND VGND VPWR VPWR net1007 sky130_fd_sc_hd__buf_2
Xfanout136 net937 VGND VGND VPWR VPWR net996 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc111 net43 net25 net1039 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__a21boi_4
Xc100 net14 net23 net31 VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__a21oi_1
Xc122 clknet_4_15_0_clk net49 net45 net1067 net53 net50 VGND VGND VPWR VPWR net57
+ net56 sky130_fd_sc_hd__sdfbbn_1
Xc144 net67 net922 net1002 net1011 net920 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__a41o_1
Xc133 net906 net866 net1035 net1043 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__a31oi_4
XFILLER_0_20_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc177 net898 net105 net1039 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__o21ba_2
Xc166 net879 net862 net1009 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__mux2_2
Xc155 net892 net104 net879 net73 net993 net1009 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__mux4_2
Xc199 net93 net1045 net131 net5 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__a31oi_4
Xc188 net117 net110 net113 net918 net648 clknet_1_1__leaf_net711 VGND VGND VPWR VPWR
+ net121 sky130_fd_sc_hd__mux4_1
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c409_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c311_A2 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_99_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c205_A3 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c563_S1 net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net121 clknet_0_net121 VGND VGND VPWR VPWR clknet_1_0__leaf_net121
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net187 clknet_0_net187 VGND VGND VPWR VPWR clknet_1_0__leaf_net187
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c738_S1 net852 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge871_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c473_S1 net741 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c306_A2 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge862_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c603_A0 net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net801 clknet_0_net801 VGND VGND VPWR VPWR clknet_1_1__leaf_net801
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c558_S1 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout142_X net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c407_A1 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c468_S1 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge844_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c423_B1 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c484_S0 net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc82 net13 net8 net15 net9 VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__a31o_4
Xc71 net912 net7 VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__and2b_1
Xc93 net24 net11 net26 VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__o21ai_1
XFILLER_0_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c82_X net17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c317_A1 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c394_S0 clknet_1_0__leaf_net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_60_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c569_S0 net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c227_A1 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c288_S1 net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c404_RESET_B net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c198_SCE net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c177_X net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_net843 net843 VGND VGND VPWR VPWR clknet_0_net843 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net821 net821 VGND VGND VPWR VPWR clknet_0_net821 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_91_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c153_A0 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input32_A in37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_11_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_100_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_20_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge808_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c571_S1 net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_37_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c238_B1 net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c555_RESET_B net980 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc529 net77 net329 net1000 VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__a21boi_4
XANTENNA_c559_X net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c314_A2 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput73 net933 VGND VGND VPWR VPWR out18 sky130_fd_sc_hd__buf_2
XFILLER_0_37_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput84 net944 VGND VGND VPWR VPWR out3 sky130_fd_sc_hd__buf_2
Xoutput95 net955 VGND VGND VPWR VPWR out4 sky130_fd_sc_hd__clkbuf_4
XANTENNA_input35_X net895 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c611_A0 net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c330_A1 net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c208_A3 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c224_A2 net647 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c414_CLK_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c582_S0 net1023 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net280 clknet_0_net280 VGND VGND VPWR VPWR clknet_1_1__leaf_net280
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c314_Y net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c307_X net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c757_S0 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s914_Q net809 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc315 net918 net228 net1001 net241 net886 net246 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__mux4_1
Xc304 net91 net236 net990 net652 net777 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__a41oi_4
Xc326 net238 net1 net1019 net259 clknet_1_0__leaf_net245 net986 VGND VGND VPWR VPWR
+ net260 sky130_fd_sc_hd__mux4_1
Xc359 net31 net17 net39 clknet_1_1__leaf_net972 clknet_1_1__leaf_net782 net784 VGND
+ VGND VPWR VPWR net961 sky130_fd_sc_hd__mux4_2
Xc337 net265 net873 net986 net219 clknet_1_0__leaf_net766 VGND VGND VPWR VPWR net270
+ sky130_fd_sc_hd__a41oi_4
Xc348 net272 net279 net265 net266 net886 clknet_1_1__leaf_net280 VGND VGND VPWR VPWR
+ net281 sky130_fd_sc_hd__mux4_2
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c150_A1 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge803 clknet_4_14_0_clk net298 net189 VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__dfstp_1
XFILLER_0_83_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge814 net173 clknet_4_14_0_clk net169 VGND VGND VPWR VPWR net693 net692 sky130_fd_sc_hd__dlrbn_1
Xmerge825 merge825/D clknet_4_12_0_clk net250 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__dlrtp_1
Xmerge836 clknet_4_11_0_clk net394 net414 VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__dfrtp_1
Xmerge847 net646 clknet_4_1_0_clk net559 VGND VGND VPWR VPWR net730 net729 sky130_fd_sc_hd__dlrbp_1
Xs942 clknet_4_0_0_clk net564 VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__dlclkp_2
Xs931 net460 clknet_4_1_0_clk VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__dlxtn_2
Xmerge869 clknet_4_4_0_clk net323 net351 VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__dfstp_2
Xs920 clknet_4_9_0_clk net395 VGND VGND VPWR VPWR net816 net815 sky130_fd_sc_hd__dfxbp_1
Xmerge858 clknet_4_14_0_clk net416 net264 VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__sdlclkp_1
XANTENNA_c309_A2 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs953 clknet_4_2_0_clk net612 VGND VGND VPWR VPWR net858 net857 sky130_fd_sc_hd__dfxbp_1
XTAP_TAPCELL_ROW_11_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net470 net470 VGND VGND VPWR VPWR clknet_0_net470 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c124_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output63_A net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c341_B1 net754 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c577_S0 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout137 net963 VGND VGND VPWR VPWR net997 sky130_fd_sc_hd__buf_4
Xfanout126 net96 VGND VGND VPWR VPWR net986 sky130_fd_sc_hd__clkbuf_8
Xfanout148 net533 VGND VGND VPWR VPWR net1008 sky130_fd_sc_hd__buf_6
Xfanout159 net933 VGND VGND VPWR VPWR net1019 sky130_fd_sc_hd__buf_4
XANTENNA_fanout172_X net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c426_B1 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc101 net33 net901 net917 net31 net30 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__a41oi_1
XFILLER_0_20_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c487_S0 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc123 net45 net958 net51 net56 net44 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__a41o_2
Xc112 net867 net964 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__nand2_1
Xc145 net922 net79 net76 net73 net67 net1015 VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__mux4_2
XANTENNA_c145_A1 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc134 net869 net870 net895 net67 net866 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__a41o_2
Xc178 net111 net1005 net110 net126 net1 net1037 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__mux4_2
Xc156 net89 net109 net868 net104 net1037 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__a41o_1
Xc167 net888 net1009 net85 net1006 net1015 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__a41oi_4
Xc189 net115 clknet_1_0__leaf_net121 net116 clknet_1_0__leaf_net120 net110 clknet_1_1__leaf_net711
+ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__mux4_4
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c161_A0 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c311_A3 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c336_A0 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc690 net429 clknet_1_0__leaf_net552 net1014 net1035 net729 net1025 VGND VGND VPWR
+ VPWR net563 sky130_fd_sc_hd__mux4_1
XANTENNA_s949_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_3_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c221_A3 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net122 clknet_0_net122 VGND VGND VPWR VPWR clknet_1_0__leaf_net122
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net144 clknet_0_net144 VGND VGND VPWR VPWR clknet_1_0__leaf_net144
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout132_A net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c246_B1 net754 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_58_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_67_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c156_B1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input62_A in9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_76_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c207_SCD net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net802 clknet_0_net802 VGND VGND VPWR VPWR clknet_1_1__leaf_net802
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_26 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c590_S0 net836 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout135_X net995 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c685_SCD net1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c423_A1 net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c142_A2 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s932_GATE_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc94 net934 net896 net26 VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__a21o_1
Xc72 net8 net3 net7 net1041 VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__a31o_2
XFILLER_0_97_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc83 net5 net919 net964 net912 net12 net905 VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__mux4_1
XFILLER_0_97_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c122_CLK_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c394_S1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net621 clknet_0_net621 VGND VGND VPWR VPWR clknet_1_1__leaf_net621
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c243_A1 clknet_1_1__leaf_net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net822 net822 VGND VGND VPWR VPWR clknet_0_net822 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c137_A2 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input25_A in30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c600_A2 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c328_A1 net105 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge855_Q net738 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output93_A net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c762_S1 net750 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c420_A2 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c429_A0 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c164_B1 net697 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput74 net934 VGND VGND VPWR VPWR out19 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput63 net923 VGND VGND VPWR VPWR out0 sky130_fd_sc_hd__buf_2
Xoutput85 net945 VGND VGND VPWR VPWR out30 sky130_fd_sc_hd__buf_2
XFILLER_0_37_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput96 clknet_1_1__leaf_net956 VGND VGND VPWR VPWR out40 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c330_A2 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_62_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c339_B1 net767 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c505_A2 clknet_1_1__leaf_net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_wire170_X net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
.ends
