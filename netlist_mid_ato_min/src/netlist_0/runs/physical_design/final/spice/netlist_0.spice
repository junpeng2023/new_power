* NGSPICE file created from netlist_0.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxbp_2 abstract view
.subckt sky130_fd_sc_hd__sedfxbp_2 CLK D DE SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_2 abstract view
.subckt sky130_fd_sc_hd__dfrbp_2 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_2 abstract view
.subckt sky130_fd_sc_hd__dlrbn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_4 abstract view
.subckt sky130_fd_sc_hd__dlxtn_4 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtp_1 abstract view
.subckt sky130_fd_sc_hd__dlxtp_1 D GATE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_1 abstract view
.subckt sky130_fd_sc_hd__dlxbn_1 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_4 abstract view
.subckt sky130_fd_sc_hd__o211a_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_4 abstract view
.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbp_1 CLK D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q
+ Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_1 abstract view
.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_4 abstract view
.subckt sky130_fd_sc_hd__mux4_4 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_2 abstract view
.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__lpflow_inputisolatch_1 abstract view
.subckt sky130_fd_sc_hd__lpflow_inputisolatch_1 D SLEEP_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbp_1 abstract view
.subckt sky130_fd_sc_hd__dlxbp_1 D GATE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_1 abstract view
.subckt sky130_fd_sc_hd__o221ai_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_16 abstract view
.subckt sky130_fd_sc_hd__buf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtn_1 abstract view
.subckt sky130_fd_sc_hd__dfrtn_1 CLK_N D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_1 abstract view
.subckt sky130_fd_sc_hd__dlclkp_1 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_2 abstract view
.subckt sky130_fd_sc_hd__dfxbp_2 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_2 abstract view
.subckt sky130_fd_sc_hd__dlxtn_2 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrbp_2 abstract view
.subckt sky130_fd_sc_hd__sdfrbp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_4 abstract view
.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfstp_1 abstract view
.subckt sky130_fd_sc_hd__sdfstp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_1 abstract view
.subckt sky130_fd_sc_hd__dlxtn_1 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_2 abstract view
.subckt sky130_fd_sc_hd__dlclkp_2 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_4 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_4 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_2 abstract view
.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_1 abstract view
.subckt sky130_fd_sc_hd__dfxbp_1 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_4 abstract view
.subckt sky130_fd_sc_hd__dlclkp_4 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_12 abstract view
.subckt sky130_fd_sc_hd__inv_12 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_4 abstract view
.subckt sky130_fd_sc_hd__o221a_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_2 abstract view
.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_1 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_4 abstract view
.subckt sky130_fd_sc_hd__nor3b_4 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtn_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtn_1 CLK_N D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_2 abstract view
.subckt sky130_fd_sc_hd__dlxbn_2 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_2 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_2 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_2 abstract view
.subckt sky130_fd_sc_hd__o221a_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_4 abstract view
.subckt sky130_fd_sc_hd__o221ai_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_2 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_2 abstract view
.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfrbp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_16 abstract view
.subckt sky130_fd_sc_hd__inv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_1 abstract view
.subckt sky130_fd_sc_hd__dfsbp_1 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_1 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_1 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_2 abstract view
.subckt sky130_fd_sc_hd__dfstp_2 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxtp_4 abstract view
.subckt sky130_fd_sc_hd__sedfxtp_4 CLK D DE SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_2 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_2 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_4 abstract view
.subckt sky130_fd_sc_hd__dfstp_4 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbp_1 abstract view
.subckt sky130_fd_sc_hd__dlrbp_1 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_2 abstract view
.subckt sky130_fd_sc_hd__o221ai_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_4 abstract view
.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_4 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_4 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfbbn_1 abstract view
.subckt sky130_fd_sc_hd__dfbbn_1 CLK_N D RESET_B SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_4 abstract view
.subckt sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_1 abstract view
.subckt sky130_fd_sc_hd__dlrtn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_1 abstract view
.subckt sky130_fd_sc_hd__dlrbn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfsbp_2 abstract view
.subckt sky130_fd_sc_hd__sdfsbp_2 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfsbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfsbp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_2 abstract view
.subckt sky130_fd_sc_hd__dlrtn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_2 abstract view
.subckt sky130_fd_sc_hd__dlrtp_2 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_1 abstract view
.subckt sky130_fd_sc_hd__dlrtp_1 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxbp_1 abstract view
.subckt sky130_fd_sc_hd__edfxbp_1 CLK D DE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxtp_1 abstract view
.subckt sky130_fd_sc_hd__edfxtp_1 CLK D DE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_0 abstract view
.subckt sky130_fd_sc_hd__and2_0 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbp_2 abstract view
.subckt sky130_fd_sc_hd__dlrbp_2 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_4 abstract view
.subckt sky130_fd_sc_hd__dlrtp_4 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_4 abstract view
.subckt sky130_fd_sc_hd__and2b_4 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

.subckt netlist_0 VGND VPWR clk in0 in1 in10 in11 in12 in13 in14 in15 in16 in17 in18
+ in19 in2 in20 in21 in22 in23 in24 in25 in26 in27 in28 in29 in3 in30 in31 in32 in33
+ in34 in35 in36 in37 in38 in39 in4 in40 in41 in42 in43 in44 in45 in46 in47 in48 in49
+ in5 in50 in51 in52 in53 in54 in55 in56 in57 in58 in59 in6 in60 in61 in7 in8 in9
+ out0 out1 out10 out11 out12 out13 out14 out15 out16 out17 out18 out19 out2 out20
+ out21 out22 out23 out24 out25 out26 out27 out28 out29 out3 out30 out31 out32 out33
+ out34 out35 out36 out37 out38 out39 out4 out40 out41 out42 out43 out44 out45 out46
+ out47 out48 out49 out5 out50 out51 out52 out53 out54 out55 out56 out57 out58 out59
+ out6 out60 out61 out7 out8 out9 rst
XFILLER_0_94_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c582_S1 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s983_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge817_A2 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc316 net248 net1044 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__or2_1
XFILLER_0_13_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc327 clknet_4_6_0_clk net259 net260 net256 net257 VGND VGND VPWR VPWR net264 net263
+ sky130_fd_sc_hd__sedfxbp_2
Xc305 net218 net812 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__and2_1
XFILLER_0_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc349 net270 net280 net260 net1003 net283 net840 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__mux4_1
Xc338 net265 net267 net802 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__nand3_4
XFILLER_0_99_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge815 net11 clknet_1_0__leaf_net16 clknet_1_0__leaf_net22 net151 clknet_1_0__leaf_net140
+ net136 VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__mux4_1
Xmerge804 clknet_1_1__leaf_net110 net106 net96 net273 net213 net818 VGND VGND VPWR
+ VPWR net684 sky130_fd_sc_hd__mux4_2
Xmerge826 net900 net1042 net1014 clknet_1_1__leaf_net140 net1039 clknet_1_0__leaf_net25
+ VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__mux4_2
Xmerge837 clknet_4_4_0_clk net660 net677 VGND VGND VPWR VPWR net719 net718 sky130_fd_sc_hd__dfrbp_2
Xs932 clknet_4_7_0_clk net116 VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_82_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge848 net606 net607 VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__or2_1
Xmerge859 net702 clknet_4_5_0_clk net644 VGND VGND VPWR VPWR net743 net742 sky130_fd_sc_hd__dlrbn_2
XANTENNA_c326_Q net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs943 net282 clknet_4_12_0_clk VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__dlxtn_4
XFILLER_0_70_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs976 net531 clknet_4_10_0_clk VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__dlxtp_1
Xs965 clknet_4_3_0_clk net475 VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__dfxtp_4
Xs954 net345 clknet_4_1_0_clk VGND VGND VPWR VPWR net852 net851 sky130_fd_sc_hd__dlxbn_1
XTAP_TAPCELL_ROW_11_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs987 net626 clknet_4_8_0_clk VGND VGND VPWR VPWR net893 net892 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_23_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c606_B2 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer7 net746 VGND VGND VPWR VPWR net962 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c622_A0 clknet_1_0__leaf_net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s965_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net304 clknet_0_net304 VGND VGND VPWR VPWR clknet_1_0__leaf_net304
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c219_A3 net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout138 net1036 VGND VGND VPWR VPWR net1035 sky130_fd_sc_hd__buf_2
XFILLER_0_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c476_C net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c469_B net352 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc102 net37 net928 net33 clknet_1_0__leaf_net35 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__o211a_4
Xc124 net3 net51 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__nand2_1
Xc113 net43 net920 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__and2b_1
XANTENNA_c145_A2 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc135 net932 net908 net1041 net921 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__o211ai_2
XFILLER_0_20_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc157 net911 net922 net1034 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__nand3b_4
Xc168 clknet_4_7_0_clk net105 net100 net101 net78 net1035 VGND VGND VPWR VPWR net108
+ net107 sky130_fd_sc_hd__sdfbbp_1
Xc146 net1040 net763 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__or2_2
Xc179 net942 net0 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__nor2b_1
XFILLER_0_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s947_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c443_Q net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c336_A1 net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c473_SCE net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc691 net85 net558 net545 net557 net458 net880 VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__mux4_4
Xc680 net549 net551 net317 net548 net532 net543 VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__mux4_1
XANTENNA_c117_A_N net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net167 clknet_0_net167 VGND VGND VPWR VPWR clknet_1_0__leaf_net167
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout125_A net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_6_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net464_X clknet_1_1__leaf_net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s955_GATE_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input55_A in58 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net869 clknet_0_net869 VGND VGND VPWR VPWR clknet_1_1__leaf_net869
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_29_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c347_A0 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c590_S1 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input2_X net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc62 net945 net951 net939 net937 net3 net1044 VGND VGND VPWR VPWR net0 sky130_fd_sc_hd__mux4_2
Xc73 net669 VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_4
Xc84 net1050 net912 clknet_1_0__leaf_net12 VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__or3_4
Xc95 net946 net927 VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_26_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c406_Q net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c75_Y net13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input58_X net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c691_S0 net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c630_A0 clknet_1_0__leaf_net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c227_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c277_A net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c444_A net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c107_SCD net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c418_A2 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net889 net889 VGND VGND VPWR VPWR clknet_0_net889 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net25 clknet_0_net25 VGND VGND VPWR VPWR clknet_1_1__leaf_net25 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_30_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net36 clknet_0_net36 VGND VGND VPWR VPWR clknet_1_1__leaf_net36 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_30_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold30 net979 VGND VGND VPWR VPWR net1087 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input18_A in24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_100_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c609_A1 net385 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c625_A0 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c344_B2 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net430 clknet_0_net430 VGND VGND VPWR VPWR clknet_1_1__leaf_net430
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_83_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net485 clknet_0_net485 VGND VGND VPWR VPWR clknet_1_1__leaf_net485
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_37_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net496 clknet_0_net496 VGND VGND VPWR VPWR clknet_1_1__leaf_net496
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_77_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge822_A3 net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c287_Y net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c429_A1 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c104_Q net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput75 net972 VGND VGND VPWR VPWR out2 sky130_fd_sc_hd__buf_2
Xoutput64 clknet_1_1__leaf_net961 VGND VGND VPWR VPWR out1 sky130_fd_sc_hd__clkbuf_1
Xoutput86 net983 VGND VGND VPWR VPWR out31 sky130_fd_sc_hd__buf_2
XFILLER_0_37_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput97 net994 VGND VGND VPWR VPWR out43 sky130_fd_sc_hd__buf_2
XANTENNA_c611_A2 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c704_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net1010 net1010 VGND VGND VPWR VPWR clknet_0_net1010 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c284_Q_N net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c505_A3 net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c247_B net48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge817_A3 net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c421_C net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c103_S1 clknet_1_1__leaf_net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_8_0_clk_X clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c202_Y net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc317 net233 net224 net215 net113 net831 net838 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__mux4_1
Xc306 net241 net1036 net812 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__or3b_1
XFILLER_0_13_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c415_A3 net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc328 net260 net262 net119 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__and3b_2
Xc339 net786 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__buf_6
XFILLER_0_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c690_CLK_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge805 clknet_1_1__leaf_net38 net982 net65 net826 VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__o211ai_4
Xmerge827 net80 net136 net902 net5 clknet_1_1__leaf_net16 net740 VGND VGND VPWR VPWR
+ net707 sky130_fd_sc_hd__mux4_4
Xmerge816 net203 net199 net200 net945 net233 net914 VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__mux4_1
Xs933 clknet_4_7_0_clk net134 VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__dfxtp_1
Xmerge838 net590 net602 VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__nand2b_2
Xmerge849 net393 net394 VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__nand2b_1
Xs977 net544 clknet_4_0_0_clk VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xs966 clknet_4_3_0_clk net482 VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__dfxtp_4
Xs955 net346 clknet_4_6_0_clk VGND VGND VPWR VPWR net854 net853 sky130_fd_sc_hd__dlxbn_1
Xs944 net285 clknet_4_12_0_clk VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__dlxtp_1
XTAP_TAPCELL_ROW_11_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs988 net627 clknet_4_8_0_clk VGND VGND VPWR VPWR net895 net894 sky130_fd_sc_hd__dlxbp_1
XFILLER_0_36_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_362 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer8 net338 VGND VGND VPWR VPWR net1098 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge892_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c688_Q net562 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_1_0__f_net464_X clknet_1_0__leaf_net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge883_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout117 net982 VGND VGND VPWR VPWR net1014 sky130_fd_sc_hd__clkbuf_4
Xfanout139 net1039 VGND VGND VPWR VPWR net1036 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c469_C net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net850 clknet_0_net850 VGND VGND VPWR VPWR clknet_1_0__leaf_net850
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_64_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc114 net926 net45 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__or2_1
Xc103 net26 clknet_1_1__leaf_net36 net33 net1014 clknet_1_0__leaf_net39 clknet_1_1__leaf_net34
+ VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__mux4_2
Xc125 net62 net59 net1042 net1014 net1085 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__o221ai_1
Xc136 net909 net958 net1041 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__or3_2
Xc169 net925 net1034 net765 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__nand3_2
Xc158 net93 net1034 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__and2b_1
XFILLER_0_13_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc147 net82 net905 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__or2_4
XANTENNA_c161_A2 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_99_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_A1 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c440_C_N net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c694_S0 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c633_A0 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge928_Q net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc681 clknet_4_0_0_clk clknet_1_1__leaf_net438 net548 net551 net324 net1078 VGND VGND
+ VPWR VPWR net554 net553 sky130_fd_sc_hd__sdfbbp_1
Xc670 net540 net204 VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__or2_1
Xc692 net454 net554 net564 net458 net1027 VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__o221a_1
XFILLER_0_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net157 clknet_0_net157 VGND VGND VPWR VPWR clknet_1_0__leaf_net157
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net168 clknet_0_net168 VGND VGND VPWR VPWR clknet_1_0__leaf_net168
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_27_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c588_S1 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c112_B net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge856_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c105_A net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout118_A net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c534_Y net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c437_A1 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c498_S1 net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge847_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input48_A in51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net848 clknet_0_net848 VGND VGND VPWR VPWR clknet_1_1__leaf_net848
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_29_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge878_Q net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net162_X clknet_1_0__leaf_net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge825_A3 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c489_CLK_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc63 net946 net938 net948 net942 net3 net939 VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__mux4_1
Xc74 clknet_1_0__leaf_net769 VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_16
XFILLER_0_97_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc96 net805 VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_26_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c614_A2 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net612 clknet_0_net612 VGND VGND VPWR VPWR clknet_1_1__leaf_net612
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c691_S1 net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_84_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_60_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_9_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c444_B net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout140_X net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net868 net868 VGND VGND VPWR VPWR clknet_0_net868 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c715_B2 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c434_A2 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold20 net761 VGND VGND VPWR VPWR net1077 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 net976 VGND VGND VPWR VPWR net1088 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c609_A2 net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output79_A net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c282_SCD net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net464 clknet_0_net464 VGND VGND VPWR VPWR clknet_1_1__leaf_net464
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c561_B net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_4_0_clk_X clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c409_B_N net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c726_A0 net581 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c164_A2 net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput76 net973 VGND VGND VPWR VPWR out20 sky130_fd_sc_hd__buf_2
Xoutput65 net1058 VGND VGND VPWR VPWR out10 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c461_A0 net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput87 net984 VGND VGND VPWR VPWR out32 sky130_fd_sc_hd__buf_2
Xoutput98 net995 VGND VGND VPWR VPWR out45 sky130_fd_sc_hd__buf_2
XANTENNA_input30_A in35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c319_SCE net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c558_SCE net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge802_S0 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c249_A2 net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c142_B net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_99_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c302_A net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc318 net122 net819 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__and2b_2
XFILLER_0_13_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc307 net242 net237 net238 net235 net1019 net224 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__mux4_1
Xc329 net206 net263 net831 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__nor3b_1
XFILLER_0_13_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge806 clknet_1_1__leaf_net30 net26 net11 net182 net180 net1005 VGND VGND VPWR
+ VPWR net686 sky130_fd_sc_hd__mux4_1
Xmerge828 net456 net461 VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__and2b_1
Xmerge817 net82 net317 net1016 net237 net220 net1022 VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__mux4_1
XANTENNA_c95_B net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs934 clknet_4_7_0_clk net137 VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_82_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge839 clknet_4_13_0_clk net154 net667 VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__dfrtn_1
Xs945 net288 clknet_4_14_0_clk VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xs967 clknet_4_3_0_clk net486 VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__dlclkp_1
XFILLER_0_36_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs956 net348 clknet_4_6_0_clk VGND VGND VPWR VPWR net856 net855 sky130_fd_sc_hd__dlxbp_1
XTAP_TAPCELL_ROW_11_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs978 clknet_4_2_0_clk net563 VGND VGND VPWR VPWR net881 net880 sky130_fd_sc_hd__dfxbp_2
Xs989 net635 clknet_4_10_0_clk VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__dlxtn_2
XFILLER_0_63_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s938_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c348_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout129 net535 VGND VGND VPWR VPWR net1026 sky130_fd_sc_hd__clkbuf_4
Xfanout118 net1016 VGND VGND VPWR VPWR net1015 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c251_A3 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge874_GATE clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c587_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c138_X net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc115 clknet_1_1__leaf_net24 net43 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__and2_1
Xc104 clknet_4_13_0_clk clknet_1_0__leaf_net39 clknet_1_1__leaf_net34 net33 clknet_1_1__leaf_net25
+ VGND VGND VPWR VPWR net42 net41 sky130_fd_sc_hd__sdfrbp_2
Xc126 net61 net902 net921 net1042 net1044 net11 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__mux4_1
XFILLER_0_60_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc137 net75 net899 net902 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__or3b_2
Xc159 net93 net933 net1034 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__nor3_1
XFILLER_0_13_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c723_A1 net581 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc148 net83 net85 net86 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__or3_1
XANTENNA_c718_CLK_N clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c617_A2 net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge770_A1 net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c71_B_N net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_12_0_clk_X clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c694_S1 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc682 net537 net547 net1040 VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__nand3b_1
Xc671 net416 net542 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__or2_2
Xc660 net81 net434 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__or2b_4
Xc693 net567 net448 net562 net537 net1027 VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__o221ai_1
XANTENNA_merge779_C1 net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net169 clknet_0_net169 VGND VGND VPWR VPWR clknet_1_0__leaf_net169
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_47_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c85_9_A net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c112_C net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_36_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_45_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net849 clknet_0_net849 VGND VGND VPWR VPWR clknet_1_1__leaf_net849
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_29_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge765_A1 net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c689_S1 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c628_A1 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c347_A2 net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc490 net396 net988 net979 net170 net375 clknet_1_1__leaf_net34 VGND VGND VPWR VPWR
+ net398 sky130_fd_sc_hd__mux4_4
XANTENNA_c603_SCD net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_63_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_82_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_72_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout130_A net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c501_D net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_81_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c477_Y net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c720_A2 net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc64 net952 net950 net956 net3 net0 net939 VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__mux4_2
Xc75 net788 VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__inv_8
Xc86 net21 net1054 net20 net11 VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__o211ai_4
Xc97 clknet_1_1__leaf_net29 net26 VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_26_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A0 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_90_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input60_A in7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c614_A3 net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge776_A0 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_60_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c444_C net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_4_0_0_clk_X clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout133_X net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net869 net869 VGND VGND VPWR VPWR clknet_0_net869 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c715_A2 net761 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net16 clknet_0_net16 VGND VGND VPWR VPWR clknet_1_1__leaf_net16 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c434_A3 net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net38 clknet_0_net38 VGND VGND VPWR VPWR clknet_1_1__leaf_net38 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c731_A1 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold10 net538 VGND VGND VPWR VPWR net1067 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 net772 VGND VGND VPWR VPWR net1078 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 net806 VGND VGND VPWR VPWR net1089 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c450_A2 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c313_S0 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c80_Y net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_523 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c73_X net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge910_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c625_A2 net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c282_SCE net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c473_CLK_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net432 clknet_0_net432 VGND VGND VPWR VPWR clknet_1_1__leaf_net432
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c369_A0 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c342_Y net277 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s942_Q net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge774_A net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c726_A1 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c63_A2 net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_50_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput66 net963 VGND VGND VPWR VPWR out11 sky130_fd_sc_hd__buf_2
Xoutput77 net974 VGND VGND VPWR VPWR out22 sky130_fd_sc_hd__buf_2
Xoutput88 net1018 VGND VGND VPWR VPWR out33 sky130_fd_sc_hd__buf_2
Xoutput99 net996 VGND VGND VPWR VPWR out46 sky130_fd_sc_hd__buf_2
XANTENNA_input23_A in29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge773_A1 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge773_B2 net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_42_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output91_A net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c218_S0 net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s968_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge802_S1 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c249_A3 net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c142_C net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc308 net939 net224 net1041 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__nand3_2
XANTENNA_c494_SCE net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc319 clknet_4_7_0_clk net248 net244 net237 net819 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__sdfstp_1
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c128_S0 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c285_X net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge807 net1 net11 net1022 net937 net126 net121 VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__mux4_1
Xmerge818 clknet_1_1__leaf_net418 net1056 net200 net455 net453 net454 VGND VGND VPWR
+ VPWR net698 sky130_fd_sc_hd__mux4_1
Xmerge829 net649 net691 VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__nand2b_1
XFILLER_0_67_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c88_B net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs935 clknet_4_12_0_clk net155 VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__dlclkp_1
Xclkbuf_0_net430 net430 VGND VGND VPWR VPWR clknet_0_net430 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs957 net368 clknet_4_3_0_clk VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__dlxtn_1
Xs968 clknet_4_3_0_clk net490 VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__dlclkp_2
Xs946 clknet_4_14_0_clk net295 VGND VGND VPWR VPWR net844 net843 sky130_fd_sc_hd__dfxbp_2
Xs979 clknet_4_2_0_clk net571 VGND VGND VPWR VPWR net883 net882 sky130_fd_sc_hd__dfxbp_2
XTAP_TAPCELL_ROW_11_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net485 net485 VGND VGND VPWR VPWR clknet_0_net485 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net496 net496 VGND VGND VPWR VPWR clknet_0_net496 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c622_A3 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input26_X net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout119 net1017 VGND VGND VPWR VPWR net1016 sky130_fd_sc_hd__clkbuf_4
XANTENNA_hold31_A net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c245_A net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c411_S0 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c130_S1 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c573_C1 net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc127 net56 net59 net1042 net902 net61 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__o221a_1
Xc116 net51 net52 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__nand2b_2
Xc105 net816 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__inv_4
XFILLER_0_13_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc138 net903 net900 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__and2_1
XANTENNA_c723_A2 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc149 net765 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__inv_4
Xc79_4 net771 VGND VGND VPWR VPWR net1049 sky130_fd_sc_hd__clkinv_8
XANTENNA_c674_Y net546 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_99_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge770_A2 net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c633_A2 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc672 clknet_1_0__leaf_net536 clknet_1_0__leaf_net541 net317 net534 net539 net1016
+ VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__mux4_1
Xc661 net806 VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__clkbuf_1
Xc683 clknet_4_0_0_clk net548 net1067 net1027 net879 VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__sdfrtp_4
Xc694 net561 net538 net1043 net556 net85 net1027 VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__mux4_4
XFILLER_0_91_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c688_SCE net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c437_A3 net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_100_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge765_A2 net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c628_A2 clknet_1_0__leaf_net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc480 clknet_4_9_0_clk net388 net385 net898 net366 net1038 VGND VGND VPWR VPWR net1011
+ net389 sky130_fd_sc_hd__sdfbbp_1
Xc491 net322 net968 net979 net899 clknet_1_0__leaf_net34 VGND VGND VPWR VPWR net399
+ sky130_fd_sc_hd__o221a_1
XANTENNA_c239_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c603_SCE net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c119_SCD net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c257_A3 net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout123_A net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc65 net928 net914 net919 net912 net900 net913 VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__mux4_2
Xc76 net6 net4 net11 net13 VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__o211a_2
Xc98 net32 net33 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__nand2b_1
Xc87 clknet_1_0__leaf_net24 net1053 clknet_1_0__leaf_net22 net21 VGND VGND VPWR VPWR
+ net25 sky130_fd_sc_hd__o211ai_4
XFILLER_0_97_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A1 net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c745_A0 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input53_A in56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge821_S0 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net848 net848 VGND VGND VPWR VPWR clknet_0_net848 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net39 clknet_0_net39 VGND VGND VPWR VPWR clknet_1_1__leaf_net39 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_30_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_A2 net562 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold22 net161 VGND VGND VPWR VPWR net1079 sky130_fd_sc_hd__dlygate4sd3_1
Xhold11 net396 VGND VGND VPWR VPWR net1068 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 net786 VGND VGND VPWR VPWR net1090 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c459_A1 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input56_X net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c491_C1 clknet_1_0__leaf_net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge787_B1 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_65_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c369_A1 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_362 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net612 net612 VGND VGND VPWR VPWR clknet_0_net612 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c726_A2 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c290_B_N net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c742_A1 net562 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput67 net964 VGND VGND VPWR VPWR out12 sky130_fd_sc_hd__buf_2
Xoutput89 clknet_1_1__leaf_net986 VGND VGND VPWR VPWR out34 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c548_CLK_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput78 net975 VGND VGND VPWR VPWR out23 sky130_fd_sc_hd__buf_2
XANTENNA_input16_A in22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net1002 net1002 VGND VGND VPWR VPWR clknet_0_net1002 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c486_C1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c636_A2 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_42_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c470_C_N net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net34_X clknet_1_1__leaf_net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c355_A3 net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge895_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge846_Q net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output84_A net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge886_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc309 net235 net118 net831 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__or3_1
XFILLER_0_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c664_B net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input8_A in15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c452_Y net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge819 net1014 net1001 net5 net6 net900 net813 VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__mux4_1
XFILLER_0_67_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge808 net898 net320 net277 net462 clknet_1_1__leaf_net417 net468 VGND VGND VPWR
+ VPWR net688 sky130_fd_sc_hd__mux4_4
XFILLER_0_48_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs936 clknet_4_12_0_clk net156 VGND VGND VPWR VPWR net992 sky130_fd_sc_hd__dlclkp_2
Xs958 net369 clknet_4_6_0_clk VGND VGND VPWR VPWR net981 sky130_fd_sc_hd__dlxtn_4
Xs947 clknet_4_14_0_clk net299 VGND VGND VPWR VPWR net846 net845 sky130_fd_sc_hd__dfxbp_1
XTAP_TAPCELL_ROW_11_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net464 net464 VGND VGND VPWR VPWR clknet_0_net464 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs969 clknet_4_3_0_clk net493 VGND VGND VPWR VPWR net969 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_51_527 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c487_CLK_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_19_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge813_S1 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s945_SLEEP_B clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc106 net947 clknet_1_1__leaf_net39 net31 net827 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__o211ai_2
Xc117 net917 net43 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_96_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc128 clknet_1_0__leaf_net38 net1042 net65 net810 net813 net827 VGND VGND VPWR VPWR
+ net66 sky130_fd_sc_hd__mux4_1
Xc139 net765 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__inv_12
XFILLER_0_13_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc79_5 net771 VGND VGND VPWR VPWR net1050 sky130_fd_sc_hd__clkinv_8
XANTENNA_c748_A0 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge915_CLK_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc662 net646 VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__inv_2
Xc673 net792 VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__buf_6
Xc684 net554 net1026 net1045 net879 VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__o211a_1
XANTENNA_merge899_GATE_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge795_A0 net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c286_A_N net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c393_A0 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c310_X net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c408_X net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c734_A2 net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c750_A1 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c628_A3 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc470 net376 net8 net260 VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__or3b_1
Xc481 net378 net366 net365 net388 net283 VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__o221a_1
Xc492 net159 net273 clknet_1_1__leaf_net169 net170 net823 VGND VGND VPWR VPWR net400
+ sky130_fd_sc_hd__o221a_4
XANTENNA_max_cap121_X net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge819_S0 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c431_A_N net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c327_DE net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c570_A1 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc66 net931 net1045 VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__nand2_1
XFILLER_0_97_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc77 net6 net924 net926 clknet_1_0__leaf_net12 net1022 net3 VGND VGND VPWR VPWR net15
+ sky130_fd_sc_hd__mux4_1
Xc99 net33 net928 VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__or2b_2
Xc88 net4 net14 VGND VGND VPWR VPWR net982 sky130_fd_sc_hd__nand2_2
XFILLER_0_97_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s965_Q net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xwire126 net266 VGND VGND VPWR VPWR net1023 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_61_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input46_A in5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge776_A2 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge876_Q net763 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge792_A1 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c172_D net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_1_0__f_net961_X clknet_1_0__leaf_net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net849 net849 VGND VGND VPWR VPWR clknet_0_net849 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c700_S0 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_31_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout119_X net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net29 clknet_0_net29 VGND VGND VPWR VPWR clknet_1_1__leaf_net29 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_87_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_A3 net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold23 net980 VGND VGND VPWR VPWR net1080 sky130_fd_sc_hd__dlygate4sd3_1
Xhold12 net545 VGND VGND VPWR VPWR net1069 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 net556 VGND VGND VPWR VPWR net1091 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c77_A2 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_39_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c459_A2 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c756_A0 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c610_S0 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net445 clknet_0_net445 VGND VGND VPWR VPWR clknet_1_1__leaf_net445
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge816_S1 net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_9_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_69_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c430_S0 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c726_A3 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_78_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c461_A3 net352 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput68 net965 VGND VGND VPWR VPWR out13 sky130_fd_sc_hd__buf_2
Xoutput79 net976 VGND VGND VPWR VPWR out24 sky130_fd_sc_hd__buf_2
XFILLER_0_98_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c189_A2 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c486_B1 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c636_A3 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge798_B1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c412_SCD net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c664_C net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge766_SCE net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c278_Y net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge809 net230 net234 net78 net114 net265 net237 VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__mux4_4
XFILLER_0_95_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c737_A2 net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs937 clknet_4_15_0_clk net188 VGND VGND VPWR VPWR net1002 sky130_fd_sc_hd__dlclkp_4
Xs948 clknet_4_14_0_clk net305 VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__dfxtp_1
Xclkbuf_0_net432 net432 VGND VGND VPWR VPWR clknet_0_net432 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs959 net406 clknet_4_11_0_clk VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_90_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_output115_A net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge784_A2 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge859_GATE_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_85_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net832 clknet_0_net832 VGND VGND VPWR VPWR clknet_1_0__leaf_net832
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_54_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net887 clknet_0_net887 VGND VGND VPWR VPWR clknet_1_0__leaf_net887
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_70_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout146_A net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c573_A1 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc107 clknet_4_13_0_clk net31 net1075 net1014 net725 VGND VGND VPWR VPWR net997 net45
+ sky130_fd_sc_hd__sdfrbp_2
Xc118 net49 net55 net52 net1014 VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__o211a_1
XFILLER_0_5_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc129 net816 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__inv_1
Xc79_6 net771 VGND VGND VPWR VPWR net1051 sky130_fd_sc_hd__clkinv_8
XFILLER_0_95_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c748_A1 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c93_B net13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc630 clknet_1_0__leaf_net34 net521 clknet_1_0__leaf_net169 net825 net1032 net973
+ VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__mux4_1
Xc663 net645 VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__buf_16
Xc696 net569 net923 net553 net564 net454 net560 VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__mux4_1
Xc685 net557 net537 net556 VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__nand3_2
Xc674 clknet_1_1__leaf_net541 net545 VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__nand2b_1
XFILLER_0_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge795_A1 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_355 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_98_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c303_X net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c734_A3 net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c750_A2 net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c759_A0 net508 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c478_B2 net385 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c214_3_A net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge919_Q net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc460 net367 net366 net352 net899 clknet_1_1__leaf_net978 net853 VGND VGND VPWR VPWR
+ net369 sky130_fd_sc_hd__mux4_1
Xc482 clknet_1_0__leaf_net372 net373 net388 net386 net246 net777 VGND VGND VPWR VPWR
+ net391 sky130_fd_sc_hd__mux4_2
Xc471 net808 VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__inv_1
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc493 clknet_4_9_0_clk net375 clknet_1_1__leaf_net372 net395 net985 net823 VGND VGND
+ VPWR VPWR net976 net401 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_99_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_32_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_82_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net30 clknet_0_net30 VGND VGND VPWR VPWR clknet_1_0__leaf_net30 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge819_S1 net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_41_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc67 net951 net1044 net0 VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__nor3b_4
XPHY_EDGE_ROW_50_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc78 clknet_1_0__leaf_net12 net14 net949 net926 VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__o211a_2
Xc89 net760 VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_26_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c729_A3 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c298_B2 net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc560_11 clknet_1_1__leaf_net967 VGND VGND VPWR VPWR net1056 sky130_fd_sc_hd__clkinv_4
XANTENNA_s958_Q net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge922_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire127 net257 VGND VGND VPWR VPWR net1024 sky130_fd_sc_hd__buf_2
XFILLER_0_21_306 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input39_A in43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net616 clknet_0_net616 VGND VGND VPWR VPWR clknet_1_1__leaf_net616
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge913_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge792_A2 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s931_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc290 net79 net829 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__or2b_1
XFILLER_0_41_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_5_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_504 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c220_B net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net19 clknet_0_net19 VGND VGND VPWR VPWR clknet_1_1__leaf_net19 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_87_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold13 net48 VGND VGND VPWR VPWR net1070 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c475_Y net385 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold35 net125 VGND VGND VPWR VPWR net1092 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 net837 VGND VGND VPWR VPWR net1081 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c163_S0 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c756_A1 net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c491_A1 net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c491_B2 net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge787_A2 net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c369_A3 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_77_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_36_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout131_X net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c430_S1 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c216_X net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c592_A0 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput69 net966 VGND VGND VPWR VPWR out14 sky130_fd_sc_hd__buf_2
XANTENNA_c561_A_N net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c621_S0 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c486_A1 net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge798_A1 net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_6_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_334 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c693_C1 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c280_A net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c706_S0 net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c333_X net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs949 clknet_4_4_0_clk net323 VGND VGND VPWR VPWR net990 sky130_fd_sc_hd__dfxtp_4
Xs938 net219 clknet_4_5_0_clk VGND VGND VPWR VPWR net834 net833 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_90_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c753_A2 net588 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c616_S0 net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input21_A in27 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_13_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c666_RESET_B net532 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c351_S0 net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_97_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_85_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net888 clknet_0_net888 VGND VGND VPWR VPWR clknet_1_0__leaf_net888
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_57_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout139_A net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc108 clknet_1_0__leaf_net35 net1052 clknet_1_0__leaf_net30 net33 net28 c108/S1 VGND
+ VGND VPWR VPWR net46 sky130_fd_sc_hd__mux4_2
XFILLER_0_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_96_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc119 clknet_4_15_0_clk net53 net1070 net926 net55 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__sdfrtn_1
XFILLER_0_41_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc79_7 net771 VGND VGND VPWR VPWR net1052 sky130_fd_sc_hd__clkinv_8
XFILLER_0_95_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c748_A2 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c483_A2 net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc620 clknet_1_0__leaf_net303 net513 net498 net1029 net1032 net875 VGND VGND VPWR
+ VPWR net515 sky130_fd_sc_hd__mux4_2
Xc631 net422 net293 net513 net968 net780 net858 VGND VGND VPWR VPWR net965 sky130_fd_sc_hd__mux4_1
Xc664 clknet_1_0__leaf_net432 net215 net81 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__nand3_1
Xc697 net538 net556 net458 VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__and3b_1
Xc686 net558 net547 net548 net1027 VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__o211a_1
Xc675 net317 net204 VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__nand2_1
XANTENNA_input24_X net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c393_A2 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c584_A1 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_29_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c759_A1 clknet_1_1__leaf_net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c478_A2 net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c197_A3 net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge905_GATE clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc472 net800 VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__clkbuf_2
Xc461 net135 clknet_1_0__leaf_net356 net361 net352 net365 net981 VGND VGND VPWR VPWR
+ net370 sky130_fd_sc_hd__mux4_1
Xc450 net359 net215 net355 net263 VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__o211a_2
XFILLER_0_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc483 net380 net373 net968 net385 net387 net840 VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__mux4_1
Xc494 clknet_4_11_0_clk net991 net401 net392 net964 net1076 VGND VGND VPWR VPWR net403
+ net402 sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_1_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c465_B net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc68 net927 net917 VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__and2_1
XANTENNA_c714_S0 net532 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c433_S1 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c298_A2 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_524 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c246_X net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c595_B1 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c761_A2 net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net617 clknet_0_net617 VGND VGND VPWR VPWR clknet_1_1__leaf_net617
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c624_S0 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_587 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c704_Q net581 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc280 net199 net207 net213 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__and3_4
Xc291 net93 net86 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__nand2_1
XFILLER_0_47_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge790 net568 net562 net454 net442 clknet_1_0__leaf_net445 net1020 VGND VGND VPWR
+ VPWR net670 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_31_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold14 net173 VGND VGND VPWR VPWR net1071 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c62_S0 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold36 net886 VGND VGND VPWR VPWR net1093 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 net312 VGND VGND VPWR VPWR net1082 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s970_Q net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_39_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c491_A2 net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c619_S0 net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input51_A in54 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge831_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net425 clknet_0_net425 VGND VGND VPWR VPWR clknet_1_1__leaf_net425
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_579 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net992 clknet_0_net992 VGND VGND VPWR VPWR clknet_1_1__leaf_net992
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_36_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c330_B net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge889_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c209_X net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c621_S1 net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c486_A2 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c64_X net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c349_S0 net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c693_B1 net562 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_52 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c280_B net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c440_A net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs939 net222 clknet_4_12_0_clk VGND VGND VPWR VPWR net960 net835 sky130_fd_sc_hd__dlxbn_2
XFILLER_0_90_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net445 net445 VGND VGND VPWR VPWR clknet_0_net445 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c753_A3 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c420_B_N net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c254_CLK_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c616_S1 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input14_A in20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c497_A1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c632_S0 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net889 clknet_0_net889 VGND VGND VPWR VPWR clknet_1_0__leaf_net889
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_72_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc109 clknet_4_13_0_clk clknet_1_1__leaf_net39 net997 net32 net41 net725 VGND VGND
+ VPWR VPWR net48 net47 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_79_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input6_A in13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_0__f_net34_X clknet_1_0__leaf_net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c748_A3 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c764_A2 net508 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c483_A3 net385 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc621 clknet_1_0__leaf_net162 net923 net1061 net1024 net840 net981 VGND VGND VPWR
+ VPWR net516 sky130_fd_sc_hd__mux4_4
Xc610 net488 clknet_1_0__leaf_net503 net497 clknet_1_0__leaf_net504 net1029 net811
+ VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__mux4_4
Xc632 net965 clknet_1_1__leaf_net464 net513 net508 net803 net815 VGND VGND VPWR VPWR
+ net526 sky130_fd_sc_hd__mux4_2
Xc698 net1057 net548 net572 net560 net1026 VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__o221a_2
Xc687 clknet_4_0_0_clk net543 net558 net78 net555 net553 VGND VGND VPWR VPWR net561
+ net560 sky130_fd_sc_hd__sdfbbn_1
Xc665 net817 VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__inv_4
Xc676 net533 net543 net539 net540 net545 net879 VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__mux4_2
XANTENNA_c627_S0 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input17_X net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c131_CLK_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c301_B1 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c362_S0 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c393_A3 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge871_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c243_B net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_98_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c584_A2 net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c65_S0 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc214_2 net771 VGND VGND VPWR VPWR net1047 sky130_fd_sc_hd__clkinv_2
XANTENNA_input9_X net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc451 net1031 net319 net353 net728 net797 VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__o221ai_4
Xc473 clknet_4_9_0_clk net373 net381 net1022 net366 net365 VGND VGND VPWR VPWR net383
+ net382 sky130_fd_sc_hd__sdfbbn_1
Xc462 net365 net334 clknet_1_1__leaf_net832 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__nor3_1
Xc440 net913 net1031 net254 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__or3b_1
Xc484 net171 net42 clknet_1_0__leaf_net169 net375 clknet_1_0__leaf_net34 VGND VGND
+ VPWR VPWR net393 sky130_fd_sc_hd__o221a_2
Xc495 net262 net281 net941 net899 net401 net809 VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__mux4_1
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net54 clknet_0_net54 VGND VGND VPWR VPWR clknet_1_0__leaf_net54 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_70_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc69 net661 VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c222_C1 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c212_SCD net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c353_A net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c595_A1 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c690_SCD net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc270 net748 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__inv_6
Xc281 net214 net212 net210 net907 net213 net207 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__mux4_1
Xc292 net226 net224 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__or2b_2
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_580 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge791 net315 clknet_1_0__leaf_net427 net76 net1016 VGND VGND VPWR VPWR net671
+ sky130_fd_sc_hd__o211ai_4
XFILLER_0_43_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge780 net90 net898 net308 net1015 VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__o211ai_1
XFILLER_0_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c206_B net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c681_SCD net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge801_A0 net13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold37 net255 VGND VGND VPWR VPWR net1094 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 net794 VGND VGND VPWR VPWR net1072 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 net89 VGND VGND VPWR VPWR net1083 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c62_S1 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c756_A3 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c619_S1 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input44_A in48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge874_Q net761 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net993 clknet_0_net993 VGND VGND VPWR VPWR clknet_1_1__leaf_net993
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c156_B net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c149_A net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_16_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net616 net616 VGND VGND VPWR VPWR clknet_0_net616 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout117_X net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c174_S1 net763 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c349_S1 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input47_X net944 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_72_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_583 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c280_C net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c440_B net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c315_C1 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output75_A net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net868 clknet_0_net868 VGND VGND VPWR VPWR clknet_1_0__leaf_net868
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_96_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c550_A net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_A1 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c733_S0 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_B2 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c269_X net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c764_A3 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc611 net495 clknet_1_0__leaf_net503 net284 clknet_1_1__leaf_net504 net1040 net92
+ VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__mux4_2
Xc600 net422 net283 clknet_1_0__leaf_net372 net712 clknet_1_1__leaf_net992 clknet_1_0__leaf_net868
+ VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__mux4_4
Xc622 clknet_1_0__leaf_net34 clknet_1_0__leaf_net303 net780 net960 net843 net1032
+ VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__mux4_1
Xc633 net1029 net521 net422 net513 net845 net867 VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__mux4_1
XANTENNA_c135_C1 net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc688 clknet_4_0_0_clk net555 net1069 net557 net1027 VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__sdfrtp_4
Xc666 clknet_4_0_0_clk net424 net532 net78 net1026 VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__sdfrtp_2
Xc677 net1077 VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__inv_2
XANTENNA_c627_S1 net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc699 net566 net458 net556 net1026 net564 net883 VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c362_S1 net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge904_GATE_N clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c348_D net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout144_A net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s952_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c198_A_N net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c65_S1 net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc214_3 net771 VGND VGND VPWR VPWR net1048 sky130_fd_sc_hd__clkinv_2
XTAP_TAPCELL_ROW_29_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c79_7_A net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc430 net331 net229 net17 net1020 net994 net1030 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc441 net247 net207 net1030 net739 clknet_1_0__leaf_net850 VGND VGND VPWR VPWR net351
+ sky130_fd_sc_hd__o221a_2
Xc463 net935 clknet_1_0__leaf_net371 net352 VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__nand3b_2
Xc452 net784 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__clkinv_8
XFILLER_0_20_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc485 net334 net968 net261 net389 VGND VGND VPWR VPWR net975 sky130_fd_sc_hd__o211a_1
Xc474 clknet_1_1__leaf_net371 net350 net377 net2 VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__o211a_4
Xc496 net404 net1062 net976 net402 clknet_1_0__leaf_net162 net988 VGND VGND VPWR VPWR
+ net405 sky130_fd_sc_hd__mux4_4
XFILLER_0_19_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge916_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s934_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net22 clknet_0_net22 VGND VGND VPWR VPWR clknet_1_0__leaf_net22 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_7_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s939_GATE_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_10_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_hold18_X net1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c283_S0 net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c212_SCE net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c141_Y net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c730_S1 clknet_1_1__leaf_net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c595_A2 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout147_X net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c301_X net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c193_S0 net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc260 net195 net192 net970 net187 net47 net18 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__mux4_1
Xc271 net735 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__inv_2
XANTENNA_merge917_Q net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc282 clknet_4_5_0_clk net209 net216 net215 net213 net212 VGND VGND VPWR VPWR net218
+ net217 sky130_fd_sc_hd__sdfbbn_2
Xc293 net933 net212 net1036 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__or3b_2
XFILLER_0_62_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c696_A1 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge781 net793 VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__inv_2
Xmerge770 net200 net81 net205 net203 VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__o211a_1
XFILLER_0_28_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge792 clknet_1_1__leaf_net372 net1022 net988 clknet_1_0__leaf_net175 net150 net1075
+ VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__mux4_2
XFILLER_0_15_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold27 net215 VGND VGND VPWR VPWR net1084 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 net884 VGND VGND VPWR VPWR net1095 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c470_B net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold16 net833 VGND VGND VPWR VPWR net1073 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c741_S0 clknet_1_0__leaf_net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c127_B1 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input37_A in41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net438 clknet_0_net438 VGND VGND VPWR VPWR clknet_1_1__leaf_net438
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net427 clknet_0_net427 VGND VGND VPWR VPWR clknet_1_1__leaf_net427
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c480_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c601_RESET_B net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c360_SCD net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net961 clknet_0_net961 VGND VGND VPWR VPWR clknet_1_1__leaf_net961
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_88_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net617 net617 VGND VGND VPWR VPWR clknet_0_net617 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c323_C net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c316_B net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c228_C1 net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge812_B1 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c352_18_A net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge783_S0 net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge896_SET_B net663 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c453_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c230_B1 net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c221_Y net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net425 net425 VGND VGND VPWR VPWR clknet_0_net425 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_0_net992_A net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge823_C1 net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_2_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c683_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c497_A3 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s988_GATE clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net992 net992 VGND VGND VPWR VPWR clknet_0_net992 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_74_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c315_B1 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_66_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c331_C1 net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net869 clknet_0_net869 VGND VGND VPWR VPWR clknet_1_0__leaf_net869
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_75_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_84_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c733_S1 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_93_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc612 net387 net495 clknet_1_0__leaf_net504 clknet_1_0__leaf_net503 net811 net870
+ VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__mux4_4
Xc601 clknet_4_9_0_clk net484 net1029 net476 net1038 net1022 VGND VGND VPWR VPWR net495
+ net494 sky130_fd_sc_hd__sdfbbn_1
XANTENNA_c135_B1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc623 net320 net513 clknet_1_0__leaf_net464 net963 clknet_1_1__leaf_net992 clknet_1_1__leaf_net868
+ VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__mux4_2
Xc634 net1024 net42 net835 net1032 net867 net876 VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__mux4_1
XANTENNA_c196_S0 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc689 net547 net555 net556 net543 net561 net1026 VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__mux4_1
Xc667 net817 VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__inv_6
Xc678 net208 net542 net549 net548 net1069 net1067 VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__mux4_1
XFILLER_0_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output106_A net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_80_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c699_A1 net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c124_A net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c728_S1 net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c660_A net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c360_CLK_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c84_B net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc420 net226 net829 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__nor2b_1
XFILLER_0_20_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc464 net785 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__clkbuf_2
Xc431 net927 net450 net739 VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__nand3b_2
Xc442 net264 net245 net797 VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__and3b_2
Xc453 clknet_4_6_0_clk net944 net320 net972 net361 VGND VGND VPWR VPWR net987 net363
+ sky130_fd_sc_hd__sdfrbp_1
XFILLER_0_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc486 net975 net1024 net1044 clknet_1_1__leaf_net303 net777 VGND VGND VPWR VPWR net394
+ sky130_fd_sc_hd__o221a_4
Xc497 net403 net1041 clknet_1_1__leaf_net1008 net41 net401 net977 VGND VGND VPWR VPWR
+ net406 sky130_fd_sc_hd__mux4_4
Xc475 net759 VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__inv_2
XFILLER_0_99_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net12 clknet_0_net12 VGND VGND VPWR VPWR clknet_1_0__leaf_net12 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_67_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net34 clknet_0_net34 VGND VGND VPWR VPWR clknet_1_0__leaf_net34 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_70_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c222_A1 net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net430 clknet_0_net430 VGND VGND VPWR VPWR clknet_1_0__leaf_net430
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net485 clknet_0_net485 VGND VGND VPWR VPWR clknet_1_0__leaf_net485
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net496 clknet_0_net496 VGND VGND VPWR VPWR clknet_1_0__leaf_net496
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge815_A0 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c739_S0 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge843_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c663_X net535 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c153_Q net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c307_A1 net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc261 net923 net195 net970 net187 net805 clknet_1_1__leaf_net1002 VGND VGND VPWR VPWR
+ net197 sky130_fd_sc_hd__mux4_2
Xc272 net749 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__inv_12
Xc250 net789 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__clkinv_8
XFILLER_0_20_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc294 net101 net933 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__and2b_1
Xc283 net904 net213 net215 net217 net200 net209 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__mux4_1
XFILLER_0_46_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c287_B_N net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge782 net18 net1004 net55 net912 clknet_1_1__leaf_net160 net779 VGND VGND VPWR
+ VPWR net662 sky130_fd_sc_hd__mux4_2
Xmerge771 net0 net1004 net234 net267 VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__o211ai_1
XFILLER_0_7_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge793 net434 net1016 clknet_1_0__leaf_net438 net424 VGND VGND VPWR VPWR net673
+ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_31_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge801_A2 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold28 net61 VGND VGND VPWR VPWR net1085 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 net865 VGND VGND VPWR VPWR net1074 sky130_fd_sc_hd__dlygate4sd3_1
Xhold39 net113 VGND VGND VPWR VPWR net1096 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c568_C net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s949_Q net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c127_B2 net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net417 clknet_0_net417 VGND VGND VPWR VPWR clknet_1_1__leaf_net417
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_90_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c500_A1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net1008 net1008 VGND VGND VPWR VPWR clknet_0_net1008 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_39_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge783_S1 net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_hold38_A net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net770 clknet_0_net770 VGND VGND VPWR VPWR clknet_1_1__leaf_net770
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_49_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge807_A1 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c419_A net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout122_X net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c747_S0 net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c482_S0 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net993 net993 VGND VGND VPWR VPWR clknet_0_net993 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge794_S0 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c331_B1 net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net848 clknet_0_net848 VGND VGND VPWR VPWR clknet_1_0__leaf_net848
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_96_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_7_0_clk_X clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc613 net814 VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__buf_2
Xc602 net492 net142 net1029 net990 clknet_1_0__leaf_net868 VGND VGND VPWR VPWR net496
+ sky130_fd_sc_hd__o221a_4
Xc635 net528 net1029 clknet_1_0__leaf_net169 net422 clknet_1_1__leaf_net969 net876
+ VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__mux4_1
Xc624 net1043 clknet_1_1__leaf_net372 net1011 net1038 net422 net870 VGND VGND VPWR
+ VPWR net519 sky130_fd_sc_hd__mux4_4
XANTENNA_c196_S1 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc668 net761 VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__inv_1
Xc679 net545 net543 net772 VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__or3_4
XANTENNA_c233_SCD net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input12_A in19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output80_A net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap135_X net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net612 clknet_0_net612 VGND VGND VPWR VPWR clknet_1_0__leaf_net612
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge804_A2 net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input4_A in11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc192_1 clknet_1_0__leaf_net769 VGND VGND VPWR VPWR net1046 sky130_fd_sc_hd__inv_16
XFILLER_0_83_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c326_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc410 net718 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__inv_6
Xc421 net314 net331 net829 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__nor3_1
Xc432 net341 net86 clknet_1_1__leaf_net849 VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__nor3b_1
Xc443 clknet_4_6_0_clk net955 net1084 net1031 net1018 VGND VGND VPWR VPWR net972 net353
+ sky130_fd_sc_hd__sdfrbp_2
Xc454 net256 net119 net362 net987 net353 net856 VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__mux4_1
XFILLER_0_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc465 clknet_1_0__leaf_net371 net839 net854 VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__and3b_2
Xc487 clknet_4_9_0_clk net989 clknet_1_0__leaf_net961 net1024 net1041 net812 VGND
+ VGND VPWR VPWR net396 net395 sky130_fd_sc_hd__sdfbbn_1
Xc476 net385 net261 net818 VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__and3_1
Xc498 net392 net213 net403 net171 clknet_1_0__leaf_net304 net985 VGND VGND VPWR VPWR
+ net407 sky130_fd_sc_hd__mux4_4
XFILLER_0_35_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input15_X net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge920 clknet_4_11_0_clk net764 net731 VGND VGND VPWR VPWR net815 net966 sky130_fd_sc_hd__dfsbp_1
XFILLER_0_51_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net24 clknet_0_net24 VGND VGND VPWR VPWR clknet_1_0__leaf_net24 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_67_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net35 clknet_0_net35 VGND VGND VPWR VPWR clknet_1_0__leaf_net35 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_hold20_A net761 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c580_S0 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net464 clknet_0_net464 VGND VGND VPWR VPWR clknet_1_0__leaf_net464
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c234_A net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c739_S1 net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge786_S1 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_79_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc251 net153 net187 net163 net1042 clknet_1_1__leaf_net54 net185 VGND VGND VPWR VPWR
+ net188 sky130_fd_sc_hd__mux4_4
Xc240 net174 net171 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__nand2_1
Xc262 net191 clknet_1_0__leaf_net190 clknet_1_0__leaf_net998 net187 net999 net805
+ VGND VGND VPWR VPWR net993 sky130_fd_sc_hd__mux4_2
XANTENNA_c604_B1 net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_15_0_clk_X clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc273 net962 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__buf_1
Xc295 net231 net212 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__nand2b_1
Xc284 clknet_4_5_0_clk net202 net214 net217 net200 net1073 VGND VGND VPWR VPWR net221
+ net220 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_46_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge772 net223 net224 net205 net233 VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__o211ai_1
Xmerge794 net297 net273 clknet_1_1__leaf_net34 net127 net1000 net1065 VGND VGND VPWR
+ VPWR net674 sky130_fd_sc_hd__mux4_4
XFILLER_0_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge783 clknet_1_1__leaf_net356 net363 net277 net350 net281 net835 VGND VGND VPWR
+ VPWR net663 sky130_fd_sc_hd__mux4_1
XANTENNA_c666_SCD net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c217_A2 net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge801_A3 net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold18 net41 VGND VGND VPWR VPWR net1075 sky130_fd_sc_hd__dlygate4sd3_1
Xhold29 net153 VGND VGND VPWR VPWR net1086 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c191_B net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c463_C net352 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge826_A0 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c408_A1 net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c701_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c705_C1 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net418 clknet_0_net418 VGND VGND VPWR VPWR clknet_1_1__leaf_net418
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net429 clknet_0_net429 VGND VGND VPWR VPWR clknet_1_1__leaf_net429
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_90_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c500_A2 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c211_C net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge812_A2 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c194_Y net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c137_C_N net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c120_B_N net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c109_Q net48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input42_A in46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c170_C1 net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c154_B net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s982_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge807_A2 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c321_B net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net438 net438 VGND VGND VPWR VPWR clknet_0_net438 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_29_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net427 net427 VGND VGND VPWR VPWR clknet_0_net427 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_4_3_0_clk_X clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c763_S0 net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c482_S1 net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net961 net961 VGND VGND VPWR VPWR clknet_0_net961 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c315_A2 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c612_A0 net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c392_S1 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_58 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s964_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net849 clknet_0_net849 VGND VGND VPWR VPWR clknet_1_0__leaf_net849
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_72_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c241_B2 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c134_A_N net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c157_Y net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc603 clknet_4_9_0_clk net1022 net1020 net422 net1040 clknet_1_1__leaf_net869 VGND
+ VGND VPWR VPWR net498 net497 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_32_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc625 net1038 clknet_1_1__leaf_net516 net968 net389 net840 net858 VGND VGND VPWR VPWR
+ net520 sky130_fd_sc_hd__mux4_4
Xc636 net1060 net528 net41 net816 net990 net877 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__mux4_1
Xc614 clknet_1_1__leaf_net496 clknet_1_1__leaf_net503 net142 net353 net494 net870
+ VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__mux4_2
Xc669 net86 clknet_1_0__leaf_net848 VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__nand2b_1
XANTENNA_s946_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c699_A3 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge919_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s937_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge804_A3 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge820_A2 clknet_1_0__leaf_net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_57_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c603_CLK_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc411 net216 net321 net311 net314 net1033 net1015 VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__mux4_1
Xc400 net210 net199 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__nand2_2
Xc455 net776 VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__inv_4
Xc444 net931 net207 net334 VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__or3_1
Xc433 clknet_1_0__leaf_net342 net898 net341 net330 net212 net927 VGND VGND VPWR VPWR
+ net343 sky130_fd_sc_hd__mux4_1
Xc422 net742 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_8_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc477 net379 net385 net207 net8 net818 VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__o221ai_4
Xc466 net352 net284 net899 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__nor3_4
Xc488 net2 clknet_1_0__leaf_net304 net375 net395 clknet_1_1__leaf_net303 VGND VGND
+ VPWR VPWR net397 sky130_fd_sc_hd__o221ai_4
XFILLER_0_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc499 net366 net991 net403 clknet_1_0__leaf_net961 net159 clknet_1_0__leaf_net34 VGND
+ VGND VPWR VPWR net408 sky130_fd_sc_hd__mux4_2
XFILLER_0_35_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge910 clknet_4_3_0_clk net757 net670 VGND VGND VPWR VPWR net967 sky130_fd_sc_hd__sdlclkp_1
Xmerge921 clknet_4_14_0_clk net685 net724 VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__dfstp_2
Xclkbuf_1_0__f_net25 clknet_0_net25 VGND VGND VPWR VPWR clknet_1_0__leaf_net25 sky130_fd_sc_hd__clkbuf_16
XANTENNA_clkbuf_4_11_0_clk_X clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net36 clknet_0_net36 VGND VGND VPWR VPWR clknet_1_0__leaf_net36 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_27_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_93_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_hold13_A net48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c580_S1 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net432 clknet_0_net432 VGND VGND VPWR VPWR clknet_1_0__leaf_net432
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s974_GATE_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c101_S0 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c413_A2 net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c328_A_N net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c710_B1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c490_S1 clknet_1_1__leaf_net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c79_5_A net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c82_A net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc230 net143 clknet_1_1__leaf_net19 net997 clknet_1_0__leaf_net160 net28 VGND VGND
+ VPWR VPWR net167 sky130_fd_sc_hd__o221ai_4
XFILLER_0_60_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc252 clknet_1_1__leaf_net54 net69 net187 clknet_1_0__leaf_net1002 VGND VGND VPWR
+ VPWR net189 sky130_fd_sc_hd__o211a_1
Xc263 net181 clknet_1_1__leaf_net190 net48 net970 clknet_1_0__leaf_net993 VGND VGND
+ VPWR VPWR net198 sky130_fd_sc_hd__o221a_4
Xc241 net179 net178 net159 net1044 net779 VGND VGND VPWR VPWR net1009 sky130_fd_sc_hd__o221a_1
Xc296 net231 net229 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__or2b_2
Xc274 net202 net207 net943 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__or3b_1
Xc285 net221 net87 net199 net212 net215 net834 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__mux4_2
XANTENNA_c235_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge884_GCLK net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge773 net1030 clknet_1_1__leaf_net445 clknet_1_0__leaf_net417 net362 net861 VGND
+ VGND VPWR VPWR net653 sky130_fd_sc_hd__o221a_1
Xmerge784 net1047 net1000 clknet_1_0__leaf_net167 net729 VGND VGND VPWR VPWR net664
+ sky130_fd_sc_hd__o211a_1
Xmerge795 net948 net1003 clknet_1_0__leaf_net1008 net294 net290 clknet_1_0__leaf_net961
+ VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__mux4_4
XFILLER_0_28_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c666_SCE net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_0_net374_A net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold19 net846 VGND VGND VPWR VPWR net1076 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c184_B net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c591_S0 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_67_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge826_A1 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout145_X net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c132_X net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c404_Y net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c408_A2 net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c424_A1 net915 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c424_B2 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_98_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge915_Q net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net986 clknet_0_net986 VGND VGND VPWR VPWR clknet_1_1__leaf_net986
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c228_A2 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c435_A0 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c496_S0 clknet_1_0__leaf_net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input35_A in4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c321_C net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net417 net417 VGND VGND VPWR VPWR clknet_0_net417 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c536_C1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c352_16_A net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net30 net30 VGND VGND VPWR VPWR clknet_0_net30 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c548_SCD net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_17_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge891_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_26_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input38_X net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c331_A2 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge882_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge818_A2 net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c529_B net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c276_C_N net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_62_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc604 net476 net277 net281 clknet_1_0__leaf_net496 clknet_1_0__leaf_net969 VGND VGND
+ VPWR VPWR net499 sky130_fd_sc_hd__o221a_2
Xc626 net513 net389 net796 net825 net858 net874 VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__mux4_1
Xc615 net509 net495 net488 clknet_1_0__leaf_net503 net508 net963 VGND VGND VPWR VPWR
+ net510 sky130_fd_sc_hd__mux4_2
Xc637 net530 net284 net920 net971 net840 net877 VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_73_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c679_X net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_80_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net770 net770 VGND VGND VPWR VPWR clknet_0_net770 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c607_B2 net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c607_A1 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c623_A0 net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output66_A net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge855_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c479_B net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c541_A net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c708_B1 net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc412 clknet_4_4_0_clk net311 net322 net1033 net1015 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__sedfxtp_4
XANTENNA_merge846_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc401 net719 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__inv_2
Xc434 net337 clknet_1_0__leaf_net342 net994 net320 net133 net1066 VGND VGND VPWR VPWR
+ net344 sky130_fd_sc_hd__mux4_2
Xc423 net314 net829 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__and2b_1
Xc445 net784 VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc467 net785 VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__clkbuf_2
Xc456 net745 VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__buf_4
Xc478 net272 net387 net381 net385 net841 VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__o221a_1
Xc489 clknet_4_11_0_clk net375 net1068 clknet_1_0__leaf_net34 net843 VGND VGND VPWR
+ VPWR net979 sky130_fd_sc_hd__sdfrtn_1
XFILLER_0_35_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c453_Q net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_28_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output104_A net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge911 clknet_4_14_0_clk net666 net664 VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__sdlclkp_2
Xmerge922 clknet_4_0_0_clk net582 net673 VGND VGND VPWR VPWR net817 sky130_fd_sc_hd__dfstp_4
Xmerge900 net700 clknet_4_0_0_clk net605 VGND VGND VPWR VPWR net792 net791 sky130_fd_sc_hd__dlrbp_1
XFILLER_0_82_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c618_A0 net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge837_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s936_GCLK net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c589_S0 net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c263_B1 net48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c413_A3 net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c710_B2 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c264_A_N net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc220 net903 net127 clknet_1_1__leaf_net12 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_79_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc231 net28 clknet_1_0__leaf_net160 net47 clknet_1_1__leaf_net12 net1003 VGND VGND
+ VPWR VPWR net168 sky130_fd_sc_hd__o221ai_2
Xc253 net187 net1038 clknet_1_0__leaf_net1002 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__and3b_2
XFILLER_0_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c604_A2 net277 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc242 net798 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__clkbuf_2
Xc286 net95 net215 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__nand2b_1
Xc264 net899 net957 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__nand2b_4
Xc275 net751 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__inv_6
Xc297 net232 net230 net915 net1036 VGND VGND VPWR VPWR net1006 sky130_fd_sc_hd__o211ai_4
XANTENNA_input20_X net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge895_Q net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge774 net777 VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__inv_4
Xmerge796 net213 net209 net238 net234 VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_31_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge785 net354 net1018 clknet_1_1__leaf_net351 net357 net333 net839 VGND VGND VPWR
+ VPWR net665 sky130_fd_sc_hd__mux4_1
XFILLER_0_43_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c591_S1 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput1 in0 VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_67_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c449_C net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c337_A net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge826_A2 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c705_A1 net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c424_A2 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c721_B1 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c153_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_90_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c631_A0 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net998 clknet_0_net998 VGND VGND VPWR VPWR clknet_1_1__leaf_net998
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_36_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c242_X net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_530 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_500 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c496_S1 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c451_B1 net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input28_A in33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net418 net418 VGND VGND VPWR VPWR clknet_0_net418 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net429 net429 VGND VGND VPWR VPWR clknet_0_net429 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c597_S0 clknet_1_0__leaf_net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c690_D net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c297_Y net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c548_SCE clknet_1_0__leaf_net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c64_A0 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net1010 clknet_0_net1010 VGND VGND VPWR VPWR clknet_1_1__leaf_net1010
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_96_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c227_SCD net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s957_GATE_N clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout120_X net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c416_A3 net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc605 net487 net8 net981 net866 clknet_1_0__leaf_net969 VGND VGND VPWR VPWR net500
+ sky130_fd_sc_hd__o221ai_4
Xc627 net927 net487 net1024 net1040 net972 net977 VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__mux4_1
Xc616 net262 clknet_1_0__leaf_net34 net971 net846 net981 net873 VGND VGND VPWR VPWR
+ net511 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_73_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c457_C1 net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge769_C1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c479_C net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c687_SCD net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c708_A1 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc402 net732 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__inv_2
Xc435 net1020 clknet_1_1__leaf_net342 net341 net739 net797 clknet_1_0__leaf_net850
+ VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__mux4_4
Xc424 net915 net1030 net331 net1033 net1015 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__o221a_1
Xc413 net321 net313 net316 net320 net317 net1033 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__mux4_1
Xc446 net355 net354 clknet_1_1__leaf_net850 VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__nand3b_2
Xc457 net326 net972 net1037 net728 VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__o211ai_1
Xc479 net381 net246 net1038 VGND VGND VPWR VPWR net968 sky130_fd_sc_hd__nor3_4
Xc468 net149 net1043 net921 net920 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_28_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input10_A in17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge912 clknet_4_15_0_clk net686 net196 VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__sdlclkp_4
Xmerge901 net279 clknet_4_12_0_clk net699 VGND VGND VPWR VPWR net794 net793 sky130_fd_sc_hd__dlrbp_1
Xclkbuf_1_0__f_net16 clknet_0_net16 VGND VGND VPWR VPWR clknet_1_0__leaf_net16 sky130_fd_sc_hd__clkbuf_16
Xmerge923 clknet_4_4_0_clk net325 net384 VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__dfstp_4
XFILLER_0_82_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net38 clknet_0_net38 VGND VGND VPWR VPWR clknet_1_0__leaf_net38 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_43_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c618_A1 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge771_B1 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c634_A0 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net445 clknet_0_net445 VGND VGND VPWR VPWR clknet_1_0__leaf_net445
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input2_A in1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c710_A2 net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c499_S1 clknet_1_0__leaf_net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c72_B1 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c68_A net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc221 clknet_1_1__leaf_net29 net917 VGND VGND VPWR VPWR net1008 sky130_fd_sc_hd__nor2b_2
XTAP_TAPCELL_ROW_79_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc210 net743 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__clkbuf_2
Xc243 net64 net997 net983 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__or3b_1
Xc232 clknet_1_1__leaf_net162 clknet_1_1__leaf_net769 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__nand2b_2
Xc254 clknet_4_14_0_clk net1079 net185 net183 VGND VGND VPWR VPWR net192 net191 sky130_fd_sc_hd__dfbbn_1
XANTENNA_input58_A in60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc287 net929 net914 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__nor2b_4
Xc265 net958 net85 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__and2_4
Xc276 net89 net208 net207 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__nor3b_1
Xc298 net227 net927 net229 net224 net1036 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__o221a_2
XTAP_TAPCELL_ROW_5_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge888_Q net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge786 net278 clknet_1_1__leaf_net34 net45 net178 net1059 net1019 VGND VGND VPWR
+ VPWR net666 sky130_fd_sc_hd__mux4_1
Xmerge775 net239 net234 net128 net237 clknet_1_0__leaf_net130 VGND VGND VPWR VPWR
+ net655 sky130_fd_sc_hd__o221ai_2
XTAP_TAPCELL_ROW_31_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge797 net315 net1015 net320 net1082 VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__o211a_1
XFILLER_0_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput2 in1 VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_67_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c705_A2 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_500 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge872_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input5_X net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c109_CLK_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c359_B1 net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s985_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c451_A1 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c451_B2 net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c78_C1 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_87_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c601_CLK_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s967_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_8_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c597_S1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput60 in7 VGND VGND VPWR VPWR net957 sky130_fd_sc_hd__buf_2
XANTENNA_c493_SCE net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net54 net54 VGND VGND VPWR VPWR clknet_0_net54 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_79_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c64_A1 net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c727_B1 net562 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net986 net986 VGND VGND VPWR VPWR clknet_0_net986 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c107_Q net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input40_A in44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s949_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold29_A net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc617 clknet_1_0__leaf_net169 net972 net320 net858 net1032 clknet_1_1__leaf_net868
+ VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__mux4_4
Xc606 net487 net498 net494 net1020 net1012 VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__o221a_1
Xc628 net522 net42 clknet_1_0__leaf_net961 net1029 net844 net990 VGND VGND VPWR VPWR
+ net523 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_73_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c358_A_N net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c713_A2 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_84_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c457_B1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c623_A2 clknet_1_0__leaf_net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input43_X net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net616 clknet_0_net616 VGND VGND VPWR VPWR clknet_1_0__leaf_net616
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_98_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c367_A0 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c708_A2 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc403 net211 net313 VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__or2b_2
Xc414 net746 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__buf_6
Xc436 net934 clknet_1_1__leaf_net342 net92 net226 clknet_1_1__leaf_net849 net851 VGND
+ VGND VPWR VPWR net346 sky130_fd_sc_hd__mux4_4
Xc425 net228 net322 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__nor2b_1
Xc447 clknet_1_1__leaf_net351 net1031 net898 net972 VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__o211ai_4
Xc458 clknet_1_0__leaf_net351 net365 net935 net92 net364 net856 VGND VGND VPWR VPWR
+ net978 sky130_fd_sc_hd__mux4_1
Xc469 net377 net352 net812 VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_28_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c86_C1 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge902 net753 clknet_4_2_0_clk net603 VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__dlrtn_1
XANTENNA_c707_SET_B net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge913 clknet_4_1_0_clk net704 net705 VGND VGND VPWR VPWR net807 net806 sky130_fd_sc_hd__dfrbp_1
XANTENNA_c468_C1 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge924 net736 clknet_4_7_0_clk net737 VGND VGND VPWR VPWR net820 net819 sky130_fd_sc_hd__dlrbn_1
XFILLER_0_67_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net39 clknet_0_net39 VGND VGND VPWR VPWR clknet_1_0__leaf_net39 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c618_A2 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c634_A1 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output71_A net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge863_GATE clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c272_Y net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c126_S0 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c265_X net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c719_A1 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_81_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c72_A1 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c68_B net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c454_A1 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc200 net721 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__buf_6
Xc211 net136 net145 net148 VGND VGND VPWR VPWR net988 sky130_fd_sc_hd__nand3b_4
XFILLER_0_32_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc244 clknet_1_1__leaf_net176 clknet_1_0__leaf_net168 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__and2_1
Xc222 net902 net28 clknet_1_1__leaf_net157 net988 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__o211a_4
Xc233 clknet_4_15_0_clk clknet_1_0__leaf_net1008 net127 clknet_1_0__leaf_net167 clknet_1_1__leaf_net769
+ VGND VGND VPWR VPWR net171 net170 sky130_fd_sc_hd__sdfsbp_2
XPHY_EDGE_ROW_68_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc255 net14 net974 net787 VGND VGND VPWR VPWR net970 sky130_fd_sc_hd__or3_4
Xc288 net224 net79 net98 net100 net1034 net765 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__mux4_1
Xc266 net735 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__buf_6
Xc277 net775 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__buf_2
Xc299 net1090 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__inv_4
XFILLER_0_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A3 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c348_SCD net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c629_A1 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge787 clknet_1_1__leaf_net111 net146 net1003 net820 VGND VGND VPWR VPWR net667
+ sky130_fd_sc_hd__o211a_2
XANTENNA_merge782_A0 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge776 net1033 net476 net246 clknet_1_1__leaf_net504 net494 clknet_1_1__leaf_net503
+ VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__mux4_2
Xmerge765 net332 net200 net308 net330 net336 net1030 VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__mux4_1
Xmerge798 net206 net203 net80 net958 VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__o211ai_1
XFILLER_0_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput3 in10 VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_67_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_39_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout140_A net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c555_B1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c481_C1 net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c350_A3 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c569_SCD net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net967 clknet_0_net967 VGND VGND VPWR VPWR clknet_1_1__leaf_net967
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net978 clknet_0_net978 VGND VGND VPWR VPWR clknet_1_1__leaf_net978
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c109_RESET_B net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_36_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge806_S0 net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge901_GATE clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_4_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout143_X net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c285_A0 net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c732_A1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_7_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c451_A2 net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge788_C1 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c536_A2 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge885_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput50 in53 VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__buf_1
Xinput61 in8 VGND VGND VPWR VPWR net958 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_12_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net22 net22 VGND VGND VPWR VPWR clknet_0_net22 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_67_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c727_A1 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c727_B2 net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net998 net998 VGND VGND VPWR VPWR clknet_0_net998 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_0_net1008_A net1008 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input33_A in38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c637_A1 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s986_GATE_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_22_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c547_A1 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc607 net246 net500 net386 net320 clknet_1_0__leaf_net832 VGND VGND VPWR VPWR net502
+ sky130_fd_sc_hd__o221a_1
Xc618 net281 net1038 net1040 net1045 net844 net867 VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_73_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc629 net521 net1024 net513 clknet_1_0__leaf_net162 net816 net1032 VGND VGND VPWR
+ VPWR net524 sky130_fd_sc_hd__mux4_1
XANTENNA_c352_14_A net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_40_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c738_B1 net562 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_12_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c623_A3 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge769_A1 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c412_DE net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net617 clknet_0_net617 VGND VGND VPWR VPWR clknet_1_0__leaf_net617
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c367_A1 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c502_S0 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c226_B_N net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge814_S0 net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c255_A net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c574_C1 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c210_X net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc415 net314 net321 net310 net200 net1033 net1015 VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__mux4_1
Xc426 net229 net236 VGND VGND VPWR VPWR net971 sky130_fd_sc_hd__nand2b_2
Xc437 net341 net1033 net797 net829 net851 net854 VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__mux4_2
Xc404 net718 VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__inv_8
Xc459 net364 net1031 net898 net367 net353 clknet_1_0__leaf_net978 VGND VGND VPWR VPWR
+ net368 sky130_fd_sc_hd__mux4_4
Xc448 clknet_1_0__leaf_net351 net835 clknet_1_1__leaf_net850 VGND VGND VPWR VPWR net358
+ sky130_fd_sc_hd__nor3b_4
XANTENNA_c740_A1 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c569_CLK_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge903 net717 clknet_4_10_0_clk net766 VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__dlrtn_1
XANTENNA_c468_B1 net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge925 net783 clknet_4_8_0_clk net782 VGND VGND VPWR VPWR net822 net821 sky130_fd_sc_hd__dlrbn_1
Xmerge914 clknet_4_9_0_clk net397 net672 VGND VGND VPWR VPWR net809 net808 sky130_fd_sc_hd__dfrbp_1
Xclkbuf_1_0__f_net29 clknet_0_net29 VGND VGND VPWR VPWR clknet_1_0__leaf_net29 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c618_A3 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c484_C1 clknet_1_0__leaf_net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge771_A2 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c634_A2 net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c407_DE net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge796_C1 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net425 clknet_0_net425 VGND VGND VPWR VPWR clknet_1_0__leaf_net425
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge928_GATE_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c126_S1 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c288_A0 net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c109_SCE net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_81_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net992 clknet_0_net992 VGND VGND VPWR VPWR clknet_1_0__leaf_net992
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_37_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c72_A2 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc201 net810 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_79_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc212 clknet_4_12_0_clk net147 net141 net146 net1022 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__sdfrtp_2
XANTENNA_c454_A2 net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc245 net14 net70 net64 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__and3_1
Xc234 net804 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__buf_2
Xc223 net813 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__buf_2
XANTENNA_c751_A0 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc256 net184 clknet_1_0__leaf_net190 net187 net970 clknet_1_0__leaf_net1002 VGND VGND
+ VPWR VPWR net193 sky130_fd_sc_hd__o221ai_2
Xc278 net751 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__clkinv_4
Xc267 net905 net79 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__nand2b_1
Xc289 net768 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__buf_1
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c493_CLK_N clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c284_Q net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c348_SCE net277 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge777 net928 net1014 net26 clknet_1_1__leaf_net25 VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__o211a_1
XANTENNA_merge782_A1 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge788 clknet_1_0__leaf_net16 net0 net224 net21 net1000 VGND VGND VPWR VPWR net668
+ sky130_fd_sc_hd__o221ai_2
Xmerge766 clknet_4_0_0_clk clknet_1_0__leaf_net430 clknet_1_0__leaf_net438 net204
+ net532 VGND VGND VPWR VPWR net646 net645 sky130_fd_sc_hd__sdfsbp_1
Xmerge799 net237 net73 net200 net812 VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__o211ai_1
XFILLER_0_55_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput4 in11 VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_67_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge811_S1 net763 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_0_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c600_S0 clknet_1_1__leaf_net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c631_A3 net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c359_A2 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c182_C net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge822_S0 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c335_A net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout136_X net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c732_A2 net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge876_GATE clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c314_S1 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c83_Y net21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c76_X net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c487_SCD net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge906_Q net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge788_B1 net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput40 in44 VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__buf_1
Xinput51 in54 VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__clkbuf_2
Xinput62 in9 VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_12_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge817_S0 net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net12 net12 VGND VGND VPWR VPWR clknet_0_net12 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net34 net34 VGND VGND VPWR VPWR clknet_0_net34 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_79_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c415_S0 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c452_A net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c64_A3 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c727_A2 net588 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c743_B2 net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net1002 clknet_0_net1002 VGND VGND VPWR VPWR clknet_1_1__leaf_net1002
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_input26_A in31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c637_A2 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge790_A1 net562 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge799_C1 net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c138_B net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c305_B net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc608 net497 clknet_1_1__leaf_net967 net1013 VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__or3b_1
Xc619 net498 net1011 clknet_1_0__leaf_net162 clknet_1_1__leaf_net464 net835 net1032
+ VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__mux4_4
XFILLER_0_69_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c145_S0 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c738_A1 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c738_B2 net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c457_A2 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge769_A2 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input29_X net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge785_A1 net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge814_S1 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c716_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net1010 clknet_0_net1010 VGND VGND VPWR VPWR clknet_1_0__leaf_net1010
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_20_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c574_B1 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc416 net326 net324 net1015 net818 net990 net847 VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__mux4_1
Xc405 net310 net218 VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__nor2_4
Xc427 net742 VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__clkbuf_1
Xc438 net218 net341 net332 net347 clknet_1_0__leaf_net850 net852 VGND VGND VPWR VPWR
+ net348 sky130_fd_sc_hd__mux4_1
Xc449 net358 net354 net135 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__nand3_2
XANTENNA_c740_A2 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c342_C_N net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c749_A0 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c86_A1 net21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmerge904 net349 clknet_4_4_0_clk net344 VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__dlrtn_2
XANTENNA_c468_A1 net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge915 clknet_4_13_0_clk net707 net738 VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__dfrtn_1
Xmerge926 net398 clknet_4_11_0_clk net499 VGND VGND VPWR VPWR net823 net1013 sky130_fd_sc_hd__dlrbp_1
XFILLER_0_95_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net19 clknet_0_net19 VGND VGND VPWR VPWR clknet_1_0__leaf_net19 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c634_A3 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge861_GATE_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge809_S1 net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c532_A net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c719_A3 net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net993 clknet_0_net993 VGND VGND VPWR VPWR clknet_1_0__leaf_net993
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_61_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge921_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c735_A2 net581 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc202 net789 VGND VGND VPWR VPWR net996 sky130_fd_sc_hd__inv_6
XANTENNA_c454_A3 net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc213 net1003 net115 net144 net830 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__o211a_1
Xc235 clknet_4_12_0_clk net917 clknet_1_0__leaf_net157 net1014 net948 net1065 VGND
+ VGND VPWR VPWR net174 net173 sky130_fd_sc_hd__sdfbbp_1
Xc224 net804 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_92_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc257 clknet_1_1__leaf_net190 net64 net970 net47 net183 clknet_1_1__leaf_net1002 VGND
+ VGND VPWR VPWR net194 sky130_fd_sc_hd__mux4_4
Xc268 net202 net201 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__and2_1
Xc279 net734 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__inv_4
XFILLER_0_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c751_A1 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc246 net798 VGND VGND VPWR VPWR net1001 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c317_S1 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c629_A3 clknet_1_0__leaf_net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge767 net930 net80 net102 net95 net1035 VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__o221ai_1
XANTENNA_merge912_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge778 net347 clknet_1_1__leaf_net427 clknet_1_0__leaf_net849 net851 VGND VGND
+ VPWR VPWR net658 sky130_fd_sc_hd__o211ai_1
XANTENNA_s930_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge789 net810 VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__clkinv_4
XFILLER_0_24_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c284_SCE net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput5 in12 VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c306_C_N net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c746_A1 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c600_S1 clknet_1_0__leaf_net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c66_A net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input56_A in59 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s979_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge777_A2 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net969 clknet_0_net969 VGND VGND VPWR VPWR clknet_1_1__leaf_net969
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_87_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c330_A_N net21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge886_Q net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c285_A2 net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout129_X net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c485_X net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input3_X net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c78_A2 net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c757_A0 clknet_1_1__leaf_net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c611_S0 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c407_Q net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c487_SCE net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_merge788_B2 net21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput30 in35 VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__buf_4
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput52 in55 VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput41 in45 VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__buf_1
XFILLER_0_52_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge817_S1 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net24 net24 VGND VGND VPWR VPWR clknet_0_net24 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net35 net35 VGND VGND VPWR VPWR clknet_0_net35 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c445_A net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c338_Y net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net967 net967 VGND VGND VPWR VPWR clknet_0_net967 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net978 net978 VGND VGND VPWR VPWR clknet_0_net978 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_22_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c743_A2 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_89_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input19_A in25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c637_A3 net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output87_A net984 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge799_B1 net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net541 clknet_0_net541 VGND VGND VPWR VPWR clknet_1_1__leaf_net541
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc609 net385 net387 net487 clknet_1_1__leaf_net503 clknet_1_0__leaf_net869 VGND VGND
+ VPWR VPWR net504 sky130_fd_sc_hd__o221ai_1
XFILLER_0_12_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c183_X net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c738_A2 net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c754_A1 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_hold27_A net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net371 clknet_0_net371 VGND VGND VPWR VPWR clknet_1_1__leaf_net371
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c150_B net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c143_A net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c574_A1 net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c574_B2 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc417 net322 net311 net1041 net990 net847 clknet_1_1__leaf_net848 VGND VGND VPWR VPWR
+ net329 sky130_fd_sc_hd__mux4_1
Xc428 net236 net326 net310 net739 net1066 VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__o221ai_4
Xc406 clknet_4_4_0_clk net316 net312 net313 net1015 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__sedfxtp_4
XFILLER_0_13_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc439 net212 net347 clknet_1_0__leaf_net342 clknet_1_1__leaf_net849 net852 net855
+ VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__mux4_2
XANTENNA_merge921_D net685 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c749_A1 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c468_A2 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge927 net518 clknet_4_10_0_clk net756 VGND VGND VPWR VPWR net825 net824 sky130_fd_sc_hd__dlrbp_1
Xmerge916 clknet_4_8_0_clk net510 net502 VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__dfrtp_2
Xmerge905 net730 clknet_4_9_0_clk net662 VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__dlrtp_2
XFILLER_0_82_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_max_cap121_A net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge796_A1 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net438 clknet_0_net438 VGND VGND VPWR VPWR clknet_1_0__leaf_net438
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net427 clknet_0_net427 VGND VGND VPWR VPWR clknet_1_0__leaf_net427
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c501_RESET_B net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c394_A1 net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_19_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net190 clknet_0_net190 VGND VGND VPWR VPWR clknet_1_1__leaf_net190
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net961 clknet_0_net961 VGND VGND VPWR VPWR clknet_1_0__leaf_net961
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c146_X net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c735_A3 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_28_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc203 net141 net740 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__and2_2
Xc225 net760 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_79_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc236 clknet_1_0__leaf_net157 clknet_1_1__leaf_net22 net171 clknet_1_1__leaf_net162
+ net1044 clknet_1_0__leaf_net172 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__mux4_2
XFILLER_0_20_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc258 net70 net77 net787 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__and3b_1
Xc247 clknet_1_1__leaf_net160 net48 net1001 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__nor3b_2
Xc269 net765 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_69_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c495_A0 net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge768 net103 net122 net124 net121 VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__o211ai_1
Xmerge779 net91 net315 clknet_1_0__leaf_net417 net316 VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__o211ai_2
XANTENNA_merge782_A3 net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge929_Q net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput6 in13 VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_36_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_wire127_X net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c686_C1 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c113_B net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout119_A net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c263_X net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c292_B_N net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c746_A2 clknet_1_1__leaf_net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c66_B net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c762_A1 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c481_A2 net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input49_A in52 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge793_A2 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c443_Q_N net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge897_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c223_A net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge888_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c328_B net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c429_S0 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c757_A1 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c611_S1 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput20 in26 VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput31 in36 VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_71_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput53 in56 VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__clkbuf_2
Xinput42 in46 VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_71_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c180_B net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net25 net25 VGND VGND VPWR VPWR clknet_0_net25 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net36 net36 VGND VGND VPWR VPWR clknet_0_net36 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c712_S0 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c577_B2 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout141_X net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge799_A1 net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c678_A0 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_73_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_23_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c617_S0 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input31_A in36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c680_A1 net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net372 clknet_0_net372 VGND VGND VPWR VPWR clknet_1_1__leaf_net372
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c150_C net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc407 clknet_4_4_0_clk net313 net317 net315 net1015 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__sedfxtp_4
Xc418 net74 net213 net322 net818 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__o211ai_1
XFILLER_0_13_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc429 net336 net1020 net228 net23 net1037 net1081 VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c749_A2 clknet_1_0__leaf_net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge917 clknet_4_7_0_clk net726 net747 VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__dfrtp_4
Xmerge906 net466 clknet_4_3_0_clk net591 VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__dlrtp_1
Xmerge928 net517 clknet_4_9_0_clk net762 VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__dlrtn_1
XANTENNA_c168_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c484_A2 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input34_X net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net417 clknet_0_net417 VGND VGND VPWR VPWR clknet_1_0__leaf_net417
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c394_A2 net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c691_A0 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c198_C net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c358_B net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c585_A1 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc215 net788 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__inv_8
Xc226 clknet_1_1__leaf_net12 net1039 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__or2b_2
XTAP_TAPCELL_ROW_79_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc204 net790 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__inv_1
XFILLER_0_60_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc237 net953 net161 clknet_1_1__leaf_net160 net173 net170 VGND VGND VPWR VPWR net176
+ sky130_fd_sc_hd__o221ai_2
Xc248 net793 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__inv_2
Xc259 net805 VGND VGND VPWR VPWR net998 sky130_fd_sc_hd__buf_4
XFILLER_0_13_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge805_Y net685 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c495_A1 net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmerge769 net76 net1040 net909 net80 VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__o211a_1
XANTENNA_c630_S0 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc760 net636 clknet_1_1__leaf_net546 net872 clknet_1_1__leaf_net887 net896 net897
+ VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__mux4_1
Xinput7 in14 VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c596_B1 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net770 clknet_0_net770 VGND VGND VPWR VPWR clknet_1_0__leaf_net770
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c423_X net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c625_S0 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c85_10_A net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output100_A net997 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_1_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c672_A2 net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc590 clknet_1_1__leaf_net429 net481 net468 net476 net799 net867 VGND VGND VPWR VPWR
+ net483 sky130_fd_sc_hd__mux4_1
XFILLER_0_44_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c328_C net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout131_A net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_65_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c697_C net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c63_S0 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s980_Q net884 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_74_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c492_A2 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input61_A in8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c355_S0 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_92_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput21 in27 VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_12_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput10 in17 VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__clkbuf_2
Xinput54 in57 VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__buf_1
Xinput32 in37 VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__buf_1
XFILLER_0_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput43 in47 VGND VGND VPWR VPWR net940 sky130_fd_sc_hd__buf_2
XANTENNA_c249_S1 net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c104_Q_N net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c712_S1 net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout134_X net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net969 net969 VGND VGND VPWR VPWR clknet_0_net969 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_43_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c622_S1 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_84_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s943_Q net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c754_A3 clknet_1_1__leaf_net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_95_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input24_A in3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c498_A1 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output92_A net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c680_A2 net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net351 clknet_0_net351 VGND VGND VPWR VPWR clknet_1_1__leaf_net351
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s951_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c129_A net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net1002 clknet_0_net1002 VGND VGND VPWR VPWR clknet_1_0__leaf_net1002
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_20_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc419 net86 net236 net836 VGND VGND VPWR VPWR net994 sky130_fd_sc_hd__nor3_4
Xc408 net313 net317 net199 net212 net312 net834 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__mux4_2
XANTENNA_clkbuf_4_6_0_clk_X clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge810_C1 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c599_B1 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc85_10 net771 VGND VGND VPWR VPWR net1055 sky130_fd_sc_hd__inv_4
XFILLER_0_67_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge918 clknet_4_15_0_clk net63 net674 VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__dfrtp_4
Xmerge907 net477 clknet_4_3_0_clk net688 VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__dlrtp_1
XFILLER_0_36_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge929 net414 clknet_4_11_0_clk net405 VGND VGND VPWR VPWR net977 sky130_fd_sc_hd__dlrtn_1
Xclkbuf_0_net541 net541 VGND VGND VPWR VPWR clknet_0_net541 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c628_S0 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s961_SLEEP_B clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net429 clknet_0_net429 VGND VGND VPWR VPWR clknet_1_0__leaf_net429
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net418 clknet_0_net418 VGND VGND VPWR VPWR clknet_1_0__leaf_net418
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s933_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c394_A3 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_10_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c253_B net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c246_A net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c139_Y net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_33_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c201_X net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc227 clknet_4_15_0_clk clknet_1_1__leaf_net25 net926 clknet_1_1__leaf_net162 clknet_1_0__leaf_net160
+ VGND VGND VPWR VPWR net164 net163 sky130_fd_sc_hd__sdfsbp_1
Xc205 net918 net136 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_79_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc216 net148 net150 net149 net151 VGND VGND VPWR VPWR net1004 sky130_fd_sc_hd__o211a_2
XFILLER_0_13_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_92_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc249 net164 clknet_1_0__leaf_net54 net180 net912 clknet_1_0__leaf_net160 net14 VGND
+ VGND VPWR VPWR net186 sky130_fd_sc_hd__mux4_2
Xc238 net1055 net174 clknet_1_1__leaf_net167 clknet_1_1__leaf_net160 clknet_1_1__leaf_net169
+ clknet_1_0__leaf_net176 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__mux4_1
XFILLER_0_99_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c325_Q net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s958_GATE_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c495_A2 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net371 net371 VGND VGND VPWR VPWR clknet_0_net371 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc750 clknet_1_1__leaf_net546 net867 net871 net872 net891 net893 VGND VGND VPWR VPWR
+ net630 sky130_fd_sc_hd__mux4_4
Xc761 net598 net824 net871 clknet_1_1__leaf_net889 net896 net897 VGND VGND VPWR VPWR
+ net641 sky130_fd_sc_hd__mux4_2
Xinput8 in15 VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_78_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_2_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c731_S0 clknet_1_0__leaf_net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c596_B2 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c762_A3 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_4_14_0_clk_X clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net190 net190 VGND VGND VPWR VPWR clknet_0_net190 sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge887_CLK_N clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc580 net469 net1040 clknet_1_1__leaf_net445 clknet_1_1__leaf_net417 net1020 net1030
+ VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__mux4_2
Xc591 net446 net480 net972 net468 net1028 net862 VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__mux4_1
XFILLER_0_63_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_63_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s941_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c111_A net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c582_A3 net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_76_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c726_S0 net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input54_A in57 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c636_S0 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c355_S1 net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net769 clknet_0_net769 VGND VGND VPWR VPWR clknet_1_1__leaf_net769
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput22 in28 VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__buf_1
Xinput11 in18 VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_71_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput55 in58 VGND VGND VPWR VPWR net952 sky130_fd_sc_hd__buf_4
Xinput33 in38 VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__clkbuf_1
Xinput44 in48 VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_12_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net16 net16 VGND VGND VPWR VPWR clknet_0_net16 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net38 net38 VGND VGND VPWR VPWR clknet_0_net38 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c443_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c281_S0 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c587_RESET_B net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c175_S1 net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input1_X net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge873_GATE_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c119_CLK_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c131_RESET_B net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge907_GATE clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c231_C1 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c588_A2 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_2_0_clk_X clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c125_B1 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c407_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input17_A in23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c633_S1 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output85_A net982 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net374 clknet_0_net374 VGND VGND VPWR VPWR clknet_1_1__leaf_net374
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c136_C net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc409 net312 net317 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__or2b_1
XANTENNA_merge810_B1 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input9_A in16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c599_A1 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c599_B2 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge919 clknet_4_9_0_clk net714 net656 VGND VGND VPWR VPWR net1012 net814 sky130_fd_sc_hd__dfsbp_1
Xmerge908 clknet_4_3_0_clk net268 net698 VGND VGND VPWR VPWR net802 net801 sky130_fd_sc_hd__edfxbp_1
XFILLER_0_36_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c613_X net508 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge765_S1 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c628_S1 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s939_D net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge851_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net160 clknet_0_net160 VGND VGND VPWR VPWR clknet_1_1__leaf_net160
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_81_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net986 clknet_0_net986 VGND VGND VPWR VPWR clknet_1_0__leaf_net986
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c729_S0 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_446 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc206 net145 net127 net143 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__nand3b_4
Xc217 net150 net146 net919 net1086 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_92_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc228 clknet_1_0__leaf_net30 net1003 clknet_1_0__leaf_net25 net14 VGND VGND VPWR VPWR
+ net165 sky130_fd_sc_hd__o211ai_4
Xc239 clknet_4_14_0_clk clknet_1_1__leaf_net172 net164 clknet_1_1__leaf_net167 net1071
+ VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__sdfstp_1
XFILLER_0_13_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_101_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c495_A3 net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net372 net372 VGND VGND VPWR VPWR clknet_0_net372 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc740 net383 net125 net1017 clknet_1_0__leaf_net616 net1038 clknet_1_0__leaf_net868
+ VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__mux4_1
Xc751 net1045 net799 net874 net878 net892 net895 VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__mux4_4
Xc762 net634 net284 clknet_1_1__leaf_net546 net867 net893 net896 VGND VGND VPWR VPWR
+ net642 sky130_fd_sc_hd__mux4_4
XFILLER_0_31_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput9 in16 VGND VGND VPWR VPWR net906 sky130_fd_sc_hd__buf_2
XFILLER_0_86_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_30_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c363_B net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c596_A2 net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c77_S0 net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c459_S0 net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_24_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc570 net1027 net455 net459 net752 VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__o211ai_1
Xc581 net776 VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__inv_2
XANTENNA_c324_C1 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc592 net247 net478 net479 clknet_1_1__leaf_net429 net800 net866 VGND VGND VPWR VPWR
+ net485 sky130_fd_sc_hd__mux4_4
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout117_A net982 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput110 net1007 VGND VGND VPWR VPWR out59 sky130_fd_sc_hd__buf_2
XFILLER_0_100_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge802_A1 clknet_1_0__leaf_net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c726_S1 net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c103_A3 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_1_1__f_net992_X clknet_1_1__leaf_net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s966_Q net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_140 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c461_S1 net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_98_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input47_A in50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput12 in19 VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_12_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput23 in29 VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__buf_4
Xinput45 in49 VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__buf_1
Xinput34 in39 VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__clkbuf_2
Xinput56 in59 VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_12_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net39 net39 VGND VGND VPWR VPWR clknet_0_net39 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_48_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c281_S1 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c571_SCE net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c463_A_N net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c229_C1 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge813_A0 net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c67_Y net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c122_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge839_CLK_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c602_C1 clknet_1_0__leaf_net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c694_A2 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_73_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c276_B net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c231_B1 net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c588_A3 net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c269_A net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge808_A0 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_95_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c125_B2 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c104_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c480_SCD net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c480_RESET_B net385 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c348_Q net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output78_A net975 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net342 clknet_0_net342 VGND VGND VPWR VPWR clknet_1_1__leaf_net342
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c599_A2 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge909 clknet_4_10_0_clk net750 net754 VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__edfxtp_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c325_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c487_SET_B net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c197_S0 net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c453_SCD net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c152_C1 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output116_A net1013 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_55 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold18_A net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net172 clknet_0_net172 VGND VGND VPWR VPWR clknet_1_1__leaf_net172
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_81_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout147_A net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net998 clknet_0_net998 VGND VGND VPWR VPWR clknet_1_0__leaf_net998
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s987_GATE_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc207 net777 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__clkinv_4
Xc218 net1048 net149 net146 net141 net153 net721 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__mux4_1
XANTENNA_c683_SCD net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c729_S1 net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc229 net917 clknet_1_0__leaf_net29 net163 net2 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__o211ai_1
XFILLER_0_13_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c396_Y net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c94_B net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge783_X net663 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c687_CLK_N clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0_net351 net351 VGND VGND VPWR VPWR clknet_0_net351 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc730 net551 net598 net562 net799 clknet_1_0__leaf_net832 clknet_1_1__leaf_net992
+ VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__mux4_4
XFILLER_0_31_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc752 net588 clknet_1_0__leaf_net992 net878 clknet_1_1__leaf_net889 net891 net895
+ VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__mux4_2
Xc763 net641 net508 net803 net875 net884 net896 VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__mux4_1
Xc741 clknet_1_1__leaf_net617 net824 net963 clknet_1_0__leaf_net832 clknet_1_0__leaf_net868
+ net890 VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__mux4_4
XFILLER_0_31_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c313_A1 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_1_0__f_net992_X clknet_1_0__leaf_net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_0_net546_A net546 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c363_C net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c144_Y net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c137_X net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c311_Y net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c77_S1 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c459_S1 clknet_1_0__leaf_net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s970_GATE_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc571 clknet_4_1_0_clk net455 net454 clknet_1_1__leaf_net427 net1028 net752 VGND VGND
+ VPWR VPWR net463 net462 sky130_fd_sc_hd__sdfbbn_1
Xc582 net473 clknet_1_0__leaf_net417 net469 net921 net940 net862 VGND VGND VPWR VPWR
+ net474 sky130_fd_sc_hd__mux4_2
XANTENNA_c324_B1 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc593 net471 net463 clknet_1_1__leaf_net485 clknet_1_1__leaf_net417 net468 net712
+ VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__mux4_2
XPHY_EDGE_ROW_16_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_25_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c85_8_A net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c218_A1 net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput100 net997 VGND VGND VPWR VPWR out47 sky130_fd_sc_hd__buf_2
XFILLER_0_88_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput111 clknet_1_1__leaf_net1008 VGND VGND VPWR VPWR out6 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_100_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c107_Q_N net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c466_A net352 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c128_A1 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c189_S1 net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_98_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_52_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge929_GATE_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput13 in2 VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__buf_1
Xinput35 in4 VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__buf_1
Xinput24 in3 VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__buf_8
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput46 in5 VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__buf_1
XFILLER_0_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput57 in6 VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_70_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net29 net29 VGND VGND VPWR VPWR clknet_0_net29 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s981_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge813_A1 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_net1008 clknet_0_net1008 VGND VGND VPWR VPWR clknet_1_1__leaf_net1008
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_97_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c701_SET_B net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c602_B1 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net546 clknet_0_net546 VGND VGND VPWR VPWR clknet_1_1__leaf_net546
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s963_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_556 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge808_A1 net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout132_X net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net769 net769 VGND VGND VPWR VPWR clknet_0_net769 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_95_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c480_SCE net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c483_S0 net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c332_B1 net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge918_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s936_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap121 net985 VGND VGND VPWR VPWR net1018 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_96_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge819_A0 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s941_Q net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c417_A0 net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input22_A in28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output109_A net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_output90_A net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net140 clknet_0_net140 VGND VGND VPWR VPWR clknet_1_1__leaf_net140
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net162 clknet_0_net162 VGND VGND VPWR VPWR clknet_1_1__leaf_net162
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_82_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_53_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net868_X clknet_1_0__leaf_net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge805_A2 net982 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc208 net949 net147 net830 VGND VGND VPWR VPWR net1003 sky130_fd_sc_hd__nand3_4
XFILLER_0_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc219 net988 net1004 net136 net146 net721 clknet_1_1__leaf_net832 VGND VGND VPWR VPWR
+ net156 sky130_fd_sc_hd__mux4_2
XFILLER_0_40_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge821_A1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c670_B net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net374 net374 VGND VGND VPWR VPWR clknet_0_net374 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc731 net599 net284 net562 net921 clknet_1_0__leaf_net868 clknet_1_0__leaf_net888
+ VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__mux4_4
Xc720 net596 net599 net458 net795 net882 net885 VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__mux4_4
Xc742 net562 net601 clknet_1_0__leaf_net374 clknet_1_1__leaf_net888 net891 VGND VGND
+ VPWR VPWR net622 sky130_fd_sc_hd__o221ai_4
Xc753 net628 net632 net588 net867 net874 net893 VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__mux4_2
Xc764 net638 net643 net508 net803 net875 net895 VGND VGND VPWR VPWR c764/X sky130_fd_sc_hd__mux4_2
XANTENNA_s944_GATE clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge792_S1 net1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge816_A1 net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net160 net160 VGND VGND VPWR VPWR clknet_0_net160 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c605_B1 net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc561 net1033 net1030 net837 VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__and3b_1
Xc572 net460 clknet_1_1__leaf_net429 net1030 VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__nand3_4
Xc550 net318 net847 VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__or2_1
Xc583 net470 net1037 clknet_1_0__leaf_net429 net728 net863 net865 VGND VGND VPWR VPWR
+ net475 sky130_fd_sc_hd__mux4_4
Xc594 net814 VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c218_A2 net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput101 clknet_1_1__leaf_net998 VGND VGND VPWR VPWR out48 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput112 net1009 VGND VGND VPWR VPWR out60 sky130_fd_sc_hd__buf_2
XFILLER_0_10_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c194_A net763 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c466_B net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_87_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge827_A0 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c326_SCD net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c160_B1 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s939_Q_N net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput14 in20 VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__clkbuf_1
Xinput25 in30 VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__clkbuf_2
Xinput36 in40 VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__buf_1
Xinput47 in50 VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__buf_1
XFILLER_0_24_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput58 in60 VGND VGND VPWR VPWR net955 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_75_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net19 net19 VGND VGND VPWR VPWR clknet_0_net19 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_48_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c229_A1 net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge890 clknet_4_12_0_clk net715 net668 VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_62_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout122_A net1006 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c207_A net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c371_Y net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s971_Q net873 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input52_A in55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge890_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c501_CLK_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c602_B2 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net503 clknet_0_net503 VGND VGND VPWR VPWR clknet_1_1__leaf_net503
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net536 clknet_0_net536 VGND VGND VPWR VPWR clknet_1_1__leaf_net536
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c346_C1 net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge881_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_7_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c443_D net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge808_A2 net277 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c701_SCD net532 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout125_X net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c703_A0 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c483_S1 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge795_S1 clknet_1_0__leaf_net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c65_X net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input55_X net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c332_A1 net952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c393_S1 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c332_B2 net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc695_12 clknet_1_0__leaf_net967 VGND VGND VPWR VPWR net1057 sky130_fd_sc_hd__inv_12
XFILLER_0_96_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge819_A1 net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c539_A net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input15_A in21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net130 clknet_0_net130 VGND VGND VPWR VPWR clknet_1_1__leaf_net130
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net967 clknet_0_net967 VGND VGND VPWR VPWR clknet_1_0__leaf_net967
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net978 clknet_0_net978 VGND VGND VPWR VPWR clknet_1_0__leaf_net978
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c406_D net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c237_A1 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc209 net721 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_92_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input7_A in14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net342 net342 VGND VGND VPWR VPWR clknet_0_net342 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc721 net586 net594 net867 net883 net886 VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__o221ai_4
Xc710 net585 net921 net1043 net1037 net817 VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__o221ai_4
Xc743 clknet_1_0__leaf_net617 net1017 net822 net880 net890 VGND VGND VPWR VPWR net623
+ sky130_fd_sc_hd__o221ai_4
Xc754 net631 net923 net781 clknet_1_1__leaf_net992 net875 net894 VGND VGND VPWR VPWR
+ net634 sky130_fd_sc_hd__mux4_4
Xc732 net382 net1043 net283 net791 net798 clknet_1_0__leaf_net887 VGND VGND VPWR VPWR
+ net612 sky130_fd_sc_hd__mux4_2
XANTENNA_clkbuf_4_15_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c313_A3 net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input18_X net915 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_0__f_net978_X clknet_1_0__leaf_net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge816_A2 net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c425_B_N net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net172 net172 VGND VGND VPWR VPWR clknet_0_net172 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c605_B2 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc540 net732 VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__clkbuf_1
Xc562 net437 net442 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__nand2b_1
Xc573 net940 net460 clknet_1_1__leaf_net429 clknet_1_1__leaf_net417 net362 VGND VGND
+ VPWR VPWR net465 sky130_fd_sc_hd__o221ai_4
Xc551 net436 net818 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__and2_1
Xc595 net422 net1038 net1029 net841 VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__o211a_1
Xc584 net950 net318 net446 net857 net865 VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__o221ai_4
XANTENNA_c621_A0 clknet_1_0__leaf_net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput102 net999 VGND VGND VPWR VPWR out49 sky130_fd_sc_hd__buf_2
XFILLER_0_2_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput113 clknet_1_1__leaf_net1010 VGND VGND VPWR VPWR out61 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c187_A net763 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c361_B net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c466_C net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c326_SCE net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c142_X net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c128_A3 net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_98_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c441_B1 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput15 in21 VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__clkbuf_4
Xinput26 in31 VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_12_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput37 in41 VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__buf_1
XANTENNA_c616_A0 net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput59 in61 VGND VGND VPWR VPWR net956 sky130_fd_sc_hd__clkbuf_1
Xinput48 in51 VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_75_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc370 net1000 net291 clknet_1_0__leaf_net986 net774 net812 VGND VGND VPWR VPWR net302
+ sky130_fd_sc_hd__o221a_2
XANTENNA_c351_A0 net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc392 net180 net996 net1044 net191 net1007 net784 VGND VGND VPWR VPWR net995 sky130_fd_sc_hd__mux4_1
XFILLER_0_74_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_48_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge891 clknet_4_15_0_clk net177 net744 VGND VGND VPWR VPWR net779 net1005 sky130_fd_sc_hd__dfsbp_1
Xmerge880 clknet_4_14_0_clk net193 net302 VGND VGND VPWR VPWR net999 net767 sky130_fd_sc_hd__edfxbp_1
XFILLER_0_70_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_3_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c261_A0 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c436_A0 net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c107_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input45_A in49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c235_SCD net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c602_A2 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net504 clknet_0_net504 VGND VGND VPWR VPWR clknet_1_1__leaf_net504
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c669_A_N net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c603_D net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c703_A1 net562 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c474_X net384 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c447_C1 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input48_X net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net356 clknet_0_net356 VGND VGND VPWR VPWR clknet_1_1__leaf_net356
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge911_GCLK net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c319_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c274_B net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge819_A2 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c558_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net546 net546 VGND VGND VPWR VPWR clknet_0_net546 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c417_A2 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c433_A1 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c152_A2 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_4_11_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c624_A0 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_355 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net175 clknet_0_net175 VGND VGND VPWR VPWR clknet_1_1__leaf_net175
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge821_A3 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c62_A0 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc722 net581 clknet_1_0__leaf_net485 net601 net125 net758 VGND VGND VPWR VPWR net602
+ sky130_fd_sc_hd__o221a_1
Xc700 net572 net557 net556 net454 net1027 net795 VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__mux4_1
Xc711 net215 net1026 net576 net866 net882 VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__o221a_1
Xc744 clknet_1_0__leaf_net617 net1017 clknet_1_1__leaf_net616 net822 net881 VGND VGND
+ VPWR VPWR net624 sky130_fd_sc_hd__o221a_2
Xc733 clknet_1_1__leaf_net374 net595 net8 net1017 net1029 net866 VGND VGND VPWR VPWR
+ net613 sky130_fd_sc_hd__mux4_2
Xc755 net588 clknet_1_0__leaf_net516 net508 net796 clknet_1_1__leaf_net868 net894
+ VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__mux4_2
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_98_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output114_A net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c504_A3 net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c370_C1 net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge816_A3 net945 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c711_B2 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c711_A1 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c181_A_N net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net140 net140 VGND VGND VPWR VPWR clknet_0_net140 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net162 net162 VGND VGND VPWR VPWR clknet_0_net162 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc530 net416 clknet_1_0__leaf_net848 VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__nor2_2
XANTENNA_c605_A2 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc552 net773 VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__inv_4
Xc541 net92 clknet_1_0__leaf_net418 VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__and2_0
Xc563 net801 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__inv_6
Xc574 net362 clknet_1_1__leaf_net429 net1020 net1037 net1030 VGND VGND VPWR VPWR net466
+ sky130_fd_sc_hd__o221a_2
Xc585 net469 net1030 net476 net857 net862 net865 VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__mux4_1
Xc596 net386 net260 net1022 net207 net484 VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__o221a_1
XANTENNA_input30_X net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c621_A1 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c104_RESET_B clknet_1_1__leaf_net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput103 net1000 VGND VGND VPWR VPWR out52 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_70_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput114 net1011 VGND VGND VPWR VPWR out7 sky130_fd_sc_hd__buf_2
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c592_S1 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s984_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge827_A2 net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout148_X net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c706_A1 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c441_A1 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_21_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c160_A2 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_30_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput27 in32 VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__buf_1
Xinput16 in22 VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_12_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput49 in52 VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c214_2_A net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c616_A1 clknet_1_0__leaf_net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput38 in42 VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge918_Q net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc371 net813 VGND VGND VPWR VPWR net989 sky130_fd_sc_hd__inv_4
Xc360 clknet_4_14_0_clk clknet_1_1__leaf_net168 net291 net997 net159 net1019 VGND
+ VGND VPWR VPWR net293 net292 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc393 net77 net192 net1014 net1019 net970 net960 VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__mux4_1
XFILLER_0_74_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_48_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s966_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_86_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge881 clknet_4_7_0_clk net652 net655 VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__edfxtp_1
XFILLER_0_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge870 net501 net527 VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__and2b_1
XFILLER_0_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge892 clknet_4_11_0_clk net511 net514 VGND VGND VPWR VPWR net781 net780 sky130_fd_sc_hd__dfsbp_1
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge789_A net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c497_S1 net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c235_SCE net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c171_B2 net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input38_A in42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net516 clknet_0_net516 VGND VGND VPWR VPWR clknet_1_1__leaf_net516
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_s948_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c627_A0 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc190 net128 net127 net1039 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__and3b_1
XFILLER_0_20_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c352_19_A net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c581_A net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c447_B1 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c153_SCD net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c493_Q net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net1008 clknet_0_net1008 VGND VGND VPWR VPWR clknet_1_0__leaf_net1008
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap135 net860 VGND VGND VPWR VPWR net1032 sky130_fd_sc_hd__clkbuf_4
Xmax_cap124 net211 VGND VGND VPWR VPWR net1021 sky130_fd_sc_hd__buf_1
XFILLER_0_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s977_SLEEP_B clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net503 net503 VGND VGND VPWR VPWR clknet_0_net503 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net536 net536 VGND VGND VPWR VPWR clknet_0_net536 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout130_X net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c417_A3 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c494_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c730_A0 net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c76_C1 net13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net110 clknet_0_net110 VGND VGND VPWR VPWR clknet_1_1__leaf_net110
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c601_SCE net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net176 clknet_0_net176 VGND VGND VPWR VPWR clknet_1_1__leaf_net176
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net969 clknet_0_net969 VGND VGND VPWR VPWR clknet_1_0__leaf_net969
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_92_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c551_B net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_77_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c709_B2 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s978_Q_N net880 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_86_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc701 clknet_4_0_0_clk net1091 net1069 net532 net572 net1027 VGND VGND VPWR VPWR net577
+ net576 sky130_fd_sc_hd__sdfbbp_1
Xc712 clknet_1_0__leaf_net546 net589 net577 net584 net1028 net728 VGND VGND VPWR VPWR
+ net590 sky130_fd_sc_hd__mux4_1
Xc723 net599 net581 net1043 net758 net885 net1093 VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__mux4_1
Xc734 clknet_1_0__leaf_net612 clknet_1_0__leaf_net374 net283 net921 net885 clknet_1_0__leaf_net888
+ VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__mux4_2
Xc745 net142 clknet_1_0__leaf_net612 clknet_1_0__leaf_net617 clknet_1_0__leaf_net546
+ net821 clknet_1_0__leaf_net889 VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__mux4_4
Xc756 net72 net283 net796 net866 net878 net896 VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__mux4_4
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input20_A in26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output107_A net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c619_A1 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc85_8 net771 VGND VGND VPWR VPWR net1053 sky130_fd_sc_hd__inv_4
XFILLER_0_41_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c711_A2 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c430_A3 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_1_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net130 net130 VGND VGND VPWR VPWR clknet_0_net130 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c688_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc531 net733 VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__inv_1
Xc564 net807 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__buf_6
Xc553 net773 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__clkbuf_1
Xc542 net428 clknet_1_0__leaf_net425 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__and2_0
Xc586 net1037 net927 net463 net800 net864 net865 VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__mux4_1
Xc575 net1090 VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__inv_1
XFILLER_0_47_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc597 net264 net1020 net353 net1045 clknet_1_0__leaf_net464 net1037 VGND VGND VPWR
+ VPWR net490 sky130_fd_sc_hd__mux4_4
XANTENNA_input23_X net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge924_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput104 net1001 VGND VGND VPWR VPWR out53 sky130_fd_sc_hd__buf_2
XFILLER_0_2_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput115 net1012 VGND VGND VPWR VPWR out8 sky130_fd_sc_hd__buf_2
XFILLER_0_2_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge827_A3 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net541 clknet_0_net541 VGND VGND VPWR VPWR clknet_1_0__leaf_net541
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c242_A net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c706_A2 net581 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c722_A1 net581 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c722_B2 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge900_GATE clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c441_A2 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c453_RESET_B net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c88_Y net982 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput17 in23 VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_91_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput28 in33 VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_12_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput39 in43 VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c616_A2 net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc361 clknet_1_0__leaf_net19 net960 net842 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__and3_4
Xc350 clknet_1_1__leaf_net111 net280 net267 net960 net840 net841 VGND VGND VPWR VPWR
+ net286 sky130_fd_sc_hd__mux4_4
XANTENNA_c632_A1 clknet_1_1__leaf_net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc372 net296 net271 net178 clknet_1_1__leaf_net162 net989 net844 VGND VGND VPWR VPWR
+ net303 sky130_fd_sc_hd__mux4_1
Xc394 net58 net921 net180 net1019 net1097 net1080 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_48_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s959_GATE_N clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge882 clknet_4_13_0_clk net166 net687 VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__sdlclkp_1
Xmerge860 net197 net194 VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__and2b_2
Xmerge871 net604 clknet_4_2_0_clk net720 VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__dlrtn_1
XFILLER_0_23_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge893 net613 net623 VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__nand2_4
XFILLER_0_28_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge884_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net371 clknet_0_net371 VGND VGND VPWR VPWR clknet_1_0__leaf_net371
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c717_A1 net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c717_B2 net588 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c436_A2 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge780_B1 net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output99_A net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc180 net956 net952 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__and2b_1
Xc191 net131 net127 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__and2_1
XFILLER_0_20_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge857_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c728_A0 net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c65_A1 net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s942_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net190 clknet_0_net190 VGND VGND VPWR VPWR clknet_1_0__leaf_net190
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c153_SCE net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c284_CLK_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input50_A in53 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c603_RESET_B net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net303 clknet_0_net303 VGND VGND VPWR VPWR clknet_1_1__leaf_net303
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_58_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c357_B2 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge791_C1 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge804_S0 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net504 net504 VGND VGND VPWR VPWR clknet_0_net504 sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c215_Y net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout123_X net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c714_A2 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c76_B1 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c70_Y net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c474_C1 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c193_A0 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c624_A2 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input53_X net950 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net111 clknet_0_net111 VGND VGND VPWR VPWR clknet_1_1__leaf_net111
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c544_B net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c709_A2 net920 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_522 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s932_Q net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net356 net356 VGND VGND VPWR VPWR clknet_0_net356 sky130_fd_sc_hd__clkbuf_16
Xc702 net575 net577 net558 net538 net572 net761 VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__mux4_1
Xc713 net585 net125 net589 net883 VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__o211ai_1
XFILLER_0_31_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc724 net601 net599 net589 net597 net923 net795 VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__mux4_1
Xc746 clknet_1_0__leaf_net616 net920 clknet_1_1__leaf_net464 clknet_1_1__leaf_net770
+ net796 net890 VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__mux4_1
Xc735 net601 clknet_1_0__leaf_net546 net581 net1045 clknet_1_0__leaf_net992 net881
+ VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__mux4_1
XANTENNA_c163_A3 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc757 clknet_1_1__leaf_net464 net906 clknet_1_1__leaf_net546 net781 clknet_1_1__leaf_net887
+ net896 VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__mux4_4
XANTENNA_c460_A1 net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c307_S0 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c87_C1 net21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input13_A in2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_80_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c619_A2 clknet_1_0__leaf_net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c635_A1 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_78_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output81_A clknet_1_0__leaf_net978 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c370_A1 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c608_C_N net1013 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc85_9 net771 VGND VGND VPWR VPWR net1054 sky130_fd_sc_hd__inv_4
XANTENNA_input5_A in12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c360_SET_B net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c442_X net352 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net175 net175 VGND VGND VPWR VPWR clknet_0_net175 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_9_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc543 net792 VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__buf_1
Xc532 net776 VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__inv_4
Xc554 net439 net1081 VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__nor2_1
Xc565 net452 net449 net433 VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__and3_1
Xc587 clknet_4_3_0_clk net467 net362 net476 net857 net1074 VGND VGND VPWR VPWR net480
+ net479 sky130_fd_sc_hd__sdfbbp_1
Xc576 net786 VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__clkbuf_2
Xc598 net1045 net376 net476 net1038 clknet_1_0__leaf_net832 VGND VGND VPWR VPWR net491
+ sky130_fd_sc_hd__o221a_2
XANTENNA_c621_A3 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input16_X net913 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge767_B2 net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c199_C1 net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_35_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_63_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c349_A2 net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput105 clknet_1_1__leaf_net1002 VGND VGND VPWR VPWR out54 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput116 net1013 VGND VGND VPWR VPWR out9 sky130_fd_sc_hd__buf_2
XFILLER_0_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c706_A3 net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c304_S1 net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c90_A net13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput18 in24 VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__clkbuf_2
Xinput29 in34 VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_91_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc340 net778 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__buf_6
Xc351 net281 net280 net1023 net234 net220 net778 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__mux4_1
Xc362 net293 net1009 net178 net996 net1004 net835 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__mux4_1
Xc373 net1007 net1063 net767 net842 net843 net846 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__mux4_1
Xc395 net291 net183 net1001 net989 c395/S0 net980 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c351_A3 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge872 net647 clknet_4_7_0_clk net684 VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__dlrtn_2
XFILLER_0_7_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge850 clknet_4_1_0_clk net659 net671 VGND VGND VPWR VPWR net733 net732 sky130_fd_sc_hd__dfsbp_1
Xmerge861 net694 clknet_4_1_0_clk net683 VGND VGND VPWR VPWR net746 net745 sky130_fd_sc_hd__dlrbn_2
XFILLER_0_15_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge883 clknet_4_8_0_clk net611 net624 VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__sdlclkp_2
Xmerge894 net622 net615 VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__nor2_1
XFILLER_0_99_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c569_D net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c704_SCE net562 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net372 clknet_0_net372 VGND VGND VPWR VPWR clknet_1_0__leaf_net372
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout140 net1039 VGND VGND VPWR VPWR net1037 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_17_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c477_C1 net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c627_A2 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge923_Q net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc181 net83 net122 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__nand2b_1
Xc170 net106 net101 net98 net1035 net765 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__o221a_2
XFILLER_0_18_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_87_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s962_Q net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c447_A2 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_18_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input43_A in47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net304 clknet_0_net304 VGND VGND VPWR VPWR clknet_1_1__leaf_net304
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_58_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge775_B2 net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge775_A1 net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge791_B1 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_355 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge804_S1 net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c155_B net914 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge820_S0 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c148_A net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net516 net516 VGND VGND VPWR VPWR clknet_0_net516 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c208_Y net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c283_A1 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c730_A2 net562 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge766_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c739_A0 net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c193_A1 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c624_A3 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net167 clknet_0_net167 VGND VGND VPWR VPWR clknet_1_1__leaf_net167
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_97_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c368_B2 net1019 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c413_S0 net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c318_X net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge920_CLK clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc703 net78 net562 net572 net577 net564 net883 VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__mux4_1
Xc714 net589 net579 net1040 net580 net532 net882 VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__mux4_1
Xc725 net587 net596 net565 net758 net795 net886 VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__mux4_1
Xc747 clknet_1_1__leaf_net617 net508 net387 net785 net880 net892 VGND VGND VPWR VPWR
+ net627 sky130_fd_sc_hd__mux4_4
Xc736 net581 net383 clknet_1_1__leaf_net612 net798 net811 VGND VGND VPWR VPWR net616
+ sky130_fd_sc_hd__o221a_2
Xc758 net629 net866 clknet_1_1__leaf_net868 net894 net896 net897 VGND VGND VPWR VPWR
+ net638 sky130_fd_sc_hd__mux4_2
XANTENNA_c460_A2 net352 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c307_S1 net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c619_A3 clknet_1_1__leaf_net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge772_A2 net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge911_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output74_A net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_0_clk_X clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_9_0_clk_X clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net110 net110 VGND VGND VPWR VPWR clknet_0_net110 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_76_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c736_A1 net581 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c736_B2 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_556 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net176 net176 VGND VGND VPWR VPWR clknet_0_net176 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c752_A0 net588 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc500 net402 net1043 net71 net979 net815 net859 VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_9_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc544 net431 net199 clknet_1_1__leaf_net418 VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__nor3_2
Xc533 net943 net420 VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__and2_1
Xc555 net441 net310 net1037 clknet_1_0__leaf_net427 net436 VGND VGND VPWR VPWR net444
+ sky130_fd_sc_hd__o221a_4
Xc566 net448 net455 net433 net861 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__o211a_1
Xc588 net478 net480 net125 net254 net459 net1028 VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__mux4_1
Xc577 net460 net468 net711 net799 net857 VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__o221a_1
Xc599 net207 net8 net1033 net840 clknet_1_0__leaf_net869 VGND VGND VPWR VPWR net492
+ sky130_fd_sc_hd__o221ai_1
XANTENNA_s978_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge767_A2 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c199_B1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c349_A3 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput106 net1003 VGND VGND VPWR VPWR out55 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s969_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout143_A net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c79_6_A net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput19 in25 VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_12_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_75_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc330 net21 net996 net1023 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__nand3b_4
XFILLER_0_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc341 net147 net275 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__nand2_1
XANTENNA_c632_A3 net508 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc363 net271 net1044 net42 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__or3_1
Xc396 net957 net201 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__nand2_2
XFILLER_0_20_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge840 net186 net189 VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__nand2b_2
Xmerge873 net657 clknet_4_13_0_clk net675 VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__dlrtn_2
Xmerge851 clknet_4_5_0_clk net650 net676 VGND VGND VPWR VPWR net735 net734 sky130_fd_sc_hd__dfsbp_1
Xmerge862 net287 net713 VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__and2b_1
XFILLER_0_7_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge884 clknet_4_13_0_clk net681 net695 VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__sdlclkp_4
XFILLER_0_15_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge895 clknet_4_12_0_clk net665 net741 VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__dfstp_4
XFILLER_0_99_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xs990 net637 clknet_4_10_0_clk VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_43_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c392_A0 net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c178_A net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net351 clknet_0_net351 VGND VGND VPWR VPWR clknet_1_0__leaf_net351
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c345_A net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout146_X net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c405_Y net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c733_A2 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout130 net1028 VGND VGND VPWR VPWR net1027 sky130_fd_sc_hd__clkbuf_4
Xfanout141 net1039 VGND VGND VPWR VPWR net1038 sky130_fd_sc_hd__buf_4
XFILLER_0_88_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c477_B1 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c196_A1 net944 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c627_A3 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge780_A2 net898 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc171 net106 net109 net107 net96 net1035 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__o221a_1
Xc160 net97 net1031 net927 net1034 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__o211ai_1
XFILLER_0_20_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c362_A3 net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc182 net938 net123 net119 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__nor3_2
Xc193 net125 net77 net124 net132 net914 net112 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__mux4_4
XFILLER_0_18_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s971_GATE_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c326_DE net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c416_S0 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c578_C1 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c728_A2 net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c297_B1 net915 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c65_A3 net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge865_GATE clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_50_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold8 net729 VGND VGND VPWR VPWR net1065 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input36_A in40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge775_A2 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c236_S0 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net850 clknet_0_net850 VGND VGND VPWR VPWR clknet_1_1__leaf_net850
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c412_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge820_S1 net532 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c148_B net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c283_A2 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c352_17_A net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c298_X net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c730_A3 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c465_X net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c739_A1 clknet_1_0__leaf_net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c458_A2 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c755_A0 net588 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s960_GATE clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net157 clknet_0_net157 VGND VGND VPWR VPWR clknet_1_1__leaf_net157
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net168 clknet_0_net168 VGND VGND VPWR VPWR clknet_1_1__leaf_net168
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge786_A1 clknet_1_1__leaf_net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c368_A2 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_0_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c265_B net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c413_S1 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c432_B net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_4_5_0_clk_X clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_46_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net303 net303 VGND VGND VPWR VPWR clknet_0_net303 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_29_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc704 clknet_4_2_0_clk clknet_1_0__leaf_net485 net1092 net577 net562 net882 VGND VGND
+ VPWR VPWR net581 net580 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_16_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc737 clknet_1_1__leaf_net616 net376 net254 clknet_1_0__leaf_net770 net821 net881
+ VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__mux4_4
Xc715 net576 net761 net817 net866 net1095 VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__o221ai_1
Xc726 net581 net1017 net923 net866 net871 net873 VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__mux4_4
XFILLER_0_12_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c741_A2 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc759 net508 clknet_1_1__leaf_net464 clknet_1_0__leaf_net887 clknet_1_0__leaf_net889
+ net895 net896 VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__mux4_2
Xc748 net72 net1045 net866 net873 net875 net894 VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_55_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c460_A3 net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_64_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c635_A3 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_73_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output67_A net964 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge797_B1 net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net769 clknet_0_net769 VGND VGND VPWR VPWR clknet_1_0__leaf_net769
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge926_GATE clknet_4_11_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_91_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge826_S0 net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net111 net111 VGND VGND VPWR VPWR clknet_0_net111 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_64_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c752_A1 clknet_1_0__leaf_net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc501 clknet_4_11_0_clk net71 net2 net1087 net159 net1088 VGND VGND VPWR VPWR net411
+ net410 sky130_fd_sc_hd__sdfbbn_1
XTAP_TAPCELL_ROW_9_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc545 net807 VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__inv_2
Xc534 net420 net416 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__nand2b_4
XANTENNA_c487_RESET_B clknet_1_0__leaf_net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc589 net468 net478 net1037 net481 net981 net865 VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__mux4_4
Xc556 net440 clknet_1_1__leaf_net427 net570 net836 VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__o211a_4
Xc578 net308 net318 net446 net857 net862 VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__o221a_1
Xc567 net801 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_63_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge783_A2 net277 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge896_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_579 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput107 net1004 VGND VGND VPWR VPWR out56 sky130_fd_sc_hd__buf_2
XFILLER_0_50_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c282_CLK_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c716_SCD net535 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout136_A net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c280_X net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c707_SCD net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c747_A1 net508 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc320 net923 net955 net831 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_75_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc342 net144 net115 net839 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__nor3b_2
Xc353 net804 VGND VGND VPWR VPWR net991 sky130_fd_sc_hd__clkbuf_16
Xc331 net1023 net1004 net221 net839 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__o211ai_1
Xc364 net760 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__inv_1
Xc397 net201 net1021 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__and2_1
XFILLER_0_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_13_0_clk_X clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge794_A1 net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge830 net117 net104 VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__or2_1
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge852 net138 net648 VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__nand2_1
Xmerge863 net678 clknet_4_5_0_clk net696 VGND VGND VPWR VPWR net749 net748 sky130_fd_sc_hd__dlrbp_2
XFILLER_0_67_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge841 net559 net573 VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__and2_2
XFILLER_0_28_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge874 net680 clknet_4_0_0_clk net723 VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__dlrtp_2
Xmerge885 clknet_4_1_0_clk net658 net727 VGND VGND VPWR VPWR net773 net772 sky130_fd_sc_hd__dfrbp_1
Xmerge896 clknet_4_8_0_clk net621 net663 VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__dfstp_1
XFILLER_0_43_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs980 clknet_4_2_0_clk net583 VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__dfxtp_1
XANTENNA_c392_A1 net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net374 clknet_0_net374 VGND VGND VPWR VPWR clknet_1_0__leaf_net374
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c133_Y net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c733_A3 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout120 net309 VGND VGND VPWR VPWR net1017 sky130_fd_sc_hd__clkbuf_4
Xfanout131 net1029 VGND VGND VPWR VPWR net1028 sky130_fd_sc_hd__buf_2
Xfanout142 net94 VGND VGND VPWR VPWR net1039 sky130_fd_sc_hd__buf_4
XFILLER_0_96_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c477_B2 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc172 clknet_4_7_0_clk net96 net105 clknet_1_0__leaf_net110 net109 net1035 VGND VGND
+ VPWR VPWR net113 net112 sky130_fd_sc_hd__sdfbbn_1
Xc161 net908 net935 net1031 net1034 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__o211a_1
Xc150 net905 net78 net83 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__nand3b_1
XFILLER_0_85_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc194 net763 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__inv_4
Xc183 net745 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__buf_4
XANTENNA_merge909_Q net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc352_13 net804 VGND VGND VPWR VPWR net1058 sky130_fd_sc_hd__clkinv_2
XFILLER_0_68_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c462_B net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c455_A net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net160 clknet_0_net160 VGND VGND VPWR VPWR clknet_1_0__leaf_net160
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c728_A3 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c744_A2 net1017 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold9 net847 VGND VGND VPWR VPWR net1066 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input29_A in34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap128 net60 VGND VGND VPWR VPWR net1025 sky130_fd_sc_hd__buf_1
XFILLER_0_21_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output97_A net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c148_C net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c308_B net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c580_A1 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_1_0_clk_X clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c458_A3 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c490_A1 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net169 clknet_0_net169 VGND VGND VPWR VPWR clknet_1_1__leaf_net169
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge786_A2 net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c258_B net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net304 net304 VGND VGND VPWR VPWR clknet_0_net304 sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_101_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c320_A net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc705 net318 net125 net565 clknet_1_1__leaf_net485 net1026 VGND VGND VPWR VPWR net582
+ sky130_fd_sc_hd__o221a_4
Xc716 clknet_4_2_0_clk net593 clknet_1_0__leaf_net485 net535 net580 net863 VGND VGND
+ VPWR VPWR net595 net594 sky130_fd_sc_hd__sdfbbp_1
Xc727 net142 net588 net562 net551 net886 VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__o221ai_1
Xc738 net8 net921 net562 net551 net811 VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__o221ai_2
XFILLER_0_97_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc749 net284 net923 clknet_1_0__leaf_net992 net874 clknet_1_1__leaf_net889 net891
+ VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_4_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c620_S0 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c485_A1 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input51_X net948 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge878_GATE clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c692_C1 net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c487_D net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c586_A0 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net167 net167 VGND VGND VPWR VPWR clknet_0_net167 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc502 clknet_1_1__leaf_net304 net410 net366 clknet_1_1__leaf_net303 net784 net859
+ VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_9_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc546 net1089 VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_32_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc535 net419 net1033 net422 VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__nor3_2
Xc568 net433 net453 net1028 VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__or3_4
Xc579 net800 VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__clkbuf_1
Xc557 net152 net440 VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__nor2_2
XANTENNA_c615_S0 net508 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input11_A in18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c350_S0 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_SCD clknet_1_0__leaf_net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput108 net1005 VGND VGND VPWR VPWR out57 sky130_fd_sc_hd__buf_2
XFILLER_0_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput90 net987 VGND VGND VPWR VPWR out35 sky130_fd_sc_hd__buf_2
XFILLER_0_93_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c235_D net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c260_S0 net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout129_A net535 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s954_GATE_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input3_A in10 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c273_X net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c747_A2 net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c763_A1 net508 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc310 net768 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__clkbuf_4
Xc321 net118 net239 net838 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__nor3_1
XFILLER_0_20_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input59_A in61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc354 net274 net141 clknet_1_0__leaf_net168 VGND VGND VPWR VPWR net961 sky130_fd_sc_hd__and3_1
Xc343 net276 net254 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__and2_1
Xc332 net952 net267 net237 net220 net147 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__o221ai_4
Xc365 clknet_1_1__leaf_net19 net292 net290 VGND VGND VPWR VPWR net1010 sky130_fd_sc_hd__nor3_1
Xc398 net743 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__inv_4
XTAP_TAPCELL_ROW_48_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge794_A2 clknet_1_1__leaf_net34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge820 net423 net424 clknet_1_0__leaf_net429 net542 net1026 net532 VGND VGND VPWR
+ VPWR net700 sky130_fd_sc_hd__mux4_1
XANTENNA_merge889_Q net777 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge853 net251 net249 VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__nor2_1
Xmerge864 net618 net642 VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__or2_1
Xmerge831 clknet_4_3_0_clk net483 net465 VGND VGND VPWR VPWR net712 net711 sky130_fd_sc_hd__dfrbp_1
Xmerge842 net515 net519 VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__nor2_4
XFILLER_0_99_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge875 net619 net506 VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__or2_1
Xs970 net505 clknet_4_8_0_clk VGND VGND VPWR VPWR net871 net870 sky130_fd_sc_hd__dlxbn_2
XFILLER_0_43_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge886 clknet_4_14_0_clk net755 net289 VGND VGND VPWR VPWR net964 net774 sky130_fd_sc_hd__dfrbp_1
Xmerge897 clknet_4_6_0_clk net653 net689 VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__dfstp_2
XFILLER_0_82_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xs981 clknet_4_2_0_clk net592 VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer1 net1098 VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c392_A2 net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net342 clknet_0_net342 VGND VGND VPWR VPWR clknet_1_0__leaf_net342
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c702_S1 net761 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c583_A1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout143 net72 VGND VGND VPWR VPWR net1040 sky130_fd_sc_hd__buf_4
Xfanout132 net457 VGND VGND VPWR VPWR net1029 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_17_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c758_A1 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_45_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c477_A2 net385 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c196_A3 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc162 net759 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__inv_6
Xc151 net74 net1083 net86 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__nand3_1
Xc140 net954 net910 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__nor2_1
Xc195 net126 net830 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__or2_2
Xc184 net109 net125 VGND VGND VPWR VPWR net1000 sky130_fd_sc_hd__or2_4
Xc173 clknet_4_7_0_clk clknet_1_1__leaf_net110 net108 net1096 net1035 net106 VGND
+ VGND VPWR VPWR net115 net114 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_87_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc352_14 net804 VGND VGND VPWR VPWR net1059 sky130_fd_sc_hd__clkinv_2
XFILLER_0_7_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c684_B1 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c190_B net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c578_A1 net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net172 clknet_0_net172 VGND VGND VPWR VPWR clknet_1_0__leaf_net172
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_1__f_net967_X clknet_1_1__leaf_net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c410_Y net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c623_S0 clknet_1_1__leaf_net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c488_A1 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge921_Q net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c173_CLK_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c480_SET_B net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s950_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c308_C net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c186_X net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c739_A3 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge923_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c755_A2 net508 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c618_S0 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input41_A in45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c499_A0 net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge914_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s932_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c146_A net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge923_SET_B net384 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c320_B net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_60_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c206_Y net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc717 net458 net584 net565 net588 net576 VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__o221a_1
Xc728 net254 net376 net551 net8 net791 net884 VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__mux4_1
Xc706 clknet_1_1__leaf_net485 net1026 net581 net458 net994 net864 VGND VGND VPWR VPWR
+ net583 sky130_fd_sc_hd__mux4_4
XFILLER_0_31_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc739 net387 clknet_1_0__leaf_net464 clknet_1_1__leaf_net617 net142 net803 net884
+ VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__mux4_2
XFILLER_0_97_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c568_X net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c485_A2 net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net850 net850 VGND VGND VPWR VPWR clknet_0_net850 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net30 clknet_0_net30 VGND VGND VPWR VPWR clknet_1_1__leaf_net30 sky130_fd_sc_hd__clkbuf_16
XANTENNA_input44_X net941 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c395_A2 net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c156_Y net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c535_B net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c586_A1 net927 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c323_Y net985 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net168 net168 VGND VGND VPWR VPWR clknet_0_net168 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net157 net157 VGND VGND VPWR VPWR clknet_0_net157 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc503 net411 net409 net401 net809 net859 net860 VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_9_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc536 net421 net422 net423 net1043 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__o211ai_4
Xc547 net434 net422 net419 net421 net424 clknet_1_0__leaf_net429 VGND VGND VPWR VPWR
+ net435 sky130_fd_sc_hd__mux4_1
Xc569 clknet_4_1_0_clk net316 net447 net458 clknet_1_1__leaf_net445 net1027 VGND VGND
+ VPWR VPWR net460 net459 sky130_fd_sc_hd__sdfbbn_2
Xc558 clknet_4_1_0_clk net443 net338 clknet_1_0__leaf_net445 net923 clknet_1_0__leaf_net849
+ VGND VGND VPWR VPWR net448 net447 sky130_fd_sc_hd__sdfbbp_1
XANTENNA_c615_S1 net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput109 net1006 VGND VGND VPWR VPWR out58 sky130_fd_sc_hd__buf_2
XFILLER_0_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput91 net988 VGND VGND VPWR VPWR out36 sky130_fd_sc_hd__buf_2
Xoutput80 net977 VGND VGND VPWR VPWR out25 sky130_fd_sc_hd__buf_2
XFILLER_0_77_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net546 clknet_0_net546 VGND VGND VPWR VPWR clknet_1_0__leaf_net546
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c260_S1 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c212_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c763_A2 net803 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c118_C1 net1014 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc311 net748 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__inv_4
Xc300 net768 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__clkinv_4
XFILLER_0_20_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc344 net267 net278 clknet_1_1__leaf_net111 net952 net1000 VGND VGND VPWR VPWR net279
+ sky130_fd_sc_hd__o221a_2
Xc333 net778 VGND VGND VPWR VPWR net984 sky130_fd_sc_hd__clkbuf_2
Xc322 net252 net255 net257 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__nand3b_1
Xc355 clknet_1_1__leaf_net22 net159 net1064 net281 net1019 net45 VGND VGND VPWR VPWR
+ net288 sky130_fd_sc_hd__mux4_2
Xc366 net290 net42 net1039 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__and3b_1
Xc399 net719 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__buf_16
XTAP_TAPCELL_ROW_48_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge794_A3 net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge810 net129 net147 net5 net9 net952 VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__o221ai_4
Xmerge821 net919 net80 net143 net11 net1014 net1025 VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__mux4_1
XFILLER_0_67_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge843 clknet_4_13_0_clk merge843/D net44 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__dfrtp_1
Xmerge854 net57 net66 VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__nor2_4
Xmerge832 net300 net301 VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__and2_4
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge876 net692 clknet_4_5_0_clk net84 VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__dlrtp_2
Xmerge887 clknet_4_6_0_clk net651 net679 VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__dfrtn_1
Xmerge865 net708 clknet_4_1_0_clk net703 VGND VGND VPWR VPWR net752 net751 sky130_fd_sc_hd__dlrbp_2
Xs960 net408 clknet_4_14_0_clk VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__dlxtp_1
XFILLER_0_99_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge898 net690 clknet_4_15_0_clk net722 VGND VGND VPWR VPWR net788 net787 sky130_fd_sc_hd__dlrbn_2
Xs982 clknet_4_2_0_clk net600 VGND VGND VPWR VPWR net886 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_11_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs971 net507 clknet_4_8_0_clk VGND VGND VPWR VPWR net873 net872 sky130_fd_sc_hd__dlxbn_1
XFILLER_0_36_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer2 net17 VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_79_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s940_GATE clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c698_C1 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net967_X clknet_1_0__leaf_net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout141_A net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_88_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c583_A2 clknet_1_0__leaf_net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c400_B net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge926_Q_N net1013 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout122 net1006 VGND VGND VPWR VPWR net1019 sky130_fd_sc_hd__buf_4
Xfanout144 net71 VGND VGND VPWR VPWR net1041 sky130_fd_sc_hd__clkbuf_8
XANTENNA_c681_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout133 net333 VGND VGND VPWR VPWR net1030 sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_45_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c79_4_A net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc130 net50 net67 net62 net65 net51 net1042 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__mux4_1
Xc163 net959 net908 net101 net92 net1031 net1034 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__mux4_2
Xc141 net75 net73 net908 net957 net959 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__o221ai_4
XFILLER_0_20_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc152 net88 net78 net79 net83 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__o211a_1
Xc196 net1046 net944 net136 net83 net1031 net1000 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__mux4_2
Xc185 net820 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__inv_1
Xc174 clknet_1_0__leaf_net111 net105 net101 net106 net112 net763 VGND VGND VPWR VPWR
+ net116 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc352_15 net804 VGND VGND VPWR VPWR net1060 sky130_fd_sc_hd__clkinv_2
XFILLER_0_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c190_C net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c578_A2 net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c448_B net835 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net140 clknet_0_net140 VGND VGND VPWR VPWR clknet_1_0__leaf_net140
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net162 clknet_0_net162 VGND VGND VPWR VPWR clknet_1_0__leaf_net162
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout144_X net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge906_GATE clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c601_SET_B net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c406_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge902_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c572_C net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c724_S0 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c618_S1 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input34_A in39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c634_S0 net867 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc90 net13 net947 VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__nor2_1
XFILLER_0_97_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge850_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c146_B net763 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c139_A net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_60_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c719_S0 net588 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc707 clknet_4_2_0_clk net577 clknet_1_0__leaf_net546 net458 net580 net880 VGND VGND
+ VPWR VPWR net585 net584 sky130_fd_sc_hd__sdfbbn_1
Xc729 net1017 net551 net580 net8 net866 net871 VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__mux4_4
Xc718 clknet_4_3_0_clk net532 net595 net565 net863 net881 VGND VGND VPWR VPWR net598
+ net597 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_31_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c591_A2 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c352_15_A net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c675_A net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c454_S0 net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c172_CLK_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c629_S0 net816 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input37_X net934 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c395_A3 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c692_B2 net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_60_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c535_C net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net169 net169 VGND VGND VPWR VPWR clknet_0_net169 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_32_446 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc537 net420 clknet_1_0__leaf_net418 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__or2_2
Xc504 net413 net411 net979 net941 net859 net860 VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__mux4_1
Xc548 clknet_4_1_0_clk clknet_1_1__leaf_net425 net426 net308 clknet_1_0__leaf_net429
+ net861 VGND VGND VPWR VPWR net437 net436 sky130_fd_sc_hd__sdfbbn_1
Xc559 net338 net852 VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__or2b_1
XANTENNA_c496_A2 net976 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput70 clknet_1_0__leaf_net967 VGND VGND VPWR VPWR out15 sky130_fd_sc_hd__clkbuf_1
Xoutput81 clknet_1_0__leaf_net978 VGND VGND VPWR VPWR out26 sky130_fd_sc_hd__clkbuf_1
Xoutput92 net989 VGND VGND VPWR VPWR out37 sky130_fd_sc_hd__buf_2
Xclkbuf_1_0__f_net503 clknet_0_net503 VGND VGND VPWR VPWR clknet_1_0__leaf_net503
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net536 clknet_0_net536 VGND VGND VPWR VPWR clknet_1_0__leaf_net536
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_14_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c168_SCE net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c732_S0 net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c597_A1 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc312 net768 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__buf_1
XFILLER_0_32_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc301 net235 net229 net92 net236 net1036 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__o221a_4
XTAP_TAPCELL_ROW_75_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc345 net776 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__buf_4
Xc323 net258 net255 net838 VGND VGND VPWR VPWR net985 sky130_fd_sc_hd__nor3_2
Xc334 net264 net267 clknet_1_0__leaf_net19 net778 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__o211a_4
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc356 net808 VGND VGND VPWR VPWR net1007 sky130_fd_sc_hd__dlymetal6s2s_1
Xc367 net273 net18 clknet_1_1__leaf_net169 net291 net774 net844 VGND VGND VPWR VPWR
+ net299 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_86_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output103_A net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge811 net81 net87 net201 net203 net202 net763 VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__mux4_1
Xmerge800 net539 clknet_1_1__leaf_net536 net534 net548 net547 VGND VGND VPWR VPWR
+ net680 sky130_fd_sc_hd__o221ai_1
Xmerge844 net225 net240 VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__or2b_1
Xmerge822 net199 net1016 net146 net148 net1000 net833 VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__mux4_1
XFILLER_0_67_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge833 net489 net491 VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__and2b_2
Xmerge855 clknet_4_4_0_clk net335 net339 VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__dfstp_2
Xmerge866 net574 net578 VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__nor2b_1
Xs950 clknet_4_4_0_clk net327 VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__dfxtp_2
Xmerge877 net399 net523 VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__nand2b_1
Xs961 net412 clknet_4_14_0_clk VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xmerge888 clknet_4_6_0_clk net697 net682 VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__dfrtp_4
Xmerge899 net693 clknet_4_13_0_clk net706 VGND VGND VPWR VPWR net790 net789 sky130_fd_sc_hd__dlrbn_2
XTAP_TAPCELL_ROW_11_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs983 clknet_4_8_0_clk net609 VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__dlclkp_1
Xs972 net512 clknet_4_10_0_clk VGND VGND VPWR VPWR net875 net874 sky130_fd_sc_hd__dlxbp_1
Xrebuffer3 net17 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c571_CLK_N clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c583_A3 net728 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge803_A0 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout145 net58 VGND VGND VPWR VPWR net1042 sky130_fd_sc_hd__buf_2
Xfanout134 net98 VGND VGND VPWR VPWR net1031 sky130_fd_sc_hd__buf_4
Xfanout123 net971 VGND VGND VPWR VPWR net1020 sky130_fd_sc_hd__buf_4
XFILLER_0_69_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_7_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc120 net32 net1042 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__nor2b_1
XFILLER_0_33_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc131 clknet_4_15_0_clk net62 net1042 clknet_1_1__leaf_net54 net810 net828 VGND VGND
+ VPWR VPWR net70 net69 sky130_fd_sc_hd__sdfbbn_1
XANTENNA_c637_S0 net840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc153 clknet_4_5_0_clk net91 net90 net86 net81 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__sdfrtp_4
Xc142 net958 net1043 net1041 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__or3_4
Xc175 net99 clknet_1_0__leaf_net110 net922 net112 net109 net829 VGND VGND VPWR VPWR
+ net117 sky130_fd_sc_hd__mux4_2
Xc186 net820 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__clkbuf_4
Xc164 net97 net899 net1031 net1035 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__o211a_1
Xc197 net132 net122 net136 net127 net135 net830 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__mux4_1
XANTENNA_c372_S0 net989 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_16_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc352_16 net804 VGND VGND VPWR VPWR net1061 sky130_fd_sc_hd__clkinv_2
XANTENNA_c684_A2 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge925_GATE_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net130 clknet_0_net130 VGND VGND VPWR VPWR clknet_1_0__leaf_net130
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c343_B net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c608_B clknet_1_1__leaf_net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_50_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c660_X net532 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_94_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net832 clknet_0_net832 VGND VGND VPWR VPWR clknet_1_1__leaf_net832
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net887 clknet_0_net887 VGND VGND VPWR VPWR clknet_1_1__leaf_net887
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_75_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c216_B1 net149 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_6_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c589_A2 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c346_Y net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c740_S0 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s946_Q net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input27_A in32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc80 net669 VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkinv_8
Xc91 net760 VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_2
XFILLER_0_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_output95_A clknet_1_0__leaf_net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c443_SCD net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c201_A net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc719 net586 net125 net576 net458 net588 net885 VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__mux4_2
Xc708 net1026 net125 net921 net864 VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__o211a_1
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge811_A0 net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c682_C net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c675_B net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c735_S0 clknet_1_0__leaf_net992 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c668_A net761 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c456_X net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c629_S1 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_78_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net54 clknet_0_net54 VGND VGND VPWR VPWR clknet_1_1__leaf_net54 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_89_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s943_GATE_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold35_A net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c213_A1 net1003 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c423_B net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c211_Y net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc505 net899 net409 net404 net976 net375 net410 VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__mux4_1
Xc538 net423 net421 VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__and2_1
Xc549 clknet_1_1__leaf_net432 net437 net861 VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__nand3_1
XANTENNA_c569_SET_B net1027 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_14_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput71 net968 VGND VGND VPWR VPWR out16 sky130_fd_sc_hd__buf_2
Xoutput93 net990 VGND VGND VPWR VPWR out38 sky130_fd_sc_hd__buf_2
Xoutput82 net979 VGND VGND VPWR VPWR out27 sky130_fd_sc_hd__buf_2
XFILLER_0_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net504 clknet_0_net504 VGND VGND VPWR VPWR clknet_1_0__leaf_net504
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c285_S0 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c597_A2 net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c426_Y net971 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge858_A net198 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc302 net775 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_75_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc313 net248 net247 clknet_1_0__leaf_net111 net224 net1019 net244 VGND VGND VPWR VPWR
+ net249 sky130_fd_sc_hd__mux4_4
Xc335 net775 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__clkbuf_1
Xc324 net255 net258 net940 net213 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__o211ai_1
Xc368 net298 net18 net291 net1019 clknet_1_0__leaf_net1010 VGND VGND VPWR VPWR net300
+ sky130_fd_sc_hd__o221ai_1
Xc357 net141 clknet_1_1__leaf_net175 clknet_1_0__leaf_net38 net1039 net842 VGND VGND
+ VPWR VPWR net289 sky130_fd_sc_hd__o221a_4
Xc346 net275 net274 net280 net794 net839 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__o221ai_4
XTAP_TAPCELL_ROW_86_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge801 net13 clknet_1_1__leaf_net16 net8 net95 net103 net102 VGND VGND VPWR VPWR
+ net681 sky130_fd_sc_hd__mux4_2
Xmerge812 net121 net900 net952 net123 net128 VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__o221a_1
XFILLER_0_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge823 net87 net205 net203 net1021 net912 VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__o221a_1
Xmerge834 net269 net286 VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__nand2_4
Xmerge845 net552 net550 VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__nor2b_1
Xmerge856 clknet_4_13_0_clk net10 net15 VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__dfstp_1
Xmerge878 net710 clknet_4_5_0_clk net709 VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__dlrtp_4
XANTENNA_c707_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge867 net525 net640 VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__and2b_1
Xs940 net243 clknet_4_4_0_clk VGND VGND VPWR VPWR net837 net836 sky130_fd_sc_hd__dlxbp_1
Xs951 clknet_4_4_0_clk net328 VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__dlclkp_1
Xs984 clknet_4_2_0_clk net610 VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__dlclkp_2
Xs973 net524 clknet_4_10_0_clk VGND VGND VPWR VPWR net973 sky130_fd_sc_hd__dlxtn_1
Xs962 clknet_4_1_0_clk net435 VGND VGND VPWR VPWR net862 net861 sky130_fd_sc_hd__dfxbp_1
Xmerge889 clknet_4_9_0_clk net716 net701 VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__dfrtp_4
XTAP_TAPCELL_ROW_11_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer4 net338 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net356 clknet_0_net356 VGND VGND VPWR VPWR clknet_1_0__leaf_net356
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s980_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c121_B net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c219_A0 net988 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c114_A net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout146 net906 VGND VGND VPWR VPWR net1043 sky130_fd_sc_hd__buf_6
XANTENNA_input1_A in0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c710_Y net588 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc110 net654 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc121 net59 net1045 net1042 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__nor3_1
Xc154 net936 net900 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__or2_1
Xc132 net932 net957 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__and2_2
Xc143 net765 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__inv_4
Xc187 net763 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__clkbuf_2
Xc165 net916 net103 net99 net1034 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__o211ai_1
Xc176 net759 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__inv_2
XANTENNA_input57_A in6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc198 net92 net115 net1039 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__and3b_1
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c372_S1 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc352_17 net804 VGND VGND VPWR VPWR net1062 sky130_fd_sc_hd__clkinv_2
XANTENNA_merge887_Q net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s962_CLK clknet_4_1_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c107_RESET_B net1075 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c547_S1 clknet_1_0__leaf_net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_4_2_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s953_CLK clknet_4_4_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net175 clknet_0_net175 VGND VGND VPWR VPWR clknet_1_0__leaf_net175
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c329_A net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c367_S1 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net888 clknet_0_net888 VGND VGND VPWR VPWR clknet_1_1__leaf_net888
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge917_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s935_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c216_A1 net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c286_B net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge908_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c740_S1 clknet_1_0__leaf_net868 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s939_Q net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c126_A1 net902 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c499_A3 clknet_1_0__leaf_net961 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc92 net1049 net27 VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__nor2_4
Xc81 net9 net1051 net740 VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__and3b_1
Xc70 net661 VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__inv_6
XFILLER_0_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output88_A net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c443_SCE net1018 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_55 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc709 net565 net920 net580 net1037 net883 VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__o221ai_1
XANTENNA_c184_X net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c418_C1 net818 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net22 clknet_0_net22 VGND VGND VPWR VPWR clknet_1_1__leaf_net22 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_101_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_10_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c600_A0 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c233_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_5_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge822_A0 net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc528 net733 VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__buf_4
Xc539 net1043 clknet_1_0__leaf_net418 VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__or2_2
XANTENNA_merge898_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c314_A1 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput83 net980 VGND VGND VPWR VPWR out29 sky130_fd_sc_hd__buf_2
Xoutput72 clknet_1_1__leaf_net969 VGND VGND VPWR VPWR out17 sky130_fd_sc_hd__clkbuf_1
Xoutput94 net991 VGND VGND VPWR VPWR out39 sky130_fd_sc_hd__clkbuf_1
Xclkbuf_1_0__f_net516 clknet_0_net516 VGND VGND VPWR VPWR clknet_1_0__leaf_net516
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c505_A0 net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c366_B net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c597_A3 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c147_X net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c325_SCD net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c419_Y net994 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc303 net734 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__clkbuf_2
Xc336 net914 net144 net267 clknet_1_1__leaf_net832 VGND VGND VPWR VPWR net986 sky130_fd_sc_hd__o211a_2
Xc314 net113 net207 net135 net119 net233 net920 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__mux4_4
Xc325 clknet_4_7_0_clk net1094 net237 net128 net819 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__sdfstp_1
Xc369 net18 net1019 net290 net1044 clknet_1_1__leaf_net19 net845 VGND VGND VPWR VPWR
+ net301 sky130_fd_sc_hd__mux4_2
Xc358 net213 net838 net842 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__nand3b_4
Xc347 net1019 net275 net281 clknet_1_0__leaf_net19 net280 net802 VGND VGND VPWR VPWR
+ net282 sky130_fd_sc_hd__mux4_4
XFILLER_0_99_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge802 net245 clknet_1_0__leaf_net464 clknet_1_1__leaf_net429 net361 net1041 net990
+ VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__mux4_2
XFILLER_0_95_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge813 net96 net142 clknet_1_1__leaf_net16 net4 clknet_1_0__leaf_net19 net5 VGND
+ VGND VPWR VPWR net693 sky130_fd_sc_hd__mux4_2
Xmerge824 clknet_1_0__leaf_net427 net426 clknet_1_1__leaf_net432 net451 net444 net449
+ VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__mux4_1
Xmerge846 clknet_4_6_0_clk net360 net370 VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__dfrtp_4
Xmerge835 net390 net391 VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__and2_2
Xs930 clknet_4_15_0_clk net40 VGND VGND VPWR VPWR net827 net826 sky130_fd_sc_hd__dfxbp_1
Xs941 net250 clknet_4_7_0_clk VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__dlxtn_2
Xmerge857 clknet_4_14_0_clk merge857/D net306 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__dfstp_1
Xmerge879 net520 net625 VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__nor2_4
Xs952 clknet_4_4_0_clk net340 VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__dlclkp_2
XFILLER_0_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge868 net400 net415 VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__and2b_4
XFILLER_0_70_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs985 clknet_4_8_0_clk net614 VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__dlclkp_4
Xs963 clknet_4_3_0_clk net472 VGND VGND VPWR VPWR net864 net863 sky130_fd_sc_hd__dfxbp_1
Xs974 net526 clknet_4_11_0_clk VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__dlxtn_1
XTAP_TAPCELL_ROW_11_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer5 net1098 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c606_C1 net1012 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_97_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output70_A clknet_1_0__leaf_net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c121_C net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c219_A1 net1004 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c114_B net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge803_A2 net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c666_CLK clknet_4_0_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout125 net5 VGND VGND VPWR VPWR net1022 sky130_fd_sc_hd__buf_4
Xfanout147 net941 VGND VGND VPWR VPWR net1044 sky130_fd_sc_hd__buf_4
Xfanout136 net319 VGND VGND VPWR VPWR net1033 sky130_fd_sc_hd__buf_4
XANTENNA_c476_A net385 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c271_Y net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_53_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c67_B net1044 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc100 net20 net27 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__nand2_1
Xc111 net920 clknet_1_0__leaf_net24 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__nand2_2
XFILLER_0_20_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc122 clknet_4_15_0_clk net52 clknet_1_0__leaf_net54 net60 net55 VGND VGND VPWR VPWR
+ net61 sky130_fd_sc_hd__sdfrtp_1
Xc144 net749 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__inv_2
Xc133 net907 net954 net905 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__nand3b_4
Xc166 net759 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_1
Xc177 net108 net114 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__or2_2
Xc155 net910 net914 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__or2_1
Xc188 net126 net123 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__nor2b_1
Xc199 net139 clknet_1_0__leaf_net22 net1041 net136 net96 VGND VGND VPWR VPWR net140
+ sky130_fd_sc_hd__o221ai_2
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge790_S1 net1020 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc352_18 net804 VGND VGND VPWR VPWR net1063 sky130_fd_sc_hd__clkinv_2
XFILLER_0_95_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge880_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net429_X clknet_1_0__leaf_net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c169_C net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net110 clknet_0_net110 VGND VGND VPWR VPWR clknet_1_0__leaf_net110
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net176 clknet_0_net176 VGND VGND VPWR VPWR clknet_1_0__leaf_net176
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c224_A net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_50_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge785_S1 net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net889 clknet_0_net889 VGND VGND VPWR VPWR clknet_1_1__leaf_net889
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge809_A1 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c247_C_N net1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout142_X net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c126_A2 net921 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc82 net920 net740 VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__or2b_1
Xc71 net7 net900 VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__or2b_2
Xc93 net7 net13 clknet_1_0__leaf_net29 VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__or3_2
XFILLER_0_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c317_A1 net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c221_B_N net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c131_SCE net810 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c288_S1 net765 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c177_X net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net832 net832 VGND VGND VPWR VPWR clknet_0_net832 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c418_B1 net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net887 net887 VGND VGND VPWR VPWR clknet_0_net887 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_50_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net12 clknet_0_net12 VGND VGND VPWR VPWR clknet_1_1__leaf_net12 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net34 clknet_0_net34 VGND VGND VPWR VPWR clknet_1_1__leaf_net34 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_101_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input32_A in37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_11_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c600_A1 net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c344_C1 net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c151_C net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge806_A2 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge822_A1 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc529 net329 net990 VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__and2_4
XFILLER_0_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c352_13_A net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge766_SET_B net532 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput73 net970 VGND VGND VPWR VPWR out18 sky130_fd_sc_hd__buf_2
XANTENNA_c314_A2 net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput84 net981 VGND VGND VPWR VPWR out3 sky130_fd_sc_hd__buf_2
XFILLER_0_37_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput95 clknet_1_0__leaf_net992 VGND VGND VPWR VPWR out4 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_62_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c582_S0 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c366_C net1039 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge817_A1 net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc315 clknet_1_1__leaf_net130 net931 net246 net838 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__o211a_1
Xc304 net100 net236 net233 net217 net231 net224 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc326 clknet_4_12_0_clk net244 net254 net985 net237 VGND VGND VPWR VPWR net262 net261
+ sky130_fd_sc_hd__sedfxbp_2
Xc359 net290 net18 net984 net729 net842 VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__o221ai_4
Xc337 net775 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__inv_2
Xc348 clknet_4_12_0_clk net221 net280 net1000 net277 net1072 VGND VGND VPWR VPWR net284
+ net283 sky130_fd_sc_hd__sdfbbp_1
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_99_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_86_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge803 net119 net361 net353 net88 net124 net114 VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__mux4_1
Xmerge836 net630 net633 VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__or2_4
XFILLER_0_23_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge825 net426 clknet_1_0__leaf_net432 net428 net86 net324 clknet_1_1__leaf_net430
+ VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__mux4_2
Xmerge814 net324 net311 net1015 net907 net200 net204 VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__mux4_1
Xs931 clknet_4_15_0_clk net68 VGND VGND VPWR VPWR net983 net828 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_82_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge847 clknet_4_13_0_clk net158 net165 VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__dfrtp_4
Xs942 net253 clknet_4_7_0_clk VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__dlxtn_2
Xmerge869 net608 net639 VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__or2b_4
Xmerge858 net198 net407 VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__nor2b_1
Xs986 net620 clknet_4_8_0_clk VGND VGND VPWR VPWR net891 net890 sky130_fd_sc_hd__dlxbn_2
Xs975 net529 clknet_4_10_0_clk VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__dlxtn_1
Xs964 clknet_4_3_0_clk net474 VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__dfxtp_2
Xs953 clknet_4_4_0_clk net343 VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__dlclkp_4
XTAP_TAPCELL_ROW_11_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer6 net338 VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output63_A net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net303 clknet_0_net303 VGND VGND VPWR VPWR clknet_1_0__leaf_net303
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout137 net1035 VGND VGND VPWR VPWR net1034 sky130_fd_sc_hd__clkbuf_4
Xfanout148 net924 VGND VGND VPWR VPWR net1045 sky130_fd_sc_hd__buf_4
XANTENNA_c251_A0 net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c371_A net813 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c264_Y net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s956_GATE clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc101 clknet_1_1__leaf_net35 clknet_1_0__leaf_net36 net37 net28 net927 net33 VGND
+ VGND VPWR VPWR net38 sky130_fd_sc_hd__mux4_4
XFILLER_0_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc123 net654 VGND VGND VPWR VPWR net974 sky130_fd_sc_hd__inv_6
Xc112 net9 net11 net45 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__and3b_1
XANTENNA_c145_A1 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc145 net901 net1040 net83 net73 net80 net959 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__mux4_1
Xc134 net1041 net907 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__nand2b_2
XFILLER_0_20_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc156 net922 net83 net1034 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__nor3b_2
Xc167 net771 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_2
Xc178 net119 net113 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__nor2_1
Xc189 net120 net106 net952 net128 net107 net127 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__mux4_4
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c161_B1 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc352_19 net804 VGND VGND VPWR VPWR net1064 sky130_fd_sc_hd__clkinv_2
XFILLER_0_95_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c695_12_A clknet_1_0__leaf_net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c473_SCD net1022 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc690 clknet_4_0_0_clk net200 net558 net1045 net557 net556 VGND VGND VPWR VPWR net565
+ net564 sky130_fd_sc_hd__sdfbbn_2
XPHY_EDGE_ROW_3_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c502_A2 net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net111 clknet_0_net111 VGND VGND VPWR VPWR clknet_1_0__leaf_net111
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c479_Y net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_67_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c327_CLK clknet_4_6_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input62_A in9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_76_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c680_S0 net532 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net868 clknet_0_net868 VGND VGND VPWR VPWR clknet_1_1__leaf_net868
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_85_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c453_D net944 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c167_A net771 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c590_S0 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge809_A2 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_580 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c718_D net532 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c126_A3 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc94 net27 net953 VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__nand2b_1
Xc72 net8 net1022 net952 net1 VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__o211a_1
Xc83 net790 VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkinv_4
XFILLER_0_85_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c317_A2 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge905_Q net798 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c585_S0 net862 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c291_B net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_583 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net888 net888 VGND VGND VPWR VPWR clknet_0_net888 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net24 clknet_0_net24 VGND VGND VPWR VPWR clknet_1_1__leaf_net24 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_30_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net35 clknet_0_net35 VGND VGND VPWR VPWR clknet_1_1__leaf_net35 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_101_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold40 net828 VGND VGND VPWR VPWR net1097 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input25_A in30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output93_A net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c560_11_A clknet_1_1__leaf_net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c137_B net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge822_A2 net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c109_Q_N net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c164_B1 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c348_Q_N net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput85 net982 VGND VGND VPWR VPWR out30 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c314_A3 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput74 net1020 VGND VGND VPWR VPWR out19 sky130_fd_sc_hd__buf_2
Xoutput63 net960 VGND VGND VPWR VPWR out0 sky130_fd_sc_hd__buf_2
XANTENNA_c480_Q net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput96 clknet_1_1__leaf_net993 VGND VGND VPWR VPWR out40 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c672_S1 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_42_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
.ends
