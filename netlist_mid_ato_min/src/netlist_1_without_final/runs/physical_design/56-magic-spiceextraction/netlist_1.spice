* NGSPICE file created from netlist_1.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_2 abstract view
.subckt sky130_fd_sc_hd__or4bb_2 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_4 abstract view
.subckt sky130_fd_sc_hd__mux4_4 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_1 abstract view
.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_4 abstract view
.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbp_1 abstract view
.subckt sky130_fd_sc_hd__dlxbp_1 D GATE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_2 abstract view
.subckt sky130_fd_sc_hd__dfsbp_2 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbn_1 abstract view
.subckt sky130_fd_sc_hd__dlrbn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_1 abstract view
.subckt sky130_fd_sc_hd__dlclkp_1 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_1 abstract view
.subckt sky130_fd_sc_hd__dlxtn_1 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_1 abstract view
.subckt sky130_fd_sc_hd__dfxbp_1 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_2 abstract view
.subckt sky130_fd_sc_hd__dlclkp_2 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfsbp_1 abstract view
.subckt sky130_fd_sc_hd__dfsbp_1 CLK D SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtn_2 abstract view
.subckt sky130_fd_sc_hd__dlxtn_2 D GATE_N VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlclkp_4 abstract view
.subckt sky130_fd_sc_hd__dlclkp_4 CLK GATE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_2 abstract view
.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_4 abstract view
.subckt sky130_fd_sc_hd__and3b_4 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_4 abstract view
.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_2 abstract view
.subckt sky130_fd_sc_hd__o2111ai_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_1 abstract view
.subckt sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_0 abstract view
.subckt sky130_fd_sc_hd__and2_0 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_1 abstract view
.subckt sky130_fd_sc_hd__dlxbn_1 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_2 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_2 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_4 abstract view
.subckt sky130_fd_sc_hd__a2111oi_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtp_1 abstract view
.subckt sky130_fd_sc_hd__dlxtp_1 D GATE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_12 abstract view
.subckt sky130_fd_sc_hd__inv_12 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbp_1 CLK D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q
+ Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_2 abstract view
.subckt sky130_fd_sc_hd__a2111oi_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxbn_2 abstract view
.subckt sky130_fd_sc_hd__dlxbn_2 D GATE_N VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtn_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtn_1 CLK_N D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_2 abstract view
.subckt sky130_fd_sc_hd__a2111o_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__lpflow_inputisolatch_1 abstract view
.subckt sky130_fd_sc_hd__lpflow_inputisolatch_1 D SLEEP_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfbbn_1 abstract view
.subckt sky130_fd_sc_hd__sdfbbn_1 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR
+ Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrbp_2 abstract view
.subckt sky130_fd_sc_hd__sdfrbp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_1 abstract view
.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_16 abstract view
.subckt sky130_fd_sc_hd__inv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_2 abstract view
.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_4 abstract view
.subckt sky130_fd_sc_hd__o2111a_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_16 abstract view
.subckt sky130_fd_sc_hd__buf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_0 abstract view
.subckt sky130_fd_sc_hd__a2111oi_0 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtn_1 abstract view
.subckt sky130_fd_sc_hd__dfrtn_1 CLK_N D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbp_2 abstract view
.subckt sky130_fd_sc_hd__dlrbp_2 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_4 abstract view
.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfsbp_2 abstract view
.subckt sky130_fd_sc_hd__sdfsbp_2 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_2 abstract view
.subckt sky130_fd_sc_hd__o2111a_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_1 abstract view
.subckt sky130_fd_sc_hd__dlrtp_1 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrbp_1 abstract view
.subckt sky130_fd_sc_hd__dlrbp_1 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxbp_2 abstract view
.subckt sky130_fd_sc_hd__sedfxbp_2 CLK D DE SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_4 abstract view
.subckt sky130_fd_sc_hd__nor3b_4 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtp_2 abstract view
.subckt sky130_fd_sc_hd__dlrtp_2 D GATE RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_4 abstract view
.subckt sky130_fd_sc_hd__dfstp_4 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfstp_1 abstract view
.subckt sky130_fd_sc_hd__sdfstp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_4 abstract view
.subckt sky130_fd_sc_hd__a2111o_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_4 abstract view
.subckt sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_2 abstract view
.subckt sky130_fd_sc_hd__dfstp_2 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxbp_1 abstract view
.subckt sky130_fd_sc_hd__edfxbp_1 CLK D DE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__edfxtp_1 abstract view
.subckt sky130_fd_sc_hd__edfxtp_1 CLK D DE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxbp_1 abstract view
.subckt sky130_fd_sc_hd__sedfxbp_1 CLK D DE SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxtp_4 abstract view
.subckt sky130_fd_sc_hd__sedfxtp_4 CLK D DE SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_1 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_1 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_4 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_4 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sedfxtp_2 abstract view
.subckt sky130_fd_sc_hd__sedfxtp_2 CLK D DE SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_2 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_2 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdlclkp_4 abstract view
.subckt sky130_fd_sc_hd__sdlclkp_4 CLK GATE SCE VGND VNB VPB VPWR GCLK
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_1 abstract view
.subckt sky130_fd_sc_hd__dlrtn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_2 abstract view
.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_4 abstract view
.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_4 abstract view
.subckt sky130_fd_sc_hd__dlrtn_4 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_1 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlrtn_2 abstract view
.subckt sky130_fd_sc_hd__dlrtn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrbp_1 abstract view
.subckt sky130_fd_sc_hd__sdfrbp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_4 abstract view
.subckt sky130_fd_sc_hd__and2b_4 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfrtp_2 abstract view
.subckt sky130_fd_sc_hd__sdfrtp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__sdfstp_2 abstract view
.subckt sky130_fd_sc_hd__sdfstp_2 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxbp_2 abstract view
.subckt sky130_fd_sc_hd__dfxbp_2 CLK D VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_2 abstract view
.subckt sky130_fd_sc_hd__dfrbp_2 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_8 abstract view
.subckt sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

.subckt netlist_1 VGND VPWR clk in0 in1 in10 in11 in12 in13 in14 in15 in16 in17 in18
+ in19 in2 in20 in21 in22 in23 in24 in25 in26 in27 in28 in29 in3 in30 in31 in32 in33
+ in34 in35 in36 in37 in38 in39 in4 in40 in41 in42 in43 in44 in45 in46 in47 in48 in49
+ in5 in50 in51 in52 in53 in54 in55 in56 in57 in58 in59 in6 in60 in61 in7 in8 in9
+ out0 out1 out10 out11 out12 out13 out14 out15 out16 out17 out18 out19 out2 out20
+ out21 out22 out23 out24 out25 out26 out27 out28 out29 out3 out30 out31 out32 out33
+ out34 out35 out36 out37 out38 out39 out4 out40 out41 out42 out43 out44 out45 out46
+ out47 out48 out49 out5 out50 out51 out52 out53 out54 out55 out56 out57 out58 out59
+ out6 out60 out61 out7 out8 out9 rst
XFILLER_0_94_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c359_C net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s983_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge817_A2 net530 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c421_B net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc305 net1076 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__buf_6
Xc327 clknet_1_1__leaf_net245 net238 net239 net230 net1036 net1070 VGND VGND VPWR
+ VPWR net247 sky130_fd_sc_hd__mux4_2
Xc316 net232 net230 net231 net925 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__or4bb_2
XFILLER_0_13_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc349 net261 net265 net233 net132 net266 net1029 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__mux4_4
Xc338 net251 net258 net257 net131 net1037 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__o2111ai_1
XFILLER_0_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c415_A2 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c150_A2 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge804 net60 net1088 net28 net44 VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__or4bb_1
Xmerge826 net55 clknet_1_0__leaf_net1000 net140 net131 net138 net837 VGND VGND VPWR
+ VPWR net698 sky130_fd_sc_hd__mux4_4
Xmerge815 net197 net188 net210 net104 net208 net838 VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__mux4_1
Xmerge837 net299 net297 VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__nand2b_4
XFILLER_0_67_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs943 net127 clknet_4_12_0_clk VGND VGND VPWR VPWR net835 net834 sky130_fd_sc_hd__dlxbp_1
Xmerge848 clknet_4_5_0_clk net648 net78 VGND VGND VPWR VPWR net723 net722 sky130_fd_sc_hd__dfsbp_2
Xmerge859 net422 clknet_4_4_0_clk net666 VGND VGND VPWR VPWR net737 net736 sky130_fd_sc_hd__dlrbn_1
XANTENNA_c213_SET_B net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs954 clknet_4_14_0_clk net286 VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__dlclkp_1
Xs976 net568 clknet_4_2_0_clk VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_36_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs965 clknet_4_9_0_clk net483 VGND VGND VPWR VPWR net862 net861 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_48_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs987 clknet_4_8_0_clk net612 VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__dlclkp_2
XTAP_TAPCELL_ROW_11_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net471 net471 VGND VGND VPWR VPWR clknet_0_net471 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net482 net482 VGND VGND VPWR VPWR clknet_0_net482 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer7 net1010 VGND VGND VPWR VPWR net1061 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c622_A0 clknet_1_1__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s965_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net304 clknet_0_net304 VGND VGND VPWR VPWR clknet_1_0__leaf_net304
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net337 clknet_0_net337 VGND VGND VPWR VPWR clknet_1_0__leaf_net337
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_74_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout149 net206 VGND VGND VPWR VPWR net1045 sky130_fd_sc_hd__buf_4
XFILLER_0_77_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge828_A1 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc102 net33 net37 net29 VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__or3_1
Xc124 net35 net977 net825 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__or3b_1
Xc113 net1013 net19 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__or2_1
Xc135 net908 net911 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__and2b_2
XFILLER_0_20_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc168 net904 net929 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__nand2b_2
Xc157 net930 net85 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__or2_1
Xc146 net76 net70 net900 net931 net68 net74 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__mux4_1
Xc179 net101 net1046 net1047 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__nor3_2
XFILLER_0_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c617_A0 net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc680 net523 net540 net543 net531 net541 clknet_1_0__leaf_net532 VGND VGND VPWR VPWR
+ net544 sky130_fd_sc_hd__mux4_4
Xc691 net761 VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__clkbuf_1
XANTENNA_max_cap130_X net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s938_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_6_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge794_C_N net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout125_A net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c112_A net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c579_A net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s974_Q net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_net829_X clknet_0_net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input55_A in58 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net847 clknet_0_net847 VGND VGND VPWR VPWR clknet_1_1__leaf_net847
+ sky130_fd_sc_hd__clkbuf_16
Xmax_cap5 net1007 VGND VGND VPWR VPWR net1099 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input10_X net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge776_C_N net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c694_SCE clknet_1_0__leaf_net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c167_B net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c341_C net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c538_C1 net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge825_A2 net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout128_X net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc62 net938 net949 net944 net913 net945 net3 VGND VGND VPWR VPWR net0 sky130_fd_sc_hd__mux4_1
Xc73 net936 net946 net2 VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__nor3b_1
Xc84 net746 VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__inv_2
Xc95 net744 VGND VGND VPWR VPWR net1002 sky130_fd_sc_hd__buf_2
XFILLER_0_85_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c630_A0 net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c284_B net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_1__f_net963_X clknet_1_1__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s937_Q net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net867 net867 VGND VGND VPWR VPWR clknet_0_net867 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net889 net889 VGND VGND VPWR VPWR clknet_0_net889 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c715_B1 net462 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c153_A2 net64 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c731_C1 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold30 net761 VGND VGND VPWR VPWR net1084 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c450_A0 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input18_A in24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c609_A1 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c194_D1 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c625_A0 net257 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c238_A2 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge822_A3 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_88_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c726_C1 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c104_Q net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput75 clknet_1_1__leaf_net971 VGND VGND VPWR VPWR out20 sky130_fd_sc_hd__clkbuf_1
Xoutput64 net960 VGND VGND VPWR VPWR out10 sky130_fd_sc_hd__buf_2
Xoutput86 clknet_1_1__leaf_net982 VGND VGND VPWR VPWR out30 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput97 net993 VGND VGND VPWR VPWR out40 sky130_fd_sc_hd__buf_2
XANTENNA_c180_B1 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c704_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net519 clknet_0_net519 VGND VGND VPWR VPWR clknet_1_0__leaf_net519
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c189_D1 net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c339_A1 net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge773_C1 net196 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_42_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_8_0_clk_X clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_587 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc306 net227 net222 net215 net201 net225 net792 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__mux4_2
Xc317 net769 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__clkbuf_2
Xc339 net937 net256 net258 net1028 net835 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__o2111ai_1
Xc328 net244 net114 net239 net727 net835 net840 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__mux4_1
XFILLER_0_13_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge801_A net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c150_A3 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge896_Y net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge805 net61 net1002 net163 net947 net940 net14 VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__mux4_1
Xmerge827 net130 net131 net129 net2 net834 VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__a2111o_1
Xmerge816 clknet_2_1__leaf_net310 net308 net1032 net104 net324 clknet_1_0__leaf_net329
+ VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__mux4_4
XFILLER_0_67_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs933 clknet_4_13_0_clk net24 VGND VGND VPWR VPWR net821 net820 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_95_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge849 clknet_4_13_0_clk net652 net661 VGND VGND VPWR VPWR net725 net724 sky130_fd_sc_hd__dfsbp_1
Xmerge838 clknet_4_0_0_clk net548 net557 VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__dfrtp_2
Xs944 net166 clknet_4_15_0_clk VGND VGND VPWR VPWR net836 sky130_fd_sc_hd__dlxtn_2
Xs977 net569 clknet_4_2_0_clk VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__dlxtn_1
Xs966 clknet_4_3_0_clk net487 VGND VGND VPWR VPWR net864 net863 sky130_fd_sc_hd__dfxbp_1
Xs955 clknet_4_3_0_clk net343 VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__dlclkp_2
XTAP_TAPCELL_ROW_11_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs988 clknet_4_8_0_clk net615 VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__dlclkp_4
XFILLER_0_36_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer8 net985 VGND VGND VPWR VPWR net1062 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge892_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c590_Q net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c622_A1 net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net349 clknet_0_net349 VGND VGND VPWR VPWR clknet_1_0__leaf_net349
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c366_C1 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge883_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout128 net14 VGND VGND VPWR VPWR net1024 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_85_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc114 net950 net49 net19 net28 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__or4bb_1
Xc125 net44 net977 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__nand2b_1
Xc103 net36 net35 net40 net37 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__or4bb_1
Xc136 net901 net906 net66 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__nand3b_2
XFILLER_0_20_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc158 net928 net925 clknet_1_1__leaf_net827 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__and3b_4
Xc169 net95 clknet_1_0__leaf_net94 net826 VGND VGND VPWR VPWR net1000 sky130_fd_sc_hd__and3_2
Xc147 net68 net74 net900 VGND VGND VPWR VPWR net1011 sky130_fd_sc_hd__or3_4
XFILLER_0_13_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s978_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_A1 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c251_B_N net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge770_A0 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c633_A0 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc670 net970 VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__buf_6
Xc681 net544 net538 net542 net1038 net524 VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__o2111ai_1
Xc692 net555 net550 net444 VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__or3b_4
XFILLER_0_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c448_D_N net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net168 clknet_0_net168 VGND VGND VPWR VPWR clknet_1_0__leaf_net168
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c588_S1 net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c112_B net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c431_C_N net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge830_A3 net427 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s967_Q net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c437_A1 net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input48_A in51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net848 clknet_0_net848 VGND VGND VPWR VPWR clknet_1_1__leaf_net848
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap6 net1101 VGND VGND VPWR VPWR net1100 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c83_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge878_Q net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c628_A0 net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge781_C1 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c167_C net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_0__f_net963_X clknet_1_0__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c599_S0 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c720_A1 net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc74 net941 net7 VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__and2b_1
Xc63 net954 net941 net951 net914 net939 net949 VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__mux4_1
Xc85 net1025 net14 net23 net17 net22 net5 VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__mux4_1
Xc96 net1002 net823 VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_26_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire123 net1020 VGND VGND VPWR VPWR net1019 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_80_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c333_A3 net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net623 clknet_0_net623 VGND VGND VPWR VPWR clknet_1_1__leaf_net623
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c358_B1 net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_9_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout140_X net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net868 net868 VGND VGND VPWR VPWR clknet_0_net868 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_31_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c731_B1 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold20 net1006 VGND VGND VPWR VPWR net1074 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 net552 VGND VGND VPWR VPWR net1085 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_552 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c80_X net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c194_C1 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge787_D1 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net849_A net849 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c554_A net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge903_GATE_N clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c726_B1 net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput76 net972 VGND VGND VPWR VPWR out21 sky130_fd_sc_hd__buf_2
Xoutput65 net961 VGND VGND VPWR VPWR out11 sky130_fd_sc_hd__buf_2
Xoutput87 net1019 VGND VGND VPWR VPWR out31 sky130_fd_sc_hd__buf_2
Xoutput98 net994 VGND VGND VPWR VPWR out41 sky130_fd_sc_hd__buf_2
XANTENNA_input30_A in35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net1000 net1000 VGND VGND VPWR VPWR clknet_0_net1000 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_98_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c339_A2 net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c697_S0 net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c355_A1 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c371_B1 net292 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net283 clknet_0_net283 VGND VGND VPWR VPWR clknet_1_1__leaf_net283
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c249_A2 net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_99_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c407_B net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc307 net212 net227 net217 net207 net206 net228 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__mux4_1
Xc318 net769 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__buf_6
XFILLER_0_13_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc329 net239 net241 net1028 net1036 net727 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__o2111ai_2
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c712_A2 net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge806 net12 net950 net9 net924 net30 net820 VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__mux4_2
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge828 net538 net72 net524 clknet_1_0__leaf_net339 clknet_1_0__leaf_net545 net444
+ VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__mux4_1
Xmerge817 net526 net530 net413 net415 net312 VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__a2111oi_1
Xs934 clknet_4_13_0_clk net26 VGND VGND VPWR VPWR net823 net822 sky130_fd_sc_hd__dfxbp_1
XFILLER_0_82_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmerge839 net96 net643 VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__and2_0
Xs945 net171 clknet_4_15_0_clk VGND VGND VPWR VPWR net837 sky130_fd_sc_hd__dlxtn_1
XFILLER_0_36_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs967 clknet_4_9_0_clk net497 VGND VGND VPWR VPWR net960 sky130_fd_sc_hd__dfxtp_2
XANTENNA_c456_A0 net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs956 clknet_4_6_0_clk net346 VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__dlclkp_4
Xs978 net579 clknet_4_2_0_clk VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__dlxtn_2
XTAP_TAPCELL_ROW_11_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs989 net621 clknet_4_8_0_clk VGND VGND VPWR VPWR net891 net890 sky130_fd_sc_hd__dlxbn_1
Xclkbuf_0_net473 net473 VGND VGND VPWR VPWR clknet_0_net473 sky130_fd_sc_hd__clkbuf_16
Xrebuffer9 net153 VGND VGND VPWR VPWR net1063 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c485_SCD net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c622_A2 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input33_X net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net339 clknet_0_net339 VGND VGND VPWR VPWR clknet_1_0__leaf_net339
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_80_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c305_X net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc126 net58 net1099 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__nand2_1
Xc104 clknet_4_15_0_clk net927 net19 net36 net38 net718 VGND VGND VPWR VPWR net974
+ net42 sky130_fd_sc_hd__sdfbbn_2
Xc115 net937 net49 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__nand2_1
Xc159 net912 net1041 net84 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__or3b_1
Xc148 net77 net703 net75 net906 net72 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__a2111o_1
Xc137 net66 net67 net68 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__or3b_1
XFILLER_0_13_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c578_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_99_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge770_A1 net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_12_0_clk_X clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c502_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc682 net773 VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__inv_4
Xc660 net638 VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__inv_2
Xc671 net714 VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__clkbuf_1
Xc693 clknet_1_0__leaf_net303 clknet_1_0__leaf_net529 net330 net556 net541 VGND VGND
+ VPWR VPWR net557 sky130_fd_sc_hd__a2111oi_4
XFILLER_0_78_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c449_SCD clknet_1_0__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_1_1__f_net829_A clknet_0_net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c262_A2 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c109_S1 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c474_B net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c467_A net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_27_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c540_11_A net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c437_A2 net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c734_A0 clknet_1_1__leaf_net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_36_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net827 clknet_0_net827 VGND VGND VPWR VPWR clknet_1_1__leaf_net827
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_45_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net849 clknet_0_net849 VGND VGND VPWR VPWR clknet_1_1__leaf_net849
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_29_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c334_SET_B net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c628_A1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_54_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge781_B1 net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc490 net31 net277 clknet_1_1__leaf_net284 net962 net993 net818 VGND VGND VPWR VPWR
+ net397 sky130_fd_sc_hd__mux4_4
XPHY_EDGE_ROW_63_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge810_S0 net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c334_D net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_72_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c94_A_N net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_81_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c720_A2 net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc75 net9 net4 net1043 VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__nand3_1
Xc64 net948 net952 net945 net1 net938 net3 VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__mux4_2
Xc97 net29 net950 net1071 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__or3_2
Xc86 net17 net16 net23 net4 VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__or4bb_1
XTAP_TAPCELL_ROW_26_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_90_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input60_A in7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c159_C_N net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net613 clknet_0_net613 VGND VGND VPWR VPWR clknet_1_1__leaf_net613
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_6_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge805_S0 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c165_A net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c332_A net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout133_X net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net847 net847 VGND VGND VPWR VPWR clknet_0_net847 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c731_A1 net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold32 net821 VGND VGND VPWR VPWR net1086 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 net962 VGND VGND VPWR VPWR net1075 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c450_A2 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c313_C_N net101 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c459_A0 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c625_A2 clknet_1_1__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net498 clknet_0_net498 VGND VGND VPWR VPWR clknet_1_1__leaf_net498
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c304_C_N net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_65_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c175_Y net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s986_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c554_B net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c335_X net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c726_A1 net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_50_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c742_A0 clknet_1_1__leaf_net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput66 net962 VGND VGND VPWR VPWR out12 sky130_fd_sc_hd__buf_2
XANTENNA_c461_A1 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput88 clknet_1_1__leaf_net984 VGND VGND VPWR VPWR out32 sky130_fd_sc_hd__clkbuf_1
Xoutput99 net995 VGND VGND VPWR VPWR out42 sky130_fd_sc_hd__buf_2
Xoutput77 net973 VGND VGND VPWR VPWR out22 sky130_fd_sc_hd__buf_2
XANTENNA_c180_A2 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input23_A in29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c189_B1 net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c486_D1 net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c355_A2 clknet_1_1__leaf_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output91_A net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c371_A1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s968_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net284 clknet_0_net284 VGND VGND VPWR VPWR clknet_1_1__leaf_net284
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_43_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c191_SCD net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc308 net201 net1048 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__and2_2
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc319 net766 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_13_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c281_A1 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c712_A3 clknet_1_0__leaf_net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c285_X net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c664_A net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge807 net7 net21 net12 net37 net38 net1002 VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__mux4_1
Xmerge818 net197 clknet_1_1__leaf_net329 clknet_2_3__leaf_net310 net133 net140 net136
+ VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__mux4_2
XANTENNA_c737_A0 net597 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge829 net450 clknet_1_0__leaf_net428 net437 clknet_1_1__leaf_net529 net537 net712
+ VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__mux4_4
XFILLER_0_48_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xs935 clknet_4_15_0_clk net43 VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xs968 clknet_4_9_0_clk net499 VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__dfxtp_4
Xs957 net365 clknet_4_6_0_clk VGND VGND VPWR VPWR net851 net850 sky130_fd_sc_hd__dlxbn_1
Xs946 net200 clknet_4_4_0_clk VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__dlxtn_2
XFILLER_0_63_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs979 net588 clknet_4_2_0_clk VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__dlxtp_1
XTAP_TAPCELL_ROW_11_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c622_A3 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net318 clknet_0_net318 VGND VGND VPWR VPWR clknet_1_0__leaf_net318
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net329 clknet_0_net329 VGND VGND VPWR VPWR clknet_1_0__leaf_net329
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c366_A1 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c501_S0 net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net829_A clknet_0_net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge813_S0 clknet_1_0__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s944_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc105 net10 net32 net29 net35 net36 net1090 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__mux4_1
Xc116 net1043 net49 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__and2_1
Xc127 net726 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__buf_6
XFILLER_0_13_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc149 net66 net77 net911 net65 net775 VGND VGND VPWR VPWR net1014 sky130_fd_sc_hd__o2111ai_2
Xc138 net65 net68 net953 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__and3_1
Xc223_2 clknet_1_0__leaf_net762 VGND VGND VPWR VPWR net1050 sky130_fd_sc_hd__inv_8
XANTENNA_c667_X net530 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c617_A3 clknet_1_1__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge770_A2 net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c633_A2 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc661 net638 VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__inv_12
Xc672 net427 clknet_1_0__leaf_net529 net531 net323 net524 net193 VGND VGND VPWR VPWR
+ net535 sky130_fd_sc_hd__mux4_4
Xc694 clknet_4_0_0_clk net196 net537 net556 clknet_1_0__leaf_net455 net1085 VGND VGND
+ VPWR VPWR net559 net558 sky130_fd_sc_hd__sdfbbp_1
Xc683 net334 clknet_1_0__leaf_net303 clknet_1_0__leaf_net455 VGND VGND VPWR VPWR net547
+ sky130_fd_sc_hd__and3_1
XFILLER_0_91_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net159 clknet_0_net159 VGND VGND VPWR VPWR clknet_1_0__leaf_net159
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c467_B net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c718_A2 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c750_A0 net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net828 clknet_0_net828 VGND VGND VPWR VPWR clknet_1_1__leaf_net828
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_100_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap8 net585 VGND VGND VPWR VPWR net1102 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_29_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c628_A2 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s990_GATE_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c347_A3 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge781_A1 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc480 net327 clknet_1_0__leaf_net384 net844 VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__and3b_1
Xc491 net278 clknet_2_3__leaf_net310 clknet_1_1__leaf_net965 net1024 clknet_1_1__leaf_net275
+ clknet_1_1__leaf_net395 VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__mux4_1
XFILLER_0_87_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_82_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c538_A2 net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c222_C net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net94 clknet_0_net94 VGND VGND VPWR VPWR clknet_1_0__leaf_net94 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_15_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc65 net914 net927 net913 net910 net919 VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__a2111oi_2
Xc76 net6 net13 VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__and2_1
Xc98 net31 net955 net33 VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__and3_1
Xc87 net20 net944 net25 net23 net1025 net17 VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_26_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A1 clknet_2_2__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input53_A in56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net614 clknet_0_net614 VGND VGND VPWR VPWR clknet_1_1__leaf_net614
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c630_A3 clknet_2_2__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c489_D1 net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c358_A2 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge805_S1 net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c549_A1 net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c332_B net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_0_net310_X clknet_0_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net848 net848 VGND VGND VPWR VPWR clknet_0_net848 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_31_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold22 net781 VGND VGND VPWR VPWR net1076 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 net317 VGND VGND VPWR VPWR net1087 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c450_A3 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c625_A3 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge787_B1 net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net455 clknet_0_net455 VGND VGND VPWR VPWR clknet_1_1__leaf_net455
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net488 clknet_0_net488 VGND VGND VPWR VPWR clknet_1_1__leaf_net488
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_65_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c504_S0 clknet_1_1__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_587 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_88_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net623 net623 VGND VGND VPWR VPWR clknet_0_net623 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c726_A2 clknet_1_1__leaf_net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput67 clknet_1_1__leaf_net963 VGND VGND VPWR VPWR out13 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c461_A2 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput78 net974 VGND VGND VPWR VPWR out23 sky130_fd_sc_hd__buf_2
Xoutput89 net1061 VGND VGND VPWR VPWR out33 sky130_fd_sc_hd__buf_2
XANTENNA_input16_A in22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c486_C1 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c636_A2 net391 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_42_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge895_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c371_A2 net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c191_SCE net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc309 net771 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__inv_2
XFILLER_0_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input8_A in15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c664_B net427 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c278_X net196 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge819 net933 net38 net1002 net929 net10 net710 VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__mux4_1
XFILLER_0_83_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge808 net146 net900 net189 clknet_1_0__leaf_net155 clknet_1_0__leaf_net283 net266
+ VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__mux4_4
Xs936 clknet_4_15_0_clk net47 VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__dfxtp_2
Xs947 net202 clknet_4_5_0_clk VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__dlxtp_1
Xs958 net411 clknet_4_10_0_clk VGND VGND VPWR VPWR net853 net852 sky130_fd_sc_hd__dlxbn_2
XFILLER_0_48_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs969 clknet_4_8_0_clk net500 VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_51_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c456_A2 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c753_B1 net292 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_2_3__f_net310 clknet_0_net310 VGND VGND VPWR VPWR clknet_2_3__leaf_net310
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_101_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input19_X net915 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c414_Q_N net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c245_B net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c411_S1 clknet_2_0__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c405_A net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc106 net22 net1002 net42 net1042 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__or4bb_1
Xc117 net726 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_96_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc128 clknet_4_15_0_clk net59 net58 net57 net49 VGND VGND VPWR VPWR net1004 sky130_fd_sc_hd__sdfrtn_1
Xc139 net902 net703 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__and2b_2
XFILLER_0_13_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc223_3 clknet_1_0__leaf_net762 VGND VGND VPWR VPWR net1051 sky130_fd_sc_hd__inv_8
XANTENNA_c85_A1 net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c748_A0 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c321_S1 net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net283 net283 VGND VGND VPWR VPWR clknet_0_net283 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_rebuffer11_X net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c633_A3 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc662 net714 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__inv_2
Xc673 net525 net872 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__and2b_1
Xc695 net559 net552 clknet_1_1__leaf_net532 net554 net332 net556 VGND VGND VPWR VPWR
+ net560 sky130_fd_sc_hd__mux4_1
Xc684 net330 net432 clknet_1_0__leaf_net529 net860 VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__or4bb_1
XFILLER_0_91_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c605_D_N clknet_1_1__leaf_net848 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge808_S1 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c188_A net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c734_A2 clknet_1_1__leaf_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge909_GATE_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net829 clknet_0_net829 VGND VGND VPWR VPWR clknet_1_1__leaf_net829
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge870_RESET_B net665 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c628_A3 clknet_1_0__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge926_Q net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc470 net790 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__buf_4
Xc492 clknet_1_0__leaf_net395 net391 clknet_1_1__leaf_net397 net46 net989 VGND VGND
+ VPWR VPWR net399 sky130_fd_sc_hd__a2111o_2
XFILLER_0_87_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_82_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_1__f_net455_X clknet_1_1__leaf_net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c570_A1 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc66 net947 net949 VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__nand2_1
Xc77 net944 net10 net12 net956 net7 net1024 VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__mux4_1
Xc88 net718 VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__inv_1
XFILLER_0_97_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc99 net779 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__inv_4
XTAP_TAPCELL_ROW_26_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c729_A2 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c532_Y net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c152_S0 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge801_D_N net196 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input46_A in5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c327_S0 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge792_A1 net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c549_A2 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c158_B net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c332_C net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net827 net827 VGND VGND VPWR VPWR clknet_0_net827 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net849 net849 VGND VGND VPWR VPWR clknet_0_net849 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_31_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold23 net826 VGND VGND VPWR VPWR net1077 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 net49 VGND VGND VPWR VPWR net1088 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c756_A0 net597 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c610_S0 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c475_A1 net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c194_A2 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_9_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge877_GATE clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c275_B net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_69_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c369_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net613 net613 VGND VGND VPWR VPWR clknet_0_net613 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_48_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge767_B net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c497_SCD net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_78_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput68 net964 VGND VGND VPWR VPWR out14 sky130_fd_sc_hd__buf_2
Xoutput79 net975 VGND VGND VPWR VPWR out24 sky130_fd_sc_hd__buf_2
XFILLER_0_98_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c189_A2 net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net1003 net1003 VGND VGND VPWR VPWR clknet_0_net1003 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c486_B1 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c636_A3 net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output77_A net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net275 clknet_0_net275 VGND VGND VPWR VPWR clknet_1_1__leaf_net275
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c608_CLK_N clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c552_A net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c587_C1 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge809 net369 net306 net376 net134 net8 net23 VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__mux4_1
Xs937 clknet_4_5_0_clk net80 VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__dfxtp_2
Xs948 net246 clknet_4_12_0_clk VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__lpflow_inputisolatch_1
Xs959 net429 clknet_4_1_0_clk VGND VGND VPWR VPWR net855 net854 sky130_fd_sc_hd__dlxbp_1
XFILLER_0_90_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net498 net498 VGND VGND VPWR VPWR clknet_0_net498 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_31_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output115_A net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net309 clknet_0_net309 VGND VGND VPWR VPWR clknet_1_0__leaf_net309
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s973_GATE_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net887 clknet_0_net887 VGND VGND VPWR VPWR clknet_1_0__leaf_net887
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c300_A net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc107 net19 net31 net35 net22 net718 net1042 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__mux4_1
Xc118 net52 net46 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__or2b_1
XFILLER_0_5_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_96_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc129 net34 net1004 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__or2b_1
XFILLER_0_79_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc223_4 clknet_1_0__leaf_net762 VGND VGND VPWR VPWR net1052 sky130_fd_sc_hd__inv_8
XFILLER_0_95_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c85_A2 net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c748_A1 net597 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c602_S1 net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net284 net284 VGND VGND VPWR VPWR clknet_0_net284 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_32_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc630 net392 net505 clknet_1_0__leaf_net968 clknet_2_2__leaf_net310 net387 net960
+ VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__mux4_1
Xc663 net317 net958 VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__nor2_2
Xc696 clknet_4_0_0_clk clknet_1_0__leaf_net545 net533 net549 clknet_1_0__leaf_net455
+ net712 VGND VGND VPWR VPWR net562 net561 sky130_fd_sc_hd__sdfbbn_2
Xc674 net531 net193 net871 VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__nor3b_2
Xc685 net814 VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__buf_1
XFILLER_0_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge795_A1 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net139 clknet_0_net139 VGND VGND VPWR VPWR clknet_1_0__leaf_net139
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_1_0__f_net455_X clknet_1_0__leaf_net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c352_C_N net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c143_Y net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout149_X net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c734_A3 net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c759_A0 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c613_S0 clknet_1_1__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_14_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c197_A2 net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_23_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc471 net371 net377 net972 VGND VGND VPWR VPWR net991 sky130_fd_sc_hd__and3_4
Xc460 net336 clknet_1_1__leaf_net366 net351 net355 net360 net782 VGND VGND VPWR VPWR
+ net367 sky130_fd_sc_hd__mux4_4
Xc482 net382 clknet_1_0__leaf_net384 net818 VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__nor3_1
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc493 clknet_4_11_0_clk net291 clknet_1_0__leaf_net965 clknet_1_0__leaf_net275 net1046
+ clknet_1_1__leaf_net204 VGND VGND VPWR VPWR net995 net400 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_99_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_82_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_41_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_93_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c584_D net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc67 net1046 net919 VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__nor2_2
XPHY_EDGE_ROW_50_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc89 net0 net9 VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__nand2b_1
Xc78 net644 VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_2
XFILLER_0_78_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net470 clknet_0_net470 VGND VGND VPWR VPWR clknet_1_0__leaf_net470
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net481 clknet_0_net481 VGND VGND VPWR VPWR clknet_1_0__leaf_net481
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c420_X net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s940_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c745_A2 net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c761_A1 net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input39_A in43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c489_B1 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge792_A2 net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge913_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc290 net655 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__inv_1
XANTENNA_c118_B_N net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_5_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net828 net828 VGND VGND VPWR VPWR clknet_0_net828 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c325_C net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c687_B net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold24 net59 VGND VGND VPWR VPWR net1078 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 net128 VGND VGND VPWR VPWR net1089 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c77_A3 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c610_S1 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c475_A2 net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c491_A1 clknet_2_3__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c163_A net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_36_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c330_A net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net614 net614 VGND VGND VPWR VPWR clknet_0_net614 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c428_A net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge768_D_N net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c742_A3 net597 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s940_GCLK net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput69 clknet_1_0__leaf_net965 VGND VGND VPWR VPWR out15 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input61_X net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c412_SCE clknet_2_1__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net243 clknet_0_net243 VGND VGND VPWR VPWR clknet_1_1__leaf_net243
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_6_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs938 clknet_4_5_0_clk net81 VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__dlclkp_1
XFILLER_0_75_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xs949 clknet_4_12_0_clk net253 VGND VGND VPWR VPWR net842 net841 sky130_fd_sc_hd__dfxbp_1
XANTENNA_c454_SET_B clknet_1_0__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_net455 net455 VGND VGND VPWR VPWR clknet_0_net455 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net488 net488 VGND VGND VPWR VPWR clknet_0_net488 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c753_A2 net597 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input21_A in27 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_13_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c351_S0 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_97_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net888 clknet_0_net888 VGND VGND VPWR VPWR clknet_1_0__leaf_net888
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_70_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c405_C net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c300_B net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc108 clknet_4_15_0_clk net45 net1072 net974 net1042 VGND VGND VPWR VPWR net973 net46
+ sky130_fd_sc_hd__sdfrbp_2
XFILLER_0_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_96_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc119 net19 net48 VGND VGND VPWR VPWR net977 sky130_fd_sc_hd__or2_2
XFILLER_0_79_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c436_S0 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c548_X net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c86_B net16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c483_A2 net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc631 net1016 clknet_1_0__leaf_net397 net408 net810 clknet_1_1__leaf_net867 clknet_1_0__leaf_net868
+ VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__mux4_1
Xc620 net437 net293 net967 net1042 net843 clknet_1_1__leaf_net867 VGND VGND VPWR VPWR
+ net506 sky130_fd_sc_hd__mux4_4
Xc664 net1038 net427 VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__and2_1
Xc697 clknet_1_1__leaf_net532 net543 net556 net562 net330 clknet_1_1__leaf_net529
+ VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__mux4_4
Xc675 net536 net534 net872 VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__or3b_1
Xc686 net807 VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__buf_1
XFILLER_0_99_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge795_A2 net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net107 clknet_0_net107 VGND VGND VPWR VPWR clknet_1_0__leaf_net107
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_39_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c393_A2 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c250_B net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc397_9 clknet_1_0__leaf_net767 VGND VGND VPWR VPWR net1057 sky130_fd_sc_hd__inv_8
XFILLER_0_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c243_A net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge905_GATE clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc461 clknet_1_0__leaf_net366 net122 net935 net360 net996 net851 VGND VGND VPWR VPWR
+ net368 sky130_fd_sc_hd__mux4_1
Xc450 net966 net355 net230 net1011 clknet_1_0__leaf_net963 net803 VGND VGND VPWR VPWR
+ net356 sky130_fd_sc_hd__mux4_4
Xc472 net795 VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__inv_2
XFILLER_0_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc483 net386 clknet_1_0__leaf_net349 net1046 net233 net1033 net818 VGND VGND VPWR
+ VPWR net389 sky130_fd_sc_hd__mux4_4
Xc494 net296 clknet_1_1__leaf_net384 net994 net832 net842 clknet_1_1__leaf_net847
+ VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__mux4_1
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_1_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c577_D net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c465_B net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc68 net951 net950 VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__nor2b_1
Xc79 net946 net915 VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__or2b_1
XFILLER_0_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net471 clknet_0_net471 VGND VGND VPWR VPWR clknet_1_0__leaf_net471
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net482 clknet_0_net482 VGND VGND VPWR VPWR clknet_1_0__leaf_net482
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_6_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net628 clknet_0_net628 VGND VGND VPWR VPWR clknet_1_1__leaf_net628
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c624_S0 clknet_1_1__leaf_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge931_Q net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc280 net768 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__inv_2
Xc291 net781 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net829 net829 VGND VGND VPWR VPWR clknet_0_net829 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge790 net186 net1081 net208 net775 VGND VGND VPWR VPWR net662 sky130_fd_sc_hd__or4bb_1
XTAP_TAPCELL_ROW_31_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c694_D net196 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c687_C net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c582_B net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c575_A net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold36 net822 VGND VGND VPWR VPWR net1090 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 net558 VGND VGND VPWR VPWR net1079 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c756_A2 net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge862_Y net740 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c475_A3 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c423_D_N clknet_2_1__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c491_A2 clknet_1_1__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input51_A in54 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net458 clknet_0_net458 VGND VGND VPWR VPWR clknet_1_1__leaf_net458
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge898_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_77_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net981 clknet_0_net981 VGND VGND VPWR VPWR clknet_1_1__leaf_net981
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_36_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c330_B net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c707_D net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c235_Q net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c266_B_N net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c349_S0 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge798_A2 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c693_B1 net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c273_A net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c587_A1 net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c440_A net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c722_S0 clknet_1_1__leaf_net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xs939 clknet_4_5_0_clk net82 VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__dlclkp_2
XFILLER_0_90_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge818_X net690 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input14_A in20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c351_S1 net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_s980_SLEEP_B clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net867 clknet_0_net867 VGND VGND VPWR VPWR clknet_1_0__leaf_net867
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_70_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net889 clknet_0_net889 VGND VGND VPWR VPWR clknet_1_0__leaf_net889
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_72_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c119_A net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc109 net38 net45 net44 net42 net28 net1042 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__mux4_1
XFILLER_0_79_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_96_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c717_S0 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input6_A in13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c436_S1 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c469_B_N net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c748_A3 clknet_2_2__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_44_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c764_A2 clknet_2_2__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c483_A3 net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net275 net275 VGND VGND VPWR VPWR clknet_0_net275 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc610 net485 net413 net142 net463 net782 net846 VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__mux4_4
Xc621 net1024 net1043 net377 net962 clknet_1_0__leaf_net284 net408 VGND VGND VPWR
+ VPWR net507 sky130_fd_sc_hd__mux4_1
Xc632 clknet_1_1__leaf_net963 net391 net811 net1042 clknet_1_0__leaf_net971 clknet_1_1__leaf_net868
+ VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__mux4_4
Xc698 net554 net555 net556 net561 clknet_2_0__leaf_net310 net874 VGND VGND VPWR VPWR
+ net564 sky130_fd_sc_hd__mux4_4
Xc687 net533 net330 net958 VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__and3_1
Xc676 net538 net320 net317 net533 net526 VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__a2111oi_1
Xc665 net71 net524 VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__nor2_1
XANTENNA_output120_A net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c303_SCE net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge871_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c250_C clknet_1_1__leaf_net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c243_B net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout151_A net915 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc207_1 clknet_1_1__leaf_net762 VGND VGND VPWR VPWR net1049 sky130_fd_sc_hd__inv_16
XTAP_TAPCELL_ROW_29_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc462 net119 net263 net252 VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__nand3_1
Xc473 net378 net142 net216 net1024 net996 net843 VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__mux4_4
Xc451 net355 net351 net1047 net806 VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__or4bb_1
Xc440 net909 net935 clknet_1_1__leaf_net848 VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__and3_4
Xc495 net1027 net974 clknet_1_1__leaf_net384 net400 net29 clknet_1_1__leaf_net395
+ VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__mux4_1
Xc484 net29 net1037 net290 net1046 net845 VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__a2111oi_1
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c193_B net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc69 net6 net917 VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__and2_1
XFILLER_0_78_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c353_A net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c141_X net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c730_S0 net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire129 net11 VGND VGND VPWR VPWR net1025 sky130_fd_sc_hd__buf_1
XFILLER_0_33_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_rebuffer4_A net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c279_SCD net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c413_D1 clknet_2_1__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c489_A2 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc270 net1032 net1038 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__or2b_2
XFILLER_0_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc281 net194 net909 net198 net186 net931 net1039 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__mux4_1
Xc292 clknet_4_5_0_clk net199 net207 net190 net1045 clknet_1_0__leaf_net828 VGND VGND
+ VPWR VPWR net212 net211 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_46_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge780 net956 net90 net109 net830 VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__or4bb_1
XFILLER_0_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge791 net1058 net432 net414 net706 VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__or4bb_4
XFILLER_0_55_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c206_B net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c217_C1 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c709_S1 clknet_1_0__leaf_net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c575_B net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold15 net794 VGND VGND VPWR VPWR net1069 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 net335 VGND VGND VPWR VPWR net1091 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 net788 VGND VGND VPWR VPWR net1080 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c189_X net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c568_A net814 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s975_GATE clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c530_Y net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c619_S1 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c491_A3 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input44_A in48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c635_S0 clknet_1_1__leaf_net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net982 clknet_0_net982 VGND VGND VPWR VPWR clknet_1_1__leaf_net982
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_0_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net971 clknet_0_net971 VGND VGND VPWR VPWR clknet_1_1__leaf_net971
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_88_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c500_C1 net391 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c156_B net64 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_38_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c323_B net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_16_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c592_A2 net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c685_A net814 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c349_S1 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input47_X net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge798_A3 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net245 clknet_0_net245 VGND VGND VPWR VPWR clknet_1_1__leaf_net245
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_27_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c320_C1 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XANTENNA_c693_A1 clknet_1_0__leaf_net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c266_A net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c722_S1 net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c440_B net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge765_B net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net868 clknet_0_net868 VGND VGND VPWR VPWR clknet_1_0__leaf_net868
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_96_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c550_A net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c598_A1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c269_X net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c452_S1 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s970_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net243 net243 VGND VGND VPWR VPWR clknet_0_net243 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc600 net805 VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__inv_2
Xc611 net494 clknet_1_0__leaf_net488 net785 net809 clknet_1_1__leaf_net848 net863
+ VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__mux4_4
Xc622 clknet_1_1__leaf_net963 net376 net1024 net1042 net843 net858 VGND VGND VPWR
+ VPWR net508 sky130_fd_sc_hd__mux4_4
XFILLER_0_32_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc633 net1026 net501 net1016 net1041 net852 clknet_1_0__leaf_net868 VGND VGND VPWR
+ VPWR net518 sky130_fd_sc_hd__mux4_1
Xc688 net773 VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__inv_4
Xc677 net807 VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__buf_1
Xc666 net528 net1060 VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__nor2b_2
XANTENNA_c295_Q net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc699 net540 net445 net556 net559 net561 net860 VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__mux4_2
XFILLER_0_99_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c396_B_N net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c502_RESET_B net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s952_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c105_A2 net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c704_RESET_B clknet_1_0__leaf_net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge925_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c494_A3 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc430 net326 net926 net222 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__nand3b_1
Xc463 net25 net1041 net1037 VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__nor3b_1
XFILLER_0_20_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc441 net796 VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__clkbuf_2
Xc452 net221 net73 net351 clknet_1_1__leaf_net333 clknet_1_0__leaf_net347 net211 VGND
+ VGND VPWR VPWR net358 sky130_fd_sc_hd__mux4_2
XFILLER_0_20_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc474 net348 net73 VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__nand2b_1
Xc496 net1027 net400 net962 net1046 net1010 VGND VGND VPWR VPWR net983 sky130_fd_sc_hd__a2111oi_1
Xc485 clknet_4_14_0_clk net212 net296 net29 net295 net1075 VGND VGND VPWR VPWR net392
+ net391 sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_19_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c373_S0 net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_82_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge916_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s934_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_10_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge790_C_N net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c179_A net101 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c283_S0 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net473 clknet_0_net473 VGND VGND VPWR VPWR clknet_1_0__leaf_net473
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c730_S1 net463 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout147_X net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c279_SCE net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c458_S0 net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c307_A0 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc260 net178 net992 net176 VGND VGND VPWR VPWR net988 sky130_fd_sc_hd__nand3_4
Xc271 net182 net65 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__nor2_4
Xc282 net747 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__inv_1
Xc293 net655 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__inv_4
XFILLER_0_46_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge770 net18 net225 net437 net479 clknet_1_1__leaf_net482 net804 VGND VGND VPWR
+ VPWR net642 sky130_fd_sc_hd__mux4_4
Xmerge781 net926 net74 net414 net208 net857 VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__o2111a_1
XFILLER_0_62_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge792 net123 net23 net131 net928 net100 net775 VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__mux4_1
XFILLER_0_15_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c217_B1 net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c278_S0 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold16 net840 VGND VGND VPWR VPWR net1070 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 net1042 VGND VGND VPWR VPWR net1092 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 net183 VGND VGND VPWR VPWR net1081 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c460_S1 net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input37_A in41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c360_SCD net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net628 net628 VGND VGND VPWR VPWR clknet_0_net628 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c316_B net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c592_A3 clknet_1_1__leaf_net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c736_S0 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c580_A net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c455_S1 clknet_1_0__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c440_C clknet_1_1__leaf_net848 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net458 net458 VGND VGND VPWR VPWR clknet_0_net458 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_2_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c149_D1 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net981 net981 VGND VGND VPWR VPWR clknet_0_net981 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_66_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net847 clknet_0_net847 VGND VGND VPWR VPWR clknet_1_0__leaf_net847
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_75_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_0_net204_A net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_84_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c171_Y net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c232_D_N net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc601 net440 clknet_1_0__leaf_net481 clknet_1_1__leaf_net981 net1040 VGND VGND VPWR
+ VPWR net486 sky130_fd_sc_hd__or4bb_1
Xc612 net383 clknet_1_1__leaf_net481 net493 net846 net864 net960 VGND VGND VPWR VPWR
+ net498 sky130_fd_sc_hd__mux4_2
Xc634 net1041 net783 net808 net1042 net852 clknet_1_0__leaf_net868 VGND VGND VPWR
+ VPWR net519 sky130_fd_sc_hd__mux4_2
Xc623 clknet_1_0__leaf_net397 net1021 clknet_1_0__leaf_net275 net437 clknet_1_0__leaf_net965
+ net784 VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__mux4_4
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc678 clknet_4_0_0_clk net534 clknet_1_0__leaf_net532 net196 net540 net871 VGND VGND
+ VPWR VPWR net542 net541 sky130_fd_sc_hd__sdfbbn_2
Xc689 net1084 VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__inv_4
Xc667 net528 net524 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__and2b_1
XANTENNA_c432_D1 net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output106_A net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c229_B net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c273_C_N net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge820_A0 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge902_D net653 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c553_Y net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c427_D1 clknet_2_1__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc420 net802 VGND VGND VPWR VPWR net966 sky130_fd_sc_hd__buf_4
XFILLER_0_20_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc464 net798 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__clkbuf_4
Xc453 net351 net355 net787 net137 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__or4bb_1
Xc431 net331 net213 net966 clknet_2_1__leaf_net310 VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__or4bb_2
Xc442 net248 clknet_1_1__leaf_net347 VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__and2_0
XFILLER_0_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc497 clknet_4_11_0_clk net1068 net1095 net1024 net995 net376 VGND VGND VPWR VPWR
+ net404 net403 sky130_fd_sc_hd__sdfbbn_1
Xc475 net250 net327 net23 net1040 net377 clknet_1_0__leaf_net963 VGND VGND VPWR VPWR
+ net381 sky130_fd_sc_hd__mux4_2
Xc486 net291 net296 net212 net844 net845 VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__a2111oi_1
XFILLER_0_59_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge930 net619 clknet_4_8_0_clk net601 VGND VGND VPWR VPWR net817 net816 sky130_fd_sc_hd__dlrbn_1
XFILLER_0_28_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c179_B net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge815_A0 net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c458_S1 net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_s945_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c307_A1 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc250 net54 net135 clknet_1_1__leaf_net829 VGND VGND VPWR VPWR net982 sky130_fd_sc_hd__and3_4
Xc261 net772 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__inv_2
Xc272 net780 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__buf_4
Xc283 net69 net199 net192 net198 net906 net194 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__mux4_1
Xc294 net195 net212 net1011 net208 net1065 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__a2111o_1
XFILLER_0_99_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge771 net87 net98 net91 clknet_1_1__leaf_net827 clknet_1_0__leaf_net828 VGND VGND
+ VPWR VPWR net643 sky130_fd_sc_hd__o2111a_4
XFILLER_0_7_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge782 clknet_1_1__leaf_net352 net146 net306 clknet_1_0__leaf_net375 VGND VGND
+ VPWR VPWR net654 sky130_fd_sc_hd__or4bb_4
Xmerge793 net948 clknet_1_0__leaf_net1000 net937 net958 net93 clknet_1_0__leaf_net107
+ VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__mux4_4
XFILLER_0_70_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c217_A1 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold17 net820 VGND VGND VPWR VPWR net1071 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 net904 VGND VGND VPWR VPWR net1082 sky130_fd_sc_hd__dlygate4sd3_1
Xhold39 net562 VGND VGND VPWR VPWR net1093 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c463_B net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net428 clknet_0_net428 VGND VGND VPWR VPWR clknet_1_1__leaf_net428
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net406 clknet_0_net406 VGND VGND VPWR VPWR clknet_1_1__leaf_net406
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c191_CLK_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net984 clknet_0_net984 VGND VGND VPWR VPWR clknet_1_1__leaf_net984
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_0_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c500_A1 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c204_A net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c485_Q net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s956_GCLK net849 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c320_A1 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c581_SCE clknet_1_0__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c329_C1 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c603_C_N clknet_1_1__leaf_net848 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold38_A net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c161_B net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c230_A1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge823_A0 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c140_A1 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net94 net94 VGND VGND VPWR VPWR clknet_0_net94 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_39_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_530 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net982 net982 VGND VGND VPWR VPWR clknet_0_net982 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net971 net971 VGND VGND VPWR VPWR clknet_0_net971 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c343_SET_B net16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c392_S0 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_85_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net848 clknet_0_net848 VGND VGND VPWR VPWR clknet_1_0__leaf_net848
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_72_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c241_A0 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_7_0_clk_X clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge818_A0 net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net245 net245 VGND VGND VPWR VPWR clknet_0_net245 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc613 clknet_1_1__leaf_net498 net494 net1048 net413 clknet_1_1__leaf_net963 net862
+ VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__mux4_2
Xc602 net413 net437 net416 clknet_1_0__leaf_net458 net461 net225 VGND VGND VPWR VPWR
+ net487 sky130_fd_sc_hd__mux4_2
Xc635 clknet_1_0__leaf_net275 clknet_1_0__leaf_net519 net1021 net808 clknet_1_1__leaf_net829
+ clknet_1_0__leaf_net868 VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__mux4_4
Xc624 net1043 net1024 clknet_1_1__leaf_net963 clknet_1_0__leaf_net965 clknet_1_1__leaf_net204
+ clknet_1_0__leaf_net847 VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__mux4_4
Xc679 net897 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__inv_4
Xc668 net714 VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__buf_16
XANTENNA_c432_C1 clknet_1_0__leaf_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input12_A in19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c344_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net623 clknet_0_net623 VGND VGND VPWR VPWR clknet_1_0__leaf_net623
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c124_B net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge820_A1 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input4_A in11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c760_S0 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c427_C1 net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c146_A0 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc410 net669 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__clkbuf_1
Xc421 net67 net966 net226 VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__and3b_1
Xc432 net226 net326 net209 clknet_1_0__leaf_net204 net189 VGND VGND VPWR VPWR net338
+ sky130_fd_sc_hd__o2111a_4
XANTENNA_c454_SCD net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc454 clknet_4_6_0_clk net357 net355 net216 net351 clknet_1_0__leaf_net963 VGND VGND
+ VPWR VPWR net361 net360 sky130_fd_sc_hd__sdfbbn_1
Xc443 clknet_1_0__leaf_net347 net67 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__and2_1
XFILLER_0_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc465 net256 net233 net348 VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__nand3b_1
Xc476 net798 VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__buf_16
Xc487 net385 net1101 clknet_1_0__leaf_net275 net376 net1037 VGND VGND VPWR VPWR net394
+ sky130_fd_sc_hd__a2111oi_0
Xc498 clknet_1_0__leaf_net395 net404 clknet_1_1__leaf_net284 net42 clknet_1_1__leaf_net829
+ VGND VGND VPWR VPWR net978 sky130_fd_sc_hd__a2111oi_1
XFILLER_0_35_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_82_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge920 clknet_4_8_0_clk net642 net631 VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__dfrtn_1
Xmerge931 net367 clknet_4_9_0_clk net716 VGND VGND VPWR VPWR net996 net818 sky130_fd_sc_hd__dlrbp_2
XFILLER_0_27_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c179_C net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge815_A1 net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c755_S0 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c413_A1 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input7_X net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c663_Y net526 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc251 net62 net977 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__or2b_1
Xc240 net163 clknet_1_1__leaf_net168 net1024 net759 net836 VGND VGND VPWR VPWR net170
+ sky130_fd_sc_hd__o2111ai_4
Xc262 net180 net992 net1043 net157 net726 net837 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__mux4_4
XANTENNA_clkbuf_4_15_0_clk_X clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc295 clknet_4_7_0_clk net208 net775 net792 clknet_1_1__leaf_net828 VGND VGND VPWR
+ VPWR net216 net215 sky130_fd_sc_hd__sdfsbp_2
Xc273 net188 net190 net1031 net1039 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__or4bb_1
Xc284 net199 net193 net839 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__nor3b_2
XANTENNA_c173_C_N net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge772 net778 VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__inv_4
XFILLER_0_55_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge783 net771 VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__buf_6
XFILLER_0_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge794 net421 net931 net306 net192 VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__or4bb_1
XFILLER_0_55_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold18 net35 VGND VGND VPWR VPWR net1072 sky130_fd_sc_hd__dlygate4sd3_1
Xhold29 net792 VGND VGND VPWR VPWR net1083 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_c353_D_N net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout152_X net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net283 clknet_0_net283 VGND VGND VPWR VPWR clknet_1_0__leaf_net283
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_61_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c92_X net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge922_Q net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net963 clknet_0_net963 VGND VGND VPWR VPWR clknet_1_1__leaf_net963
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_88_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c204_B net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c574_D_N net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c573_B net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c108_Q_N net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input42_A in46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net204 clknet_0_net204 VGND VGND VPWR VPWR clknet_1_1__leaf_net204
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_43_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c329_B1 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c556_D_N net332 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c230_A2 clknet_1_1__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge931_GATE clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c154_B net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s982_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_4_3_0_clk_X clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc244_5 clknet_1_1__leaf_net762 VGND VGND VPWR VPWR net1053 sky130_fd_sc_hd__inv_4
XFILLER_0_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c702_A0 net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c334_RESET_B net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c226_Q net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c392_S1 net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net827 clknet_0_net827 VGND VGND VPWR VPWR clknet_1_0__leaf_net827
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net849 clknet_0_net849 VGND VGND VPWR VPWR clknet_1_0__leaf_net849
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c711_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s955_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c529_A net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc603 net233 net804 clknet_1_1__leaf_net848 net861 VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__or4bb_1
XFILLER_0_32_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc636 net513 clknet_1_1__leaf_net519 net391 net791 net810 net853 VGND VGND VPWR VPWR
+ net521 sky130_fd_sc_hd__mux4_1
Xc614 clknet_1_0__leaf_net488 clknet_1_0__leaf_net498 net493 net785 net862 net865
+ VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__mux4_1
Xc625 net257 clknet_1_0__leaf_net284 clknet_1_1__leaf_net963 net1047 net474 net865
+ VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__mux4_4
Xc669 net323 net1059 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__and2_0
XFILLER_0_99_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge928_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output73_A net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge919_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s937_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net613 clknet_0_net613 VGND VGND VPWR VPWR clknet_1_0__leaf_net613
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c236_A1 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c544_B_N net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c342_SET_B net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge880_B net701 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc411 net307 net308 net312 net909 net302 clknet_2_0__leaf_net310 VGND VGND VPWR VPWR
+ net315 sky130_fd_sc_hd__mux4_2
Xc400 clknet_1_1__leaf_net303 net838 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__nand2_1
Xc422 net314 net325 clknet_1_1__leaf_net318 clknet_1_0__leaf_net303 net326 net226
+ VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__mux4_1
Xc433 net219 net103 net926 net225 net788 VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__o2111ai_4
Xc444 net796 VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__clkbuf_4
Xc455 net361 net355 net359 clknet_1_1__leaf_net313 clknet_1_1__leaf_net347 clknet_1_0__leaf_net963
+ VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__mux4_2
XPHY_EDGE_ROW_8_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc477 net795 VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__inv_4
Xc466 net798 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__buf_8
Xc488 net392 net962 clknet_1_0__leaf_net965 net1037 net989 VGND VGND VPWR VPWR net395
+ sky130_fd_sc_hd__a2111o_2
XFILLER_0_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc499 net402 net290 net1046 net994 net844 VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__o2111a_2
XFILLER_0_99_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c725_Q net597 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge921 clknet_4_6_0_clk net354 net730 VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__dfrtp_1
Xmerge910 net394 clknet_4_11_0_clk net399 VGND VGND VPWR VPWR net994 sky130_fd_sc_hd__dlrtp_1
XFILLER_0_95_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge932 net732 clknet_4_15_0_clk net733 VGND VGND VPWR VPWR net819 net964 sky130_fd_sc_hd__dlrbp_1
XFILLER_0_82_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c337_A0 net16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c503_A2 net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net498 clknet_0_net498 VGND VGND VPWR VPWR clknet_1_0__leaf_net498
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout142_A net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c401_B net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc230 net1041 clknet_1_1__leaf_net965 net39 clknet_1_0__leaf_net159 net151 VGND VGND
+ VPWR VPWR net160 sky130_fd_sc_hd__a2111oi_2
XTAP_TAPCELL_ROW_79_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc252 net748 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__buf_2
Xc241 net962 net36 net163 net151 net1033 net735 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__mux4_1
Xc263 net179 net181 net937 net1054 net1006 net992 VGND VGND VPWR VPWR net1003 sky130_fd_sc_hd__mux4_4
XFILLER_0_20_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc285 net201 net195 net203 net1031 net815 clknet_1_0__leaf_net829 VGND VGND VPWR VPWR
+ net204 sky130_fd_sc_hd__mux4_4
Xc296 net728 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__clkbuf_1
Xc274 net183 net1030 net1039 net815 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__or4bb_1
XANTENNA_c235_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c620_A0 net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge773 net550 clknet_1_1__leaf_net529 net537 net196 net860 VGND VGND VPWR VPWR
+ net645 sky130_fd_sc_hd__a2111oi_2
XFILLER_0_28_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge784 net778 VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__inv_4
Xmerge795 net115 net8 net135 net945 net110 net111 VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_31_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c364_D1 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold19 net875 VGND VGND VPWR VPWR net1073 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c591_S0 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_39_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net284 clknet_0_net284 VGND VGND VPWR VPWR clknet_1_0__leaf_net284
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout145_X net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c132_X net64 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_0_net963_X clknet_0_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_98_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c584_SCD net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge812_A3 net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c292_Q_N net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input35_A in4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net249 clknet_0_net249 VGND VGND VPWR VPWR clknet_1_1__leaf_net249
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_43_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net428 net428 VGND VGND VPWR VPWR clknet_0_net428 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net406 net406 VGND VGND VPWR VPWR clknet_0_net406 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c419_C net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc244_6 clknet_1_1__leaf_net762 VGND VGND VPWR VPWR net1054 sky130_fd_sc_hd__inv_4
XFILLER_0_31_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c690_C net860 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c683_B clknet_1_0__leaf_net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c297_X net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net984 net984 VGND VGND VPWR VPWR clknet_0_net984 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_26_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net828 clknet_0_net828 VGND VGND VPWR VPWR clknet_1_0__leaf_net828
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_35_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net591 clknet_0_net591 VGND VGND VPWR VPWR clknet_1_1__leaf_net591
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net580 clknet_0_net580 VGND VGND VPWR VPWR clknet_1_1__leaf_net580
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_53_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge818_A2 clknet_2_3__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c529_B net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c212_X net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_62_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc604 net805 VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__clkbuf_1
Xc637 clknet_1_1__leaf_net204 net789 net801 net811 net853 clknet_1_1__leaf_net971
+ VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__mux4_2
Xc615 net494 net1021 net972 net864 net865 net866 VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__mux4_1
Xc626 net504 net437 net1021 net967 net1043 net960 VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__mux4_4
XTAP_TAPCELL_ROW_73_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c713_A0 net530 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c151_A2 net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_80_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c607_A1 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output66_A net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net614 clknet_0_net614 VGND VGND VPWR VPWR clknet_1_0__leaf_net614
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c367_D1 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge820_A3 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c541_A net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c146_A2 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc412 clknet_4_4_0_clk net1057 net306 clknet_1_0__leaf_net313 clknet_2_1__leaf_net310
+ VGND VGND VPWR VPWR net317 net316 sky130_fd_sc_hd__sedfxbp_2
Xc401 net911 net67 net302 VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__nand3_1
Xc434 clknet_1_1__leaf_net767 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__buf_8
Xc423 net103 net327 net319 clknet_2_1__leaf_net310 VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__or4bb_4
Xc445 clknet_1_1__leaf_net350 net351 clknet_1_1__leaf_net849 VGND VGND VPWR VPWR net352
+ sky130_fd_sc_hd__nor3b_4
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc456 net319 net361 net85 net348 net787 net803 VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__mux4_1
Xc478 net766 VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__dlymetal6s2s_1
Xc467 net23 net972 VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__nand2_1
Xc489 clknet_1_1__leaf_net349 net973 net1011 clknet_1_0__leaf_net395 net376 VGND VGND
+ VPWR VPWR net396 sky130_fd_sc_hd__a2111oi_0
XFILLER_0_35_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output104_A clknet_1_1__leaf_net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge922 clknet_4_0_0_clk net689 net478 VGND VGND VPWR VPWR net970 sky130_fd_sc_hd__dfrtp_4
Xmerge911 net321 clknet_4_1_0_clk net720 VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__dlrtp_2
Xmerge900 clknet_4_1_0_clk net688 net739 VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__dfstp_4
XFILLER_0_67_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c618_A0 net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c337_A1 net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c601_D_N net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_54_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net455 clknet_0_net455 VGND VGND VPWR VPWR clknet_1_0__leaf_net455
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net488 clknet_0_net488 VGND VGND VPWR VPWR clknet_1_0__leaf_net488
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c227_B net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c589_S0 net463 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_446 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge815_A3 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout135_A net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_s948_SLEEP_B clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c438_A0 net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_79_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc220 net760 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__inv_6
Xc253 clknet_1_1__leaf_net159 clknet_1_0__leaf_net982 net176 net173 VGND VGND VPWR
+ VPWR net177 sky130_fd_sc_hd__or4bb_1
Xc242 net964 VGND VGND VPWR VPWR net976 sky130_fd_sc_hd__clkbuf_1
Xc231 clknet_4_13_0_clk net39 net158 net72 clknet_1_0__leaf_net155 net148 VGND VGND
+ VPWR VPWR net162 net161 sky130_fd_sc_hd__sdfbbn_1
Xc286 net746 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__inv_1
Xc275 net190 net903 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__nand2_4
Xc297 net815 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__clkbuf_2
Xc264 net728 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A1 net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge895_Q net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge796 net173 net903 net1074 net172 net176 net959 VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__mux4_1
Xmerge785 net64 net72 net69 net1030 VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__or4bb_1
XTAP_TAPCELL_ROW_31_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmerge774 clknet_1_1__leaf_net313 net211 net1036 net235 clknet_1_1__leaf_net345 net832
+ VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__mux4_2
XFILLER_0_43_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput1 in0 VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__buf_1
XANTENNA_c591_S1 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_39_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_582 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c162_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c416_Q net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c78_X net16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c615_A1 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c631_A0 net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_2_2__f_net310 clknet_0_net310 VGND VGND VPWR VPWR clknet_2_2__leaf_net310
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge908_Q net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c350_A1 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net965 clknet_0_net965 VGND VGND VPWR VPWR clknet_1_1__leaf_net965
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_0_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c584_SCE clknet_1_0__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s947_Q net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge779_A net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_76_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c170_A1 net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input28_A in33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c361_A0 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net762 clknet_0_net762 VGND VGND VPWR VPWR clknet_1_1__leaf_net762
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c147_C net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge823_A3 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c683_C clknet_1_0__leaf_net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c192_X net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c702_A2 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c669_A net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net963 net963 VGND VGND VPWR VPWR clknet_0_net963 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c108_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net829 clknet_0_net829 VGND VGND VPWR VPWR clknet_1_0__leaf_net829
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_97_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c369_D net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c257_B net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net204 net204 VGND VGND VPWR VPWR clknet_0_net204 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_29_360 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c205_X net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc616 net282 net1047 net437 net301 clknet_1_0__leaf_net847 net852 VGND VGND VPWR VPWR
+ net502 sky130_fd_sc_hd__mux4_4
Xc627 net282 net1033 net783 net970 clknet_1_1__leaf_net868 VGND VGND VPWR VPWR net513
+ sky130_fd_sc_hd__o2111ai_1
Xc605 clknet_1_1__leaf_net458 net812 net154 clknet_1_1__leaf_net848 VGND VGND VPWR
+ VPWR net490 sky130_fd_sc_hd__or4bb_2
XTAP_TAPCELL_ROW_73_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c151_A3 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge873_GATE clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c372_CLK_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c607_A2 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c623_A1 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c236_A3 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge829_A2 net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_net829_A net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c534_A net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c427_A2 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c146_A3 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc402 net305 net1030 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__nand2_2
Xc424 net773 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__buf_6
Xc413 net900 net314 net316 clknet_1_0__leaf_net304 clknet_2_1__leaf_net310 VGND VGND
+ VPWR VPWR net318 sky130_fd_sc_hd__a2111oi_1
Xc435 clknet_4_6_0_clk net336 net335 clknet_1_0__leaf_net337 net330 net1080 VGND VGND
+ VPWR VPWR net342 net341 sky130_fd_sc_hd__sdfbbn_1
Xc446 net114 clknet_1_1__leaf_net249 clknet_1_1__leaf_net350 clknet_2_3__leaf_net310
+ VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__or4bb_4
Xc457 net359 net363 net361 net953 clknet_1_0__leaf_net963 net351 VGND VGND VPWR VPWR
+ net364 sky130_fd_sc_hd__mux4_4
Xc468 net138 clknet_2_3__leaf_net310 net846 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__and3b_4
Xc479 net766 VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_28_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input10_A in17 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge901 clknet_4_11_0_clk net774 net745 VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__dfstp_1
Xmerge912 net717 clknet_4_11_0_clk net405 VGND VGND VPWR VPWR net989 sky130_fd_sc_hd__dlrtp_1
XFILLER_0_82_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge923 clknet_4_2_0_clk net700 net752 VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__dfrtp_2
XANTENNA_c678_SCD net196 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c618_A1 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c634_A0 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c695_S0 net332 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge868_RESET_B net696 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_34_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_62_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c122_B net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout128_A net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c115_A net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c596_C net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input2_A in1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s991_GATE clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c719_A0 net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc210 net2 net133 net132 net115 net128 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__a2111o_1
XTAP_TAPCELL_ROW_79_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc221 net760 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input58_A in60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc254 net135 net176 VGND VGND VPWR VPWR net1009 sky130_fd_sc_hd__nor2_1
Xc232 net919 net1029 net162 net1048 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__or4bb_2
Xc243 net999 net837 VGND VGND VPWR VPWR net1005 sky130_fd_sc_hd__nand2_1
Xc276 net183 net189 net1039 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__nor3b_1
Xc265 net728 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__inv_2
Xc287 net921 net925 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__nand2_1
Xc298 clknet_1_1__leaf_net767 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_5_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A2 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input13_X net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c629_A0 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c348_A1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge786 net109 net116 net924 net128 net8 VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__a2111oi_1
XTAP_TAPCELL_ROW_31_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge775 clknet_1_1__leaf_net428 net233 clknet_1_0__leaf_net963 net469 net460 net468
+ VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__mux4_4
Xmerge797 clknet_4_4_0_clk net308 net306 net415 clknet_1_0__leaf_net204 VGND VGND
+ VPWR VPWR net669 sky130_fd_sc_hd__sdfstp_1
XFILLER_0_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c364_B1 net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_2_3__f_net310_X clknet_2_3__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1__f_net1000_X clknet_1_1__leaf_net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput2 in1 VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_67_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net275 clknet_0_net275 VGND VGND VPWR VPWR clknet_1_0__leaf_net275
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c232_A net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge826_A3 net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_1__f_net963_A clknet_0_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c721_A1 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c615_A2 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net988 clknet_0_net988 VGND VGND VPWR VPWR clknet_1_1__leaf_net988
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_36_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c287_B net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c107_S1 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s985_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout150_X net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c732_A0 net332 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c155_A_N net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c83_SCD net16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c90_X net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c626_A1 net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c345_A2 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c361_A1 net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s967_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_8_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput60 in7 VGND VGND VPWR VPWR net956 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c202_B net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c493_SCE net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c727_A0 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input40_A in44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c612_A3 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_net1000 clknet_0_net1000 VGND VGND VPWR VPWR clknet_1_1__leaf_net1000
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_s949_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c698_S0 clknet_2_0__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c637_A0 clknet_1_1__leaf_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_hold29_A net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net560 clknet_0_net560 VGND VGND VPWR VPWR clknet_1_1__leaf_net560
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_merge803_S0 net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net593 clknet_0_net593 VGND VGND VPWR VPWR clknet_1_1__leaf_net593
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c547_A0 clknet_1_0__leaf_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net249 net249 VGND VGND VPWR VPWR clknet_0_net249 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_71_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc606 net797 VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__inv_4
Xc628 net392 net1041 net1040 clknet_1_0__leaf_net965 clknet_1_0__leaf_net971 clknet_1_1__leaf_net868
+ VGND VGND VPWR VPWR net968 sky130_fd_sc_hd__mux4_1
Xc617 net416 net1016 clknet_1_0__leaf_net397 clknet_1_1__leaf_net963 net1021 net856
+ VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_73_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c713_A2 net526 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_84_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c98_A net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c607_A3 clknet_1_1__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input43_X net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c367_B1 net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c696_SCE clknet_1_0__leaf_net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c155_Y net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c534_B net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge769_C_N net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc403 net736 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__inv_4
Xc414 clknet_4_1_0_clk net1087 clknet_1_0__leaf_net318 clknet_2_0__leaf_net310 net1032
+ net706 VGND VGND VPWR VPWR net320 net319 sky130_fd_sc_hd__sdfbbp_1
Xc436 net332 net341 clknet_1_1__leaf_net337 clknet_2_1__leaf_net310 net1032 net838
+ VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__mux4_1
Xc425 net896 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__clkbuf_1
Xc458 net236 net361 net363 net355 net319 net987 VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__mux4_4
Xc447 net85 net73 net909 clknet_1_0__leaf_net963 net351 VGND VGND VPWR VPWR net353
+ sky130_fd_sc_hd__a2111o_4
Xc469 net216 net1037 VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__nor2b_4
XANTENNA_c306_S0 net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge902 clknet_4_9_0_clk net653 net753 VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__dfstp_2
Xmerge913 clknet_4_9_0_clk net646 net682 VGND VGND VPWR VPWR net796 net795 sky130_fd_sc_hd__edfxbp_1
Xmerge924 clknet_4_8_0_clk net705 net763 VGND VGND VPWR VPWR net809 net808 sky130_fd_sc_hd__dfsbp_1
XANTENNA_c618_A2 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net591 net591 VGND VGND VPWR VPWR clknet_0_net591 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net580 net580 VGND VGND VPWR VPWR clknet_0_net580 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c484_D1 net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_93_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output71_A net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_2_2__f_net310_X clknet_2_2__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_0__f_net963_A clknet_0_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_62_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c263_A2 net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_53_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c75_C net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc211 net748 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_79_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc200 net75 net18 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__and2_1
XFILLER_0_20_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc233 net40 clknet_1_0__leaf_net155 net162 net39 net157 VGND VGND VPWR VPWR net164
+ sky130_fd_sc_hd__a2111o_1
Xc222 net27 net833 net113 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__nor3_4
XPHY_EDGE_ROW_68_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc255 net1049 net61 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__nand2b_4
Xc266 net910 net71 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__nor2b_1
Xc288 net203 net190 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__nand2_2
Xc277 net768 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__inv_8
Xc299 net190 net196 net1040 net216 net1045 net207 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__mux4_1
XFILLER_0_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c620_A3 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c629_A1 net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c348_A2 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge765 net163 net5 net57 net176 VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__or4bb_1
Xmerge776 net71 net70 net73 net69 VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__or4bb_1
Xmerge787 net235 net237 net84 net238 net1031 VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__o2111ai_1
Xmerge798 net13 net12 net19 net5 net8 net819 VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__mux4_4
XFILLER_0_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 in10 VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_67_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net243 clknet_0_net243 VGND VGND VPWR VPWR clknet_1_0__leaf_net243
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c232_B net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c225_A net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout140_A net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c594_A net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c578_SCD net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c295_Q_N net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c350_A3 net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c182_B net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_4_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c402_Y net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c170_A3 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c626_A2 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c345_A3 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c361_A2 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput50 in53 VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__buf_1
Xinput61 in8 VGND VGND VPWR VPWR net957 sky130_fd_sc_hd__buf_2
XFILLER_0_71_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c557_A net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s952_Q net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge791_B net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net965 net965 VGND VGND VPWR VPWR clknet_0_net965 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c451_C_N net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input33_A in38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c487_D1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge774_A1 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge799_D1 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_13_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net583 clknet_0_net583 VGND VGND VPWR VPWR clknet_1_1__leaf_net583
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c547_A1 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc607 clknet_1_0__leaf_net482 net73 net1043 clknet_1_1__leaf_net963 net862 net864
+ VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__mux4_1
Xc618 net282 net1021 net1042 net843 net856 clknet_1_1__leaf_net867 VGND VGND VPWR
+ VPWR net504 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_73_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc629 net121 net392 net1015 clknet_1_1__leaf_net397 net783 clknet_1_1__leaf_net868
+ VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__mux4_4
XFILLER_0_99_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_84_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_40_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c98_B net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_51_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net762 net762 VGND VGND VPWR VPWR clknet_0_net762 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge849_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_4_12_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c623_A3 net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_2_1__f_net310_X clknet_2_1__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c412_DE net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net628 clknet_0_net628 VGND VGND VPWR VPWR clknet_1_0__leaf_net628
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge814_S0 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c308_X net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc426 net813 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__clkbuf_2
Xc415 net192 clknet_1_0__leaf_net318 net76 clknet_1_0__leaf_net313 clknet_1_0__leaf_net309
+ clknet_2_1__leaf_net310 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__mux4_1
Xc437 clknet_1_0__leaf_net329 net342 net323 clknet_1_1__leaf_net318 net707 clknet_1_0__leaf_net848
+ VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__mux4_4
Xc404 net76 net1032 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__nand2_1
XFILLER_0_40_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc459 net1038 net360 net351 clknet_1_1__leaf_net350 net806 net850 VGND VGND VPWR VPWR
+ net366 sky130_fd_sc_hd__mux4_1
Xc448 clknet_1_0__leaf_net333 net227 net1036 net85 VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__or4bb_2
XFILLER_0_99_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c306_S1 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge903 net708 clknet_4_3_0_clk net496 VGND VGND VPWR VPWR net786 net785 sky130_fd_sc_hd__dlrbn_1
XFILLER_0_67_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge914 clknet_4_2_0_clk net660 net750 VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__edfxtp_1
Xmerge925 clknet_4_10_0_clk net729 net515 VGND VGND VPWR VPWR net811 net810 sky130_fd_sc_hd__dfsbp_1
XANTENNA_c231_SET_B net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c618_A3 net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c484_C1 net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output64_A net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net458 clknet_0_net458 VGND VGND VPWR VPWR clknet_1_0__leaf_net458
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge809_S0 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net981 clknet_0_net981 VGND VGND VPWR VPWR clknet_1_0__leaf_net981
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_37_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c735_A1 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge800_D_N net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc201 net814 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_4
Xc212 net813 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__buf_6
XANTENNA_c421_A_N net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc245 net903 net1033 net726 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__and3b_1
Xc234 clknet_1_0__leaf_net164 net158 net162 clknet_1_0__leaf_net155 net145 VGND VGND
+ VPWR VPWR net165 sky130_fd_sc_hd__a2111o_2
XFILLER_0_32_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c751_A0 net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc256 net174 net176 VGND VGND VPWR VPWR net986 sky130_fd_sc_hd__or2_1
Xc278 net185 net1039 net64 net195 net1030 net815 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__mux4_2
Xc267 net183 net906 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__and2b_1
Xc289 net65 net74 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__nor2_4
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c629_A2 net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c348_A3 clknet_1_1__leaf_net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge766 net897 VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__buf_2
Xmerge788 net330 net414 clknet_1_0__leaf_net482 net1011 net812 net856 VGND VGND VPWR
+ VPWR net660 sky130_fd_sc_hd__mux4_2
XFILLER_0_43_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge777 net324 net926 clknet_1_1__leaf_net318 net707 net1066 VGND VGND VPWR VPWR
+ net649 sky130_fd_sc_hd__a2111o_4
Xmerge799 net112 net903 net111 net117 net120 VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__a2111o_1
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput4 in11 VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout133_A net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c225_B net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_0_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_5_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c594_B net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c502_SCE net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net968 clknet_0_net968 VGND VGND VPWR VPWR clknet_1_1__leaf_net968
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_87_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c370_CLK_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c301_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_87_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout136_X net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c716_A3 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_87_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c414_Q net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c76_X net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c626_A3 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c492_C1 net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge788_A0 net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_49_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c505_S0 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput40 in44 VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__buf_1
Xinput51 in54 VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__clkbuf_2
Xinput62 in9 VGND VGND VPWR VPWR net958 sky130_fd_sc_hd__buf_4
XFILLER_0_12_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_s945_Q net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net988 net988 VGND VGND VPWR VPWR clknet_0_net988 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_10_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_2_0__f_net310_X clknet_2_0__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input26_A in31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c487_C1 net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge774_A2 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c637_A2 net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c563_A1 net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c200_A net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc608 clknet_4_3_0_clk net480 clknet_1_0__leaf_net963 net142 net377 net1069 VGND VGND
+ VPWR VPWR net494 net493 sky130_fd_sc_hd__sdfbbn_1
Xc619 net967 net1041 net966 net376 clknet_1_1__leaf_net799 net865 VGND VGND VPWR VPWR
+ net505 sky130_fd_sc_hd__mux4_1
XFILLER_0_69_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c674_B net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c190_X net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c310_D_N net101 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c754_A0 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c473_A1 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c608_RESET_B clknet_1_0__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input29_X net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c498_D1 clknet_1_1__leaf_net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c725_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c368_D_N net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge814_S1 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge830_S0 net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c724_A3 net530 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc405 net909 clknet_1_1__leaf_net303 net1032 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__nor3_4
Xc416 clknet_4_4_0_clk net188 net316 clknet_2_0__leaf_net310 net1069 VGND VGND VPWR
+ VPWR net323 net322 sky130_fd_sc_hd__sedfxbp_1
Xc427 net213 net85 net223 net330 clknet_2_1__leaf_net310 VGND VGND VPWR VPWR net333
+ sky130_fd_sc_hd__a2111oi_2
Xc438 net342 clknet_1_1__leaf_net340 net1022 net806 net838 clknet_1_0__leaf_net848
+ VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__mux4_4
Xc449 clknet_4_9_0_clk net351 clknet_1_1__leaf_net347 clknet_1_0__leaf_net963 clknet_1_1__leaf_net350
+ VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__sedfxtp_4
XANTENNA_c740_A2 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c572_X net969 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c749_A0 clknet_2_2__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge904 net338 clknet_4_6_0_clk net356 VGND VGND VPWR VPWR net788 net787 sky130_fd_sc_hd__dlrbn_1
Xmerge926 clknet_4_3_0_clk net777 net486 VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__dfstp_2
Xmerge915 clknet_4_9_0_clk net680 net654 VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__sdlclkp_1
XFILLER_0_67_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c707_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net560 net560 VGND VGND VPWR VPWR clknet_0_net560 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net593 net593 VGND VGND VPWR VPWR clknet_0_net593 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c634_A3 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c394_A0 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge809_S1 net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge825_S0 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c560_A2 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c198_A net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net971 clknet_0_net971 VGND VGND VPWR VPWR clknet_1_0__leaf_net971
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net982 clknet_0_net982 VGND VGND VPWR VPWR clknet_1_0__leaf_net982
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c418_X net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c585_C1 net1026 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_61_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c735_A2 net463 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc202 net20 net900 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_79_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc235 clknet_4_15_0_clk net162 clknet_1_0__leaf_net159 net135 net734 VGND VGND VPWR
+ VPWR net962 sky130_fd_sc_hd__sdfrtp_4
Xc213 clknet_4_12_0_clk net136 net1089 net138 net16 net131 VGND VGND VPWR VPWR net144
+ net143 sky130_fd_sc_hd__sdfbbp_1
Xc224 clknet_1_0__leaf_net139 net105 net153 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__nor3_4
XFILLER_0_32_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_92_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc246 net50 net1075 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__nand2_1
Xc257 net176 net1002 net1013 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__nor3_1
XFILLER_0_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c751_A1 net292 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc268 net74 net185 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__nor2b_1
Xc279 clknet_4_5_0_clk net195 net194 net1030 net189 net182 VGND VGND VPWR VPWR net198
+ net197 sky130_fd_sc_hd__sdfbbp_1
XFILLER_0_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c333_S0 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge778 net910 net36 net925 clknet_1_1__leaf_net139 net819 VGND VGND VPWR VPWR net650
+ sky130_fd_sc_hd__a2111oi_0
Xmerge767 net90 net937 net238 net727 VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__or4bb_1
Xmerge789 net111 net113 clknet_1_1__leaf_net107 net251 net131 VGND VGND VPWR VPWR
+ net661 sky130_fd_sc_hd__a2111o_2
XFILLER_0_24_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c554_C_N net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput5 in12 VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net245 clknet_0_net245 VGND VGND VPWR VPWR clknet_1_0__leaf_net245
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_52_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c225_C net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c571_A1 clknet_1_0__leaf_net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s988_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c270_X net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c707_RESET_B net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge785_D_N net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c66_A net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input56_A in59 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge777_A2 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input11_X net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c672_A0 net427 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge797_SET_B clknet_1_0__leaf_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge822_S1 net16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c168_B net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c701_S0 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_76_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c757_A0 net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c611_S0 clknet_1_1__leaf_net848 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_41_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input59_X net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c295_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_merge788_A1 net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net799 clknet_0_net799 VGND VGND VPWR VPWR clknet_1_1__leaf_net799
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput30 in35 VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__buf_2
Xinput41 in45 VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__clkbuf_4
Xinput52 in55 VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__buf_1
XFILLER_0_12_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge920_CLK_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c415_S1 clknet_2_1__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge889_D net740 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c727_A3 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c150_S1 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net1003 clknet_0_net1003 VGND VGND VPWR VPWR clknet_1_1__leaf_net1003
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_input19_A in25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_18_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c547_A3 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c138_C net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge866_GATE clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c200_B net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc609 net491 net1038 net493 net809 net861 net863 VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__mux4_1
XFILLER_0_69_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s942_Q_N net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_84_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c738_A2 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c457_A3 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c754_A1 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c473_A2 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_59_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c498_C1 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c143_A net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c310_A net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net1000 clknet_0_net1000 VGND VGND VPWR VPWR clknet_1_0__leaf_net1000
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_20_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c408_A net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc428 net782 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__inv_2
Xc417 clknet_4_4_0_clk clknet_1_0__leaf_net313 net316 clknet_2_1__leaf_net310 net1069
+ VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__sedfxtp_2
Xc406 clknet_1_1__leaf_net304 clknet_1_1__leaf_net303 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__or2b_1
XFILLER_0_13_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc439 net300 net330 net341 net223 clknet_1_1__leaf_net345 clknet_1_0__leaf_net848
+ VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_28_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c749_A1 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge927 clknet_4_3_0_clk net731 net690 VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__dfstp_1
Xmerge905 net754 clknet_4_10_0_clk net410 VGND VGND VPWR VPWR net789 net975 sky130_fd_sc_hd__dlrbp_1
Xmerge916 clknet_4_8_0_clk net389 net632 VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__sdlclkp_2
XFILLER_0_55_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c96_A net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c484_A1 net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net583 net583 VGND VGND VPWR VPWR clknet_0_net583 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input41_X net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge796_A1 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c394_A1 clknet_1_1__leaf_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c560_A3 net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge825_S1 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_19_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc203 net116 net132 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__or2_1
Xc236 net156 net925 net161 net962 net735 net819 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__mux4_1
Xc214 net755 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_79_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc225 net113 net106 net31 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_92_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc247 net49 net1006 net157 VGND VGND VPWR VPWR net990 sky130_fd_sc_hd__nand3_1
XANTENNA_c751_A2 net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc269 net728 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__clkbuf_2
Xc258 net772 VGND VGND VPWR VPWR net997 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_69_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c333_S1 net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmerge768 net952 net12 net30 net910 VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__or4bb_1
XFILLER_0_83_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge779 net970 VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_24_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput6 in13 VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c113_B net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c431_D_N clknet_2_1__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c299_A1 net196 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s968_Q net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c746_A2 net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input49_A in52 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge793_A2 net937 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c429_DE net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c463_C_N net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c285_A3 net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_87_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c708_SCD net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c195_A3 net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net767 clknet_0_net767 VGND VGND VPWR VPWR clknet_1_1__leaf_net767
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_68_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput31 in36 VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput20 in26 VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__buf_1
XFILLER_0_71_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput53 in56 VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__buf_1
Xinput42 in46 VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__buf_1
XFILLER_0_12_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c340_A net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout141_X net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net968 net968 VGND VGND VPWR VPWR clknet_0_net968 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c593_B1 clknet_1_0__leaf_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c675_C_N net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c622_S0 net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c81_X net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net564 clknet_0_net564 VGND VGND VPWR VPWR clknet_1_1__leaf_net564
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_84_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c738_A3 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s950_Q net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_35_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_23_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c473_A3 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c704_SET_B net462 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c617_S0 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input31_A in36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output118_A net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_530 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net350 clknet_0_net350 VGND VGND VPWR VPWR clknet_1_1__leaf_net350
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c310_B net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc418 net802 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__clkbuf_2
Xc407 net307 net300 net308 clknet_2_0__leaf_net310 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__or4bb_4
XFILLER_0_13_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc429 clknet_4_6_0_clk net223 net300 net325 net213 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__sedfxtp_4
XFILLER_0_99_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge928 clknet_4_14_0_clk net738 net711 VGND VGND VPWR VPWR net1001 sky130_fd_sc_hd__dfstp_2
Xmerge917 clknet_4_3_0_clk net672 net647 VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__sdlclkp_4
Xmerge906 net681 clknet_4_11_0_clk net396 VGND VGND VPWR VPWR net790 net993 sky130_fd_sc_hd__dlrbp_1
XFILLER_0_35_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c484_A2 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net406 clknet_0_net406 VGND VGND VPWR VPWR clknet_1_0__leaf_net406
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net428 clknet_0_net428 VGND VGND VPWR VPWR clknet_1_0__leaf_net428
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c394_A2 net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net984 clknet_0_net984 VGND VGND VPWR VPWR clknet_1_0__leaf_net984
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_49_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c139_X net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c306_X net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc204 net917 net1043 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__nand2_1
Xc215 net141 net2 net143 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__nand3b_2
Xc226 clknet_4_15_0_clk net106 net39 net156 net148 net824 VGND VGND VPWR VPWR net999
+ net157 sky130_fd_sc_hd__sdfbbn_2
XTAP_TAPCELL_ROW_79_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c80_C_N net16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc248 net1004 net759 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__and2b_1
Xc237 clknet_1_1__leaf_net965 clknet_1_0__leaf_net164 net161 net734 net836 VGND VGND
+ VPWR VPWR net167 sky130_fd_sc_hd__o2111a_2
Xc259 net964 VGND VGND VPWR VPWR net992 sky130_fd_sc_hd__buf_6
XFILLER_0_13_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c614_S1 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c495_A1 net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge769 net186 net1022 net300 net1011 VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__or4bb_1
XFILLER_0_36_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc760 net578 net376 clknet_1_1__leaf_net204 net816 net865 net893 VGND VGND VPWR VPWR
+ net632 sky130_fd_sc_hd__mux4_4
Xinput7 in14 VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c106_B net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c571_A3 clknet_1_0__leaf_net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c299_A2 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c540_12_A net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c746_A3 net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c450_S0 clknet_1_0__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c625_S0 net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_1_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output100_A net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge793_A3 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc590 clknet_4_3_0_clk clknet_1_0__leaf_net350 clknet_1_1__leaf_net471 clknet_1_1__leaf_net473
+ net1069 VGND VGND VPWR VPWR net475 net474 sky130_fd_sc_hd__sdfsbp_2
XANTENNA_c414_SCD clknet_2_0__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_35_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c493_RESET_B clknet_1_0__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_65_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c63_S0 net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c370_Q_N net292 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_74_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c492_A2 net391 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input61_A in8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge788_A3 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_92_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c142_C_N net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput21 in27 VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_12_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput10 in17 VGND VGND VPWR VPWR net906 sky130_fd_sc_hd__clkbuf_2
Xinput54 in57 VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput32 in37 VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__buf_1
Xinput43 in47 VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__buf_2
XFILLER_0_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c173_B net101 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c104_Q_N net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c712_S1 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout134_X net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c605_B net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c124_C_N net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c313_D_N net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_46_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c622_S1 net858 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_196 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge799_A2 net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net532 clknet_0_net532 VGND VGND VPWR VPWR clknet_1_1__leaf_net532
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net598 clknet_0_net598 VGND VGND VPWR VPWR clknet_1_1__leaf_net598
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c608_SCD net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c354_C_N net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c562_C net858 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c106_C_N net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c723_S0 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c588_A1 clknet_2_0__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c336_X net257 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net799 net799 VGND VGND VPWR VPWR clknet_0_net799 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_50_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_95_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c617_S1 net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input24_A in3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c336_C_N net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net340 clknet_0_net340 VGND VGND VPWR VPWR clknet_1_1__leaf_net340
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net395 clknet_0_net395 VGND VGND VPWR VPWR clknet_1_1__leaf_net395
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net384 clknet_0_net384 VGND VGND VPWR VPWR clknet_1_1__leaf_net384
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c262_S1 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s951_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c136_B net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc408 net782 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__inv_12
Xc419 net324 net322 net1065 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__and3b_1
XANTENNA_c718_S0 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c665_A net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmerge907 net743 clknet_4_8_0_clk net765 VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__dlrtn_1
Xmerge918 clknet_4_3_0_clk net649 net757 VGND VGND VPWR VPWR net802 net801 sky130_fd_sc_hd__dfrbp_1
XFILLER_0_67_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge929 net191 clknet_4_7_0_clk net758 VGND VGND VPWR VPWR net815 net814 sky130_fd_sc_hd__dlrbn_1
XFILLER_0_36_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge924_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c347_S1 clknet_1_0__leaf_net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge915_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s933_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c394_A3 net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_10_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net963 clknet_0_net963 VGND VGND VPWR VPWR clknet_1_0__leaf_net963
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_77_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c201_X net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc216 net145 net146 net132 net140 net109 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__o2111ai_1
Xc227 net145 net1040 net833 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__and3b_2
XTAP_TAPCELL_ROW_79_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xc205 net790 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_92_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc238 net1050 net161 net939 net151 net748 net836 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__mux4_2
Xc249 net1074 net977 net1094 net836 net837 VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__a2111o_1
XFILLER_0_40_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c531_B_N net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s958_GATE_N clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c630_S1 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc750 net377 net489 net596 net870 clknet_1_1__leaf_net888 net890 VGND VGND VPWR VPWR
+ net622 sky130_fd_sc_hd__mux4_1
Xc761 clknet_1_1__leaf_net547 net377 clknet_1_0__leaf_net799 net805 net890 net895
+ VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__mux4_2
Xinput8 in15 VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__buf_1
Xclkbuf_1_0__f_net204 clknet_0_net204 VGND VGND VPWR VPWR clknet_1_0__leaf_net204
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c468_B clknet_2_3__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c299_A3 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c625_S1 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_14_0_clk_X clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c672_A3 net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc591 clknet_1_1__leaf_net981 clknet_1_0__leaf_net473 net475 clknet_1_1__leaf_net470
+ net1045 net792 VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__mux4_1
Xc580 net227 net461 VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__nor2b_1
XANTENNA_c414_SCE net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s941_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput120 net1016 VGND VGND VPWR VPWR out9 sky130_fd_sc_hd__buf_2
XFILLER_0_69_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c213_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c757_A3 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c461_S0 net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_98_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input54_A in57 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput22 in28 VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_83_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput11 in18 VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__buf_2
Xinput55 in58 VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__buf_1
Xinput33 in38 VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput44 in48 VGND VGND VPWR VPWR net940 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c281_S0 net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c593_A2 net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge918_Q_N net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c104_CLK_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input57_X net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c608_SCE net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c588_A2 net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_2_0_clk_X clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s936_Q net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net767 net767 VGND VGND VPWR VPWR clknet_0_net767 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_90_443 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input17_A in23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output85_A clknet_1_0__leaf_net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net352 clknet_0_net352 VGND VGND VPWR VPWR clknet_1_1__leaf_net352
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net1003 clknet_0_net1003 VGND VGND VPWR VPWR clknet_1_0__leaf_net1003
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_25_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc409 net185 net312 clknet_2_1__leaf_net310 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__nand3b_4
Xmax_cap130 net442 VGND VGND VPWR VPWR net1026 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_40_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c286_Y net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input9_A in16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c734_S0 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c599_A1 clknet_2_3__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c446_X net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge919 clknet_4_9_0_clk net484 net715 VGND VGND VPWR VPWR net804 net803 sky130_fd_sc_hd__dfrbp_1
Xmerge908 net776 clknet_4_6_0_clk net719 VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__dlrtn_4
XFILLER_0_36_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net564 net564 VGND VGND VPWR VPWR clknet_0_net564 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_50_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge851_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_81_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc217 net956 net145 net131 net142 net143 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__o2111ai_4
Xc206 net128 net75 net134 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_79_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc239 clknet_1_0__leaf_net168 clknet_1_1__leaf_net164 net161 net748 net824 VGND VGND
+ VPWR VPWR net169 sky130_fd_sc_hd__a2111o_2
Xc228 net1052 net151 net39 net157 net1094 net832 VGND VGND VPWR VPWR net965 sky130_fd_sc_hd__mux4_1
XFILLER_0_13_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net350 net350 VGND VGND VPWR VPWR clknet_0_net350 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc740 net527 clknet_1_0__leaf_net470 net865 net878 net886 clknet_1_0__leaf_net887
+ VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__mux4_2
Xc762 net489 net596 clknet_1_0__leaf_net799 net869 net891 net895 VGND VGND VPWR VPWR
+ net634 sky130_fd_sc_hd__mux4_2
Xc751 net377 net292 net474 clknet_1_0__leaf_net847 net870 net886 VGND VGND VPWR VPWR
+ net623 sky130_fd_sc_hd__mux4_4
XANTENNA_clkbuf_4_10_0_clk_X clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput9 in16 VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__buf_2
Xclkbuf_1_0__f_net249 clknet_0_net249 VGND VGND VPWR VPWR clknet_1_0__leaf_net249
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_86_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_5 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c468_C net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c407_D_N clknet_2_0__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c435_Q net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc570 net447 net1045 net453 net445 net756 clknet_1_0__leaf_net848 VGND VGND VPWR VPWR
+ net455 sky130_fd_sc_hd__mux4_2
Xc581 clknet_4_3_0_clk net230 net464 net461 clknet_1_0__leaf_net963 VGND VGND VPWR
+ VPWR net465 sky130_fd_sc_hd__sdfrtp_1
Xc592 clknet_1_0__leaf_net471 net466 net475 clknet_1_1__leaf_net455 clknet_1_1__leaf_net473
+ net465 VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__mux4_2
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c448_C_N net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput110 net1006 VGND VGND VPWR VPWR out52 sky130_fd_sc_hd__buf_2
XFILLER_0_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net591 clknet_0_net591 VGND VGND VPWR VPWR clknet_1_0__leaf_net591
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net580 clknet_0_net580 VGND VGND VPWR VPWR clknet_1_0__leaf_net580
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c71_C net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input47_A in50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput12 in19 VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_12_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput23 in29 VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__clkbuf_2
Xinput45 in49 VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__clkbuf_1
Xinput34 in39 VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__clkbuf_1
Xinput56 in59 VGND VGND VPWR VPWR net952 sky130_fd_sc_hd__buf_1
XFILLER_0_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_1__f_net204_X clknet_1_1__leaf_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c159_B net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c131_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c737_S0 net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c67_Y net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c321_A0 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net545 clknet_0_net545 VGND VGND VPWR VPWR clknet_1_1__leaf_net545
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_17_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c226_CLK_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c276_B net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c171_A net64 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c443_B net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c603_A net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c343_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output78_A net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net397 clknet_0_net397 VGND VGND VPWR VPWR clknet_1_1__leaf_net397
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net375 clknet_0_net375 VGND VGND VPWR VPWR clknet_1_1__leaf_net375
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c334_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap131 net1100 VGND VGND VPWR VPWR net1027 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge810_A1 net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c599_A2 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c181_Y net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge909 net260 clknet_4_12_0_clk net709 VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__dlrtn_2
XFILLER_0_95_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge780_A net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_net532 net532 VGND VGND VPWR VPWR clknet_0_net532 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net598 net598 VGND VGND VPWR VPWR clknet_0_net598 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_2_1__f_net310 clknet_0_net310 VGND VGND VPWR VPWR clknet_2_1__leaf_net310
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_81_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c570_S0 net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c141_B net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net965 clknet_0_net965 VGND VGND VPWR VPWR clknet_1_0__leaf_net965
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout147_A net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_61_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge805_A1 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc218 net710 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc229 net1051 net947 net158 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__or3b_1
XFILLER_0_13_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c396_Y net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c670_A net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_101_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net340 net340 VGND VGND VPWR VPWR clknet_0_net340 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c578_RESET_B clknet_2_0__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net384 net384 VGND VGND VPWR VPWR clknet_0_net384 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net395 net395 VGND VGND VPWR VPWR clknet_0_net395 sky130_fd_sc_hd__clkbuf_16
Xc730 net380 net73 clknet_1_1__leaf_net598 net600 net474 net463 VGND VGND VPWR VPWR
+ net602 sky130_fd_sc_hd__mux4_2
XANTENNA_merge792_S0 net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc741 net462 net953 net812 net882 clknet_1_0__leaf_net887 clknet_1_0__leaf_net888
+ VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__mux4_4
Xc752 net293 clknet_1_1__leaf_net623 net121 net853 clknet_1_0__leaf_net867 clknet_1_1__leaf_net888
+ VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__mux4_4
Xc763 net634 clknet_1_0__leaf_net628 net756 net805 net852 net891 VGND VGND VPWR VPWR
+ net635 sky130_fd_sc_hd__mux4_2
XFILLER_0_59_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c338_D1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c417_SCD clknet_2_1__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net762 clknet_0_net762 VGND VGND VPWR VPWR clknet_1_0__leaf_net762
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c144_Y net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge816_A0 clknet_2_1__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c311_Y net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c77_S1 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c475_S0 net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc571 net435 clknet_1_0__leaf_net981 net453 clknet_1_0__leaf_net455 net756 net858
+ VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__mux4_4
Xc582 net453 net240 clknet_1_0__leaf_net428 VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__nor3_4
Xc560 net435 net445 net1026 net437 net441 net434 VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__mux4_1
Xc593 clknet_1_0__leaf_net473 net474 clknet_1_0__leaf_net204 clknet_1_1__leaf_net470
+ net1084 VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__a2111o_4
XPHY_EDGE_ROW_16_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net204_X clknet_1_0__leaf_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c79_B_N net915 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_25_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput100 net996 VGND VGND VPWR VPWR out43 sky130_fd_sc_hd__buf_2
Xoutput111 net1018 VGND VGND VPWR VPWR out54 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c573_D_N net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_34_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c480_C net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c540_10_A net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c421_X net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_98_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge929_GATE_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c316_D_N net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput13 in2 VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__clkbuf_4
Xinput24 in3 VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__buf_1
Xinput46 in5 VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__buf_1
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput35 in4 VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__clkbuf_2
Xinput57 in6 VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__buf_4
XFILLER_0_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c160_A_N net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s981_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge813_A1 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_97_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s972_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c602_A0 net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c321_A1 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_531 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c346_D1 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c331_A net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s954_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge808_A1 net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout132_X net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge824_A0 net101 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c109_A3 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c85_S1 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c748_S0 clknet_1_1__leaf_net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c483_S0 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge927_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge795_S0 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input62_X net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge902_Q net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge918_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s936_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c608_SET_B net1069 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge810_A2 clknet_1_0__leaf_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c599_A3 net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge819_A0 net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s941_Q net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c714_D1 net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c433_C1 net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c152_A0 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input22_A in28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c360_Q net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output109_A net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_526 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net988 clknet_0_net988 VGND VGND VPWR VPWR clknet_1_0__leaf_net988
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_57_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c134_B net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc208 net755 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__inv_1
XFILLER_0_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc219 net149 net956 net130 net148 net832 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__a2111oi_1
XANTENNA_c435_SCE net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net352 net352 VGND VGND VPWR VPWR clknet_0_net352 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc720 clknet_1_1__leaf_net560 net542 net475 net1035 net575 net879 VGND VGND VPWR VPWR
+ net591 sky130_fd_sc_hd__mux4_4
Xc731 net1048 net372 net865 net866 net873 VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__o2111ai_1
XANTENNA_merge792_S1 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc742 clknet_1_1__leaf_net455 net600 clknet_1_0__leaf_net613 net597 net879 net885
+ VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__mux4_4
Xc764 net624 net635 clknet_2_2__leaf_net310 clknet_1_0__leaf_net867 net877 clknet_1_1__leaf_net888
+ VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__mux4_4
Xc753 clknet_1_1__leaf_net488 net597 net292 net817 net870 VGND VGND VPWR VPWR net625
+ sky130_fd_sc_hd__a2111o_2
XFILLER_0_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c338_C1 net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_30_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c417_SCE net1069 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c504_A1 net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c756_S0 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c475_S1 clknet_1_0__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c344_SCD net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc550 net784 VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__clkbuf_1
Xc572 net434 net851 VGND VGND VPWR VPWR net969 sky130_fd_sc_hd__or2_1
Xc561 net780 VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__buf_16
Xc583 net461 net230 net463 net465 VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__or4bb_4
Xc594 net187 net233 clknet_1_1__leaf_net799 VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__or3_2
XFILLER_0_78_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput101 net997 VGND VGND VPWR VPWR out44 sky130_fd_sc_hd__buf_2
XFILLER_0_88_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput112 net1008 VGND VGND VPWR VPWR out56 sky130_fd_sc_hd__buf_2
XFILLER_0_10_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c578_D net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_610 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net560 clknet_0_net560 VGND VGND VPWR VPWR clknet_1_0__leaf_net560
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net593 clknet_0_net593 VGND VGND VPWR VPWR clknet_1_0__leaf_net593
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_98_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c301_SET_B net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge798_S0 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput14 in20 VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__clkbuf_4
Xinput36 in40 VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__buf_1
Xinput25 in30 VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__buf_1
Xinput58 in60 VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__clkbuf_1
Xinput47 in50 VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__clkbuf_2
XANTENNA_merge932_Q net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_48_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge890 clknet_4_7_0_clk net220 net659 VGND VGND VPWR VPWR net770 net769 sky130_fd_sc_hd__dfrbp_1
XFILLER_0_43_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_226 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge813_A2 net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c583_B net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c469_Y net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input52_A in55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c70_D1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge890_CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c602_A1 net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net547 clknet_0_net547 VGND VGND VPWR VPWR clknet_1_1__leaf_net547
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_44_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c284_C_N net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge881_CLK clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c171_C net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_7_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge808_A2 net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge824_A1 net915 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c217_Y net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout125_X net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c703_A0 net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c764_S0 net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c579_X net463 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c422_A1 net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c485_Q_N net391 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c65_D1 net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c393_S1 net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net333 clknet_0_net333 VGND VGND VPWR VPWR clknet_1_1__leaf_net333
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net366 clknet_0_net366 VGND VGND VPWR VPWR clknet_1_1__leaf_net366
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c446_D_N clknet_2_3__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmax_cap122 net1007 VGND VGND VPWR VPWR net1018 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c553_C net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net545 net545 VGND VGND VPWR VPWR clknet_0_net545 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c759_S0 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c714_C1 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c433_B1 net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input15_A in21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output83_A net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_81_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge805_A3 net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c237_A1 clknet_1_1__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc209 clknet_1_0__leaf_net762 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__buf_4
XFILLER_0_79_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input7_A in14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c663_B net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net375 net375 VGND VGND VPWR VPWR clknet_0_net375 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net397 net397 VGND VGND VPWR VPWR clknet_0_net397 sky130_fd_sc_hd__clkbuf_16
Xc710 net565 clknet_1_0__leaf_net470 net958 net876 VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__or4bb_1
Xc721 net1045 clknet_1_0__leaf_net583 net553 net566 net876 VGND VGND VPWR VPWR net592
+ sky130_fd_sc_hd__a2111o_1
Xc732 net332 clknet_1_0__leaf_net598 net570 net600 net813 net873 VGND VGND VPWR VPWR
+ net604 sky130_fd_sc_hd__mux4_4
Xc743 net495 clknet_1_1__leaf_net613 clknet_1_1__leaf_net614 clknet_1_0__leaf_net488
+ net881 net886 VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__mux4_2
Xc754 net1047 net784 net789 clknet_1_0__leaf_net867 net886 clknet_1_1__leaf_net888
+ VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__mux4_1
XANTENNA_clkbuf_4_15_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c610_A1 net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c338_B1 net257 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c504_A2 clknet_2_3__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_hold23_A net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c356_D net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout152_A net907 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge816_A2 net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c245_A_N net903 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c404_A net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc573 net443 net1047 net453 net432 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__or4bb_1
Xc562 net441 net857 net858 VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__and3_1
Xc551 net325 net806 net857 VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__and3_1
Xc595 net142 clknet_1_1__leaf_net470 net791 VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__nor3b_4
XFILLER_0_47_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc584 clknet_4_3_0_clk net118 net461 net416 clknet_1_0__leaf_net963 VGND VGND VPWR
+ VPWR net468 sky130_fd_sc_hd__sdfrtp_1
XANTENNA_c621_A0 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c605_C_N net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_43_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput113 net1009 VGND VGND VPWR VPWR out58 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput102 net998 VGND VGND VPWR VPWR out45 sky130_fd_sc_hd__buf_2
XFILLER_0_2_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net583 clknet_0_net583 VGND VGND VPWR VPWR clknet_1_0__leaf_net583
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_552 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge798_S1 net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c95_X net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput37 in41 VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__buf_1
Xinput26 in31 VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_12_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c616_A0 net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput15 in21 VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__clkbuf_2
Xinput59 in61 VGND VGND VPWR VPWR net955 sky130_fd_sc_hd__clkbuf_2
Xinput48 in51 VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__buf_1
XFILLER_0_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc370 clknet_4_14_0_clk net152 net279 clknet_1_0__leaf_net283 net148 net1083 VGND
+ VGND VPWR VPWR net293 net292 sky130_fd_sc_hd__sdfbbn_1
Xc392 net977 net992 net999 clknet_1_0__leaf_net988 net1002 net825 VGND VGND VPWR VPWR
+ net984 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_48_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmerge891 clknet_4_7_0_clk net639 net692 VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__dfrtn_1
Xmerge880 net694 net701 VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__and2b_1
XFILLER_0_70_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_3_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c411_A3 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s964_Q net860 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c436_A0 net332 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input45_A in49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c235_SCD net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c602_A2 net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c627_C1 net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c362_C1 net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c191_Q_N net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c157_B net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c686_A net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c65_C1 net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c86_C_N net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c447_C1 clknet_1_0__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_net345 clknet_0_net345 VGND VGND VPWR VPWR clknet_1_1__leaf_net345
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_s976_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c193_C_N net939 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c274_B net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge819_A2 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c577_CLK_N clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c152_A2 net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_11_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c429_SCD net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c624_A0 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output76_A net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net164 clknet_0_net164 VGND VGND VPWR VPWR clknet_1_1__leaf_net164
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_81_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net968 clknet_0_net968 VGND VGND VPWR VPWR clknet_1_0__leaf_net968
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge821_A3 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c166_C_N net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c551_A net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_net310 net310 VGND VGND VPWR VPWR clknet_0_net310 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc711 clknet_4_2_0_clk net1093 net576 net573 clknet_1_0__leaf_net547 net1073 VGND
+ VGND VPWR VPWR net582 net581 sky130_fd_sc_hd__sdfbbn_1
Xc700 net445 net537 net565 net556 net552 net874 VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__mux4_1
Xc722 net553 net1102 net574 net577 clknet_1_1__leaf_net455 net756 VGND VGND VPWR VPWR
+ net593 sky130_fd_sc_hd__mux4_2
Xc744 clknet_1_1__leaf_net613 clknet_1_0__leaf_net614 net120 net884 clknet_1_0__leaf_net888
+ clknet_1_0__leaf_net889 VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__mux4_1
Xc755 clknet_1_0__leaf_net397 clknet_1_1__leaf_net580 clknet_1_0__leaf_net623 net463
+ net1040 net869 VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__mux4_4
Xc733 net600 net1048 clknet_1_1__leaf_net598 clknet_1_0__leaf_net849 net884 VGND VGND
+ VPWR VPWR net605 sky130_fd_sc_hd__o2111a_1
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c610_A2 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c619_A0 net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c504_A3 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c190_A_N net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout145_A net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge816_A3 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c404_B net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_0_net963_A net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xwire2 net983 VGND VGND VPWR VPWR net1096 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_96_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c439_A0 net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c92_B net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge781_X net653 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc530 net1039 net1077 VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__nor2b_4
Xc552 net784 VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__clkbuf_1
Xc563 net205 net443 net441 clknet_1_1__leaf_net339 net444 VGND VGND VPWR VPWR net981
+ sky130_fd_sc_hd__o2111a_4
Xc541 net800 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__buf_6
XANTENNA_c678_Q net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc574 clknet_1_0__leaf_net249 clknet_1_0__leaf_net350 net1045 net240 VGND VGND VPWR
+ VPWR net458 sky130_fd_sc_hd__or4bb_4
XFILLER_0_47_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc585 net467 net461 net341 net1026 net850 VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__o2111ai_2
Xc596 net320 net1056 net377 VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__and3b_4
XANTENNA_input30_X net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c621_A1 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c104_RESET_B net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_586 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput114 net1053 VGND VGND VPWR VPWR out59 sky130_fd_sc_hd__clkbuf_1
Xoutput103 net999 VGND VGND VPWR VPWR out46 sky130_fd_sc_hd__buf_2
XFILLER_0_70_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge790_D_N net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s984_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge827_A2 net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c135_X net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_12_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_30_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge836_CLK_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput27 in32 VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__clkbuf_1
Xinput16 in22 VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_12_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput49 in52 VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__buf_1
XANTENNA_c616_A1 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput38 in42 VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__buf_1
XFILLER_0_52_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc360 clknet_4_14_0_clk net281 net939 net277 net86 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__sdfstp_1
XFILLER_0_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c632_A0 clknet_1_1__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc371 net962 net974 net292 net772 net792 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__o2111a_1
Xc393 net175 clknet_1_0__leaf_net1003 net1021 clknet_1_0__leaf_net984 net1008 net839
+ VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__mux4_4
XANTENNA_merge778_D1 net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s966_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge881 clknet_4_13_0_clk net650 net169 VGND VGND VPWR VPWR net760 net759 sky130_fd_sc_hd__edfxbp_1
XFILLER_0_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge870 net742 clknet_4_11_0_clk net665 VGND VGND VPWR VPWR net985 sky130_fd_sc_hd__dlrtn_2
XFILLER_0_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge892 clknet_4_14_0_clk net287 net668 VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_15_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c471_B net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input38_A in42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc190 net929 net117 net826 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__and3b_1
XANTENNA_c226_SCE net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c362_B1 net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s939_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c598_S0 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_1__f_net829_X clknet_1_1__leaf_net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c422_A3 clknet_1_0__leaf_net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c447_B1 net909 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c596_A_N net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_s947_GATE clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c613_A2 net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net313 clknet_0_net313 VGND VGND VPWR VPWR clknet_1_1__leaf_net313
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_58_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c357_B1 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap124 net1096 VGND VGND VPWR VPWR net1020 sky130_fd_sc_hd__clkbuf_1
XANTENNA_merge819_A3 net929 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c267_B net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_net547 net547 VGND VGND VPWR VPWR clknet_0_net547 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c714_A1 net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge927_SET_B net690 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_4_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c70_X net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c327_A3 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input60_X net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c624_A1 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c485_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output69_A clknet_1_0__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge900_Q net782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge786_D1 net8 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c172_Y net101 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_77_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c108_SCD net974 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net366 net366 VGND VGND VPWR VPWR clknet_0_net366 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net333 net333 VGND VGND VPWR VPWR clknet_0_net333 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c294_D1 net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_86_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc701 net556 net546 net562 net565 net1045 net1079 VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__mux4_2
Xc712 clknet_1_0__leaf_net340 net576 net84 clknet_1_0__leaf_net455 net573 net1038
+ VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__mux4_4
XFILLER_0_31_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc723 clknet_1_1__leaf_net591 clknet_1_0__leaf_net470 clknet_1_0__leaf_net593 net797
+ net877 net879 VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__mux4_4
Xc756 net597 net626 net293 net869 net877 net892 VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__mux4_4
Xc745 net372 clknet_1_1__leaf_net614 net907 clknet_1_1__leaf_net887 clknet_1_0__leaf_net888
+ clknet_1_1__leaf_net889 VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__mux4_4
Xc734 clknet_1_1__leaf_net455 net380 clknet_1_1__leaf_net204 net1048 net872 net884
+ VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__mux4_1
XANTENNA_merge824_X net696 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c191_Q net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input20_A in26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c610_A3 net463 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c619_A1 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net799 clknet_0_net799 VGND VGND VPWR VPWR clknet_1_0__leaf_net799
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c449_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire3 net393 VGND VGND VPWR VPWR net1097 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_96_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c439_A1 net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc531 net305 net193 VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__nor2b_2
Xc542 net302 net420 VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__nor2_1
Xc553 net1041 net855 net856 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__nand3b_4
Xc564 net208 net441 net442 net448 net447 net439 VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__mux4_1
Xc586 net800 VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__buf_2
Xc575 net227 net120 net855 VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__nor3_1
Xc597 net142 clknet_1_0__leaf_net481 net846 VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__and3_1
XFILLER_0_47_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c621_A2 net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input23_X net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput104 clknet_1_1__leaf_net1000 VGND VGND VPWR VPWR out47 sky130_fd_sc_hd__clkbuf_1
Xoutput115 net1011 VGND VGND VPWR VPWR out6 sky130_fd_sc_hd__buf_2
XFILLER_0_2_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput28 in33 VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput17 in23 VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_91_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput39 in43 VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__buf_2
XFILLER_0_24_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c616_A2 net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc361 net925 net108 net1028 net274 net1046 net751 VGND VGND VPWR VPWR net1008 sky130_fd_sc_hd__mux4_2
Xc372 clknet_4_14_0_clk net294 net280 net274 net279 net1001 VGND VGND VPWR VPWR net961
+ net295 sky130_fd_sc_hd__sdfbbn_1
Xc350 net267 net228 net262 net843 net844 net845 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__mux4_1
XANTENNA_c632_A1 net391 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc394 net1028 clknet_1_1__leaf_net204 net973 net1005 net1001 net972 VGND VGND VPWR
+ VPWR net298 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_48_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge871 net671 clknet_4_7_0_clk net102 VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__dlrtn_4
Xmerge860 net289 net276 VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__nor2_4
Xmerge882 clknet_4_0_0_clk net451 net693 VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__edfxtp_1
XFILLER_0_28_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge893 clknet_4_0_0_clk net675 net645 VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_55_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c270_B_N net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c102_C net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net829_X clknet_1_0__leaf_net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c471_C net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c704_SCD net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c452_A1 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout150 net940 VGND VGND VPWR VPWR net1046 sky130_fd_sc_hd__buf_4
XFILLER_0_44_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c627_A1 net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c346_A2 net955 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc180 net916 net939 net1029 net826 net831 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__o2111a_1
Xc191 clknet_4_7_0_clk net936 net1044 net119 net118 net117 VGND VGND VPWR VPWR net121
+ net120 sky130_fd_sc_hd__sdfbbn_2
XFILLER_0_85_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge789_D1 net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c162_SCE net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c598_S1 net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c728_B1 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s942_GATE_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c447_A1 net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_22_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c423_C_N net319 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge848_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input50_A in53 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c613_A3 net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f_net303 clknet_0_net303 VGND VGND VPWR VPWR clknet_1_1__leaf_net303
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net347 clknet_0_net347 VGND VGND VPWR VPWR clknet_1_1__leaf_net347
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_58_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c357_A1 net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c706_D net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c730_A1 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c624_A2 clknet_1_1__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net155 net424 VGND VGND VPWR VPWR clknet_1_1__leaf_net155 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_92_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc481_7 net766 VGND VGND VPWR VPWR net1055 sky130_fd_sc_hd__clkinv_2
XANTENNA_c356_SCE net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c108_SCE net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc540_10 net800 VGND VGND VPWR VPWR net1058 sky130_fd_sc_hd__inv_1
Xclkbuf_0_net345 net345 VGND VGND VPWR VPWR clknet_0_net345 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c294_C1 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc702 net188 net565 net1045 net567 net1040 net561 VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__mux4_1
Xc713 net530 clknet_1_0__leaf_net583 net526 net581 net573 net1045 VGND VGND VPWR VPWR
+ net584 sky130_fd_sc_hd__mux4_4
XFILLER_0_31_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc724 net1034 clknet_1_0__leaf_net593 clknet_1_0__leaf_net580 net530 net575 net860
+ VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__mux4_4
Xc746 clknet_1_0__leaf_net613 net596 net791 net807 net812 clknet_1_0__leaf_net889
+ VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__mux4_4
Xc735 net527 net1047 net463 net600 net879 net884 VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__mux4_4
XFILLER_0_31_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c741_A0 net462 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc757 net475 net622 clknet_1_1__leaf_net488 net120 clknet_1_0__leaf_net867 net891
+ VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__mux4_2
XFILLER_0_98_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input13_A in2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c619_A2 net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output81_A net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_78_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_2_3__f_net310_A clknet_0_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net767 clknet_0_net767 VGND VGND VPWR VPWR clknet_1_0__leaf_net767
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c132_C net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c125_B net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xwire4 net124 VGND VGND VPWR VPWR net1098 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input5_A in12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c577_SCE clknet_2_2__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c360_SET_B net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_net164 net164 VGND VGND VPWR VPWR clknet_0_net164 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc543 net669 VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__inv_4
Xc532 net651 VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__inv_6
Xc554 net100 net414 net330 clknet_2_1__leaf_net310 VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__or4bb_1
Xc565 net773 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__inv_2
Xc587 net342 clknet_1_0__leaf_net249 clknet_1_1__leaf_net470 net953 net468 VGND VGND
+ VPWR VPWR net471 sky130_fd_sc_hd__a2111o_4
Xc576 net459 clknet_1_0__leaf_net350 VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__nor2_4
Xc598 net1055 net1041 clknet_1_1__leaf_net481 net383 net1024 net416 VGND VGND VPWR
+ VPWR net483 sky130_fd_sc_hd__mux4_4
XANTENNA_c621_A3 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c349_A2 net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput116 net1012 VGND VGND VPWR VPWR out60 sky130_fd_sc_hd__buf_2
Xoutput105 net1001 VGND VGND VPWR VPWR out48 sky130_fd_sc_hd__buf_2
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_hold21_A net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c559_SCE net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net564 clknet_0_net564 VGND VGND VPWR VPWR clknet_1_0__leaf_net564
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_fanout150_A net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge930_GATE_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput18 in24 VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_12_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput29 in34 VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__buf_4
XFILLER_0_91_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc362 net1063 net257 net148 net839 clknet_1_0__leaf_net155 VGND VGND VPWR VPWR net283
+ sky130_fd_sc_hd__a2111o_4
Xc340 net1038 net252 net841 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__nand3_1
Xc351 net258 net265 net261 net793 net844 net845 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__mux4_1
Xc373 net158 net151 net282 net961 net148 net294 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__mux4_2
Xc395 clknet_1_0__leaf_net984 clknet_1_1__leaf_net1000 net295 net986 net998 net793
+ VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__mux4_4
XFILLER_0_20_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge778_B1 net925 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge850 clknet_4_15_0_clk net51 net676 VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__dfstp_1
XFILLER_0_74_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge872 net592 net586 VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__and2_1
Xmerge861 net362 net477 VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__nand2_4
Xmerge883 clknet_4_15_0_clk net677 net699 VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__sdlclkp_1
XFILLER_0_15_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge894 net511 net764 VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__nand2b_1
XFILLER_0_99_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_net350 clknet_0_net350 VGND VGND VPWR VPWR clknet_1_0__leaf_net350
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c140_X net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c704_SCE net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c717_A2 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_rebuffer3_A net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c436_A3 clknet_2_1__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout140 net1037 VGND VGND VPWR VPWR net1036 sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_net529 clknet_0_net529 VGND VGND VPWR VPWR clknet_1_1__leaf_net529
+ sky130_fd_sc_hd__clkbuf_16
Xfanout151 net915 VGND VGND VPWR VPWR net1047 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_17_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c627_A2 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge923_Q net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc170 net97 net924 net89 net925 net1041 clknet_1_1__leaf_net828 VGND VGND VPWR VPWR
+ net99 sky130_fd_sc_hd__mux4_1
XFILLER_0_85_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c362_A2 net257 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc181 net1062 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__inv_2
Xc192 net1067 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__buf_6
XFILLER_0_18_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_34_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_s962_Q net858 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c447_A2 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_18_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input43_A in47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net304 clknet_0_net304 VGND VGND VPWR VPWR clknet_1_1__leaf_net304
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net337 clknet_0_net337 VGND VGND VPWR VPWR clknet_1_1__leaf_net337
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_55_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge775_A1 net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge873_Q net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c699_S1 net860 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c357_A2 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap126 net203 VGND VGND VPWR VPWR net1022 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_20_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap148 net3 VGND VGND VPWR VPWR net1044 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_0_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c155_B net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c315_A net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c564_A0 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c684_A net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_27_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c706_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c624_A3 clknet_1_0__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_2_2__f_net310_A clknet_0_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge907_GATE_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge786_B1 net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c303_Q_N net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c503_S0 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_merge815_S0 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc481_8 net766 VGND VGND VPWR VPWR net1056 sky130_fd_sc_hd__clkinv_2
XFILLER_0_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net313 net313 VGND VGND VPWR VPWR clknet_0_net313 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_91_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc540_11 net800 VGND VGND VPWR VPWR net1059 sky130_fd_sc_hd__inv_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c294_B1 net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c318_X net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc703 net414 net566 net334 net549 net712 net875 VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__mux4_1
XFILLER_0_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc725 clknet_4_2_0_clk clknet_1_0__leaf_net591 clknet_1_1__leaf_net593 net786 net860
+ net883 VGND VGND VPWR VPWR net597 net596 sky130_fd_sc_hd__sdfbbp_1
Xc714 net542 net582 net574 net958 net475 VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__a2111oi_1
Xc736 net600 clknet_1_0__leaf_net488 net816 net866 net872 net878 VGND VGND VPWR VPWR
+ net608 sky130_fd_sc_hd__mux4_4
Xc747 net618 clknet_1_0__leaf_net614 net1047 net791 net885 clknet_1_1__leaf_net887
+ VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__mux4_1
XFILLER_0_31_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c590_SET_B net1069 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c741_A1 net953 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc758 net376 net463 clknet_1_0__leaf_net628 net817 net890 net894 VGND VGND VPWR VPWR
+ net630 sky130_fd_sc_hd__mux4_4
XANTENNA_c292_SCE net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c307_S1 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c344_Q net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c619_A3 net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c635_A2 net1021 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_78_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output74_A net970 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c676_D1 net526 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_0_clk_X clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge902_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c545_A2 net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_9_0_clk_X clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c275_Y net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s987_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c752_A0 net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc500 net31 net404 clknet_1_1__leaf_net395 net391 net989 VGND VGND VPWR VPWR net406
+ sky130_fd_sc_hd__o2111a_2
XTAP_TAPCELL_ROW_9_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc555 clknet_4_1_0_clk clknet_1_0__leaf_net318 net435 net854 net856 VGND VGND VPWR
+ VPWR net440 net439 sky130_fd_sc_hd__sdfrbp_1
Xc544 net425 net416 VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__nor2b_4
Xc533 net651 VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__clkbuf_1
Xc566 net436 net445 clknet_1_0__leaf_net345 net442 net437 net859 VGND VGND VPWR VPWR
+ net451 sky130_fd_sc_hd__mux4_1
Xc588 clknet_1_0__leaf_net345 clknet_2_0__leaf_net310 net437 net443 clknet_1_0__leaf_net471
+ net969 VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__mux4_1
Xc577 clknet_4_3_0_clk net240 clknet_1_0__leaf_net458 clknet_1_1__leaf_net428 clknet_2_2__leaf_net310
+ VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__sdfrtn_1
XANTENNA_s964_SLEEP_B clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc599 clknet_1_1__leaf_net458 clknet_2_3__leaf_net310 net1021 net377 net846 net861
+ VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_63_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_71_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c128_CLK_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c365_A2 net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c497_SET_B net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput106 net1002 VGND VGND VPWR VPWR out49 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput117 net1013 VGND VGND VPWR VPWR out61 sky130_fd_sc_hd__buf_2
XFILLER_0_23_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s969_CLK clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net532 clknet_0_net532 VGND VGND VPWR VPWR clknet_1_0__leaf_net532
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout143_A net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net598 clknet_0_net598 VGND VGND VPWR VPWR clknet_1_0__leaf_net598
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c402_B net1030 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c597_A net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput19 in25 VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_40_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc330 net900 net1028 net834 net839 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__or4bb_2
XFILLER_0_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc352 net152 net266 net1028 net793 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__or4bb_1
Xc341 net189 net138 net1028 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__or3_2
XFILLER_0_20_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c632_A3 net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc363 net798 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__buf_1
XFILLER_0_20_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc396 net1022 net958 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__nor2b_2
XANTENNA_merge778_A1 net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge873 net170 clknet_4_13_0_clk net1017 VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__dlrtp_2
Xmerge851 clknet_4_12_0_clk net242 net247 VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__dfstp_1
XFILLER_0_7_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge840 clknet_4_0_0_clk net663 net674 VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__dfrtp_4
Xmerge862 net364 net368 VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__nand2_1
XFILLER_0_55_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge895 clknet_4_5_0_clk net79 net713 VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_23_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge884 net518 net517 VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__and2b_4
XFILLER_0_99_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs990 net627 clknet_4_10_0_clk VGND VGND VPWR VPWR net893 net892 sky130_fd_sc_hd__dlxbn_1
XANTENNA_c392_A0 net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_97_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge807_S1 net1002 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge823_S0 net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c178_A net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c352_B net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net340 clknet_0_net340 VGND VGND VPWR VPWR clknet_1_0__leaf_net340
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c567_A0 net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net384 clknet_0_net384 VGND VGND VPWR VPWR clknet_1_0__leaf_net384
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout146_X net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net395 clknet_0_net395 VGND VGND VPWR VPWR clknet_1_0__leaf_net395
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c140_S1 net957 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c733_A2 net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout152 net907 VGND VGND VPWR VPWR net1048 sky130_fd_sc_hd__buf_4
Xclkbuf_1_1__f_net519 clknet_0_net519 VGND VGND VPWR VPWR clknet_1_1__leaf_net519
+ sky130_fd_sc_hd__clkbuf_16
Xfanout141 net979 VGND VGND VPWR VPWR net1037 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc171 net64 net98 net85 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__nand3_4
Xc160 net935 net85 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__and2b_1
XFILLER_0_20_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc182 net916 net1029 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__and2_1
Xc193 net116 net119 net939 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__or3b_1
XANTENNA_s950_Q_N net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c241_S0 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c581_D net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c462_A net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c728_A2 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge794_B net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c151_S0 net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_2_1__f_net310_A clknet_0_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input36_A in40 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c326_S0 net943 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net349 clknet_0_net349 VGND VGND VPWR VPWR clknet_1_1__leaf_net349
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_58_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c488_C1 net1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge775_A2 clknet_1_0__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c301_SCD net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c373_A2 net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap127 net1098 VGND VGND VPWR VPWR net1023 sky130_fd_sc_hd__clkbuf_1
Xmax_cap138 net1035 VGND VGND VPWR VPWR net1034 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge820_S1 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c315_B net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c684_B net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c677_A net807 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_c490_A0 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input39_X net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net168 clknet_0_net168 VGND VGND VPWR VPWR clknet_1_1__leaf_net168
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c499_D1 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c681_C1 net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge815_S1 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_0_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c278_A2 net64 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_5_0_clk_X clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net303 net303 VGND VGND VPWR VPWR clknet_0_net303 sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_46_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc540_12 net800 VGND VGND VPWR VPWR net1060 sky130_fd_sc_hd__inv_1
Xclkbuf_0_net347 net347 VGND VGND VPWR VPWR clknet_0_net347 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc704 clknet_4_2_0_clk net526 clknet_1_0__leaf_net455 net432 net84 net462 VGND VGND
+ VPWR VPWR net571 net570 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc715 net549 clknet_1_0__leaf_net564 net462 clknet_2_0__leaf_net310 clknet_1_0__leaf_net583
+ VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__o2111a_4
Xc737 net597 clknet_1_0__leaf_net488 net600 net495 net807 net876 VGND VGND VPWR VPWR
+ net609 sky130_fd_sc_hd__mux4_4
Xc726 net320 clknet_1_1__leaf_net455 net1048 net866 net878 VGND VGND VPWR VPWR net598
+ sky130_fd_sc_hd__a2111o_2
XANTENNA_c741_A2 net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc759 net121 net630 clknet_1_1__leaf_net628 clknet_1_1__leaf_net488 net865 net893
+ VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__mux4_4
Xc748 net121 net597 clknet_1_1__leaf_net488 clknet_2_2__leaf_net310 clknet_1_1__leaf_net829
+ net853 VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_55_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_64_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_73_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net94 clknet_0_net94 VGND VGND VPWR VPWR clknet_1_1__leaf_net94 sky130_fd_sc_hd__clkbuf_16
XANTENNA_output67_A clknet_1_1__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c545_A3 net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c279_Q_N net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net155 net155 VGND VGND VPWR VPWR clknet_0_net155 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_64_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc501 net264 clknet_1_1__leaf_net284 net278 clknet_1_1__leaf_net397 net1046 net994
+ VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_9_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc545 net302 net426 net413 net414 net415 net737 VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__mux4_1
Xc534 net906 net931 VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__or2_1
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc578 clknet_4_3_0_clk net432 clknet_2_0__leaf_net310 net84 net851 VGND VGND VPWR
+ VPWR net462 sky130_fd_sc_hd__sdfrtp_2
Xc567 net413 net440 net444 c567/A3 net761 net859 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__mux4_4
Xc589 net468 net465 net320 clknet_1_1__leaf_net470 net463 net854 VGND VGND VPWR VPWR
+ net473 sky130_fd_sc_hd__mux4_4
Xc556 net325 net435 net335 net332 VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__or4bb_2
XTAP_TAPCELL_ROW_63_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_362 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c496_C1 net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_71_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput107 clknet_1_1__leaf_net1003 VGND VGND VPWR VPWR out5 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput118 net1031 VGND VGND VPWR VPWR out7 sky130_fd_sc_hd__buf_2
XFILLER_0_23_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c228_S1 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout136_A net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge887_CLK clknet_4_9_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s985_Q net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c707_SCD net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc320 net110 net239 net238 net227 net237 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__o2111a_1
XFILLER_0_20_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_75_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc353 net148 clknet_1_1__leaf_net155 net1048 net839 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__or4bb_1
Xc331 net189 net138 net250 net840 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__or4bb_1
Xc342 clknet_4_12_0_clk net255 net262 net234 net793 net839 VGND VGND VPWR VPWR net264
+ net263 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_20_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc364 net280 net1012 net148 clknet_1_1__leaf_net275 net972 VGND VGND VPWR VPWR net285
+ sky130_fd_sc_hd__o2111ai_2
XFILLER_0_74_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input21_X net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_4_13_0_clk_X clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmerge830 net539 net540 net426 net427 net193 net871 VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__mux4_1
XFILLER_0_7_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge863 net589 net633 VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__nor2b_1
XFILLER_0_28_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge841 net353 net358 VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__nor2b_1
Xmerge852 clknet_4_4_0_clk net657 net662 VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__dfstp_1
XFILLER_0_99_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge874 net604 net616 VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__nor2b_1
Xmerge885 net507 net509 VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__and2b_4
XFILLER_0_55_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge896 net288 net285 VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__nor2b_4
XFILLER_0_82_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xs991 net629 clknet_4_8_0_clk VGND VGND VPWR VPWR net895 net894 sky130_fd_sc_hd__dlxbp_1
Xs980 net590 clknet_4_2_0_clk VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__lpflow_inputisolatch_1
XTAP_TAPCELL_ROW_97_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_1_0__f_net981_X clknet_1_0__leaf_net981 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f_net352 clknet_0_net352 VGND VGND VPWR VPWR clknet_1_0__leaf_net352
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c702_S0 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_2_0__f_net310_A clknet_0_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout142 net184 VGND VGND VPWR VPWR net1038 sky130_fd_sc_hd__buf_4
XFILLER_0_96_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c758_A0 net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_45_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c120_D1 net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc161 net923 net933 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__or2_1
Xc172 net92 net928 net830 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__nor3b_2
Xc150 net899 net65 net1011 net1030 net722 net775 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__mux4_1
XFILLER_0_20_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc183 net725 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__inv_1
XFILLER_0_85_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc194 net114 net122 net117 net121 net1029 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__a2111oi_1
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_99_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c151_S1 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c744_A2 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c760_A1 net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input29_A in34 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net339 clknet_0_net339 VGND VGND VPWR VPWR clknet_1_1__leaf_net339
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_58_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c488_B1 clknet_1_0__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmax_cap139 net585 VGND VGND VPWR VPWR net1035 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c236_S1 net819 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net529 net529 VGND VGND VPWR VPWR clknet_0_net529 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c308_B net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c739_A2 net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge802_D_N net530 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c295_SCD net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c337_S0 net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c681_B1 net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c160_B net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net304 net304 VGND VGND VPWR VPWR clknet_0_net304 sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_101_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c704_D net526 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net337 net337 VGND VGND VPWR VPWR clknet_0_net337 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c294_A2 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_16_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc738 net571 clknet_1_0__leaf_net598 net1011 net1038 clknet_1_0__leaf_net849 net872
+ VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__mux4_2
Xc716 net582 net574 net575 net1038 net935 net797 VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__mux4_2
Xc705 net566 net567 net565 net541 VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__or4bb_1
Xc727 net122 clknet_1_1__leaf_net598 clknet_1_0__leaf_net547 net866 net876 net881
+ VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__mux4_4
XFILLER_0_97_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc749 clknet_2_2__leaf_net310 net72 clknet_1_1__leaf_net547 net578 net870 net886 VGND
+ VGND VPWR VPWR net621 sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_4_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c620_S0 net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input51_X net947 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge878_GATE clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge917_GCLK net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c395_A1 clknet_1_1__leaf_net1000 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge826_S1 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire7 net390 VGND VGND VPWR VPWR net1101 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c270_A net1032 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer10 net1063 VGND VGND VPWR VPWR net1064 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c736_A3 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c752_A2 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc502 clknet_4_10_0_clk net388 net974 clknet_1_0__leaf_net406 net1043 net1092 VGND
+ VGND VPWR VPWR net967 net408 sky130_fd_sc_hd__sdfbbp_1
XTAP_TAPCELL_ROW_9_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc535 net714 VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__inv_1
Xc546 net423 net418 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__and2_1
Xc568 net814 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__buf_6
Xc557 net205 net436 net704 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__nor3_1
Xc579 net800 VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_99_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c615_S0 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input11_A in18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c725_SCE net860 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c496_B1 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c350_S0 net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput108 net1004 VGND VGND VPWR VPWR out50 sky130_fd_sc_hd__buf_2
XFILLER_0_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput119 net1015 VGND VGND VPWR VPWR out8 sky130_fd_sc_hd__buf_2
Xoutput90 net986 VGND VGND VPWR VPWR out34 sky130_fd_sc_hd__buf_2
XFILLER_0_77_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net545 clknet_0_net545 VGND VGND VPWR VPWR clknet_1_0__leaf_net545
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c116_A net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c597_C net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input3_A in10 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_s978_Q net877 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c707_SCE net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c342_CLK_N clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c747_A2 net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c170_S0 net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc310 net943 net216 net935 net101 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__or4bb_1
Xc321 net218 net230 net201 net239 net830 net839 VGND VGND VPWR VPWR net1015 sky130_fd_sc_hd__mux4_2
XANTENNA_input59_A in61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc343 clknet_4_12_0_clk net131 net144 net262 net16 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__sdfstp_1
XTAP_TAPCELL_ROW_75_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc332 net937 net142 net131 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__nand3_2
Xc354 net274 net105 net831 VGND VGND VPWR VPWR net1012 sky130_fd_sc_hd__nor3b_2
XFILLER_0_20_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc365 clknet_1_1__leaf_net283 net263 net282 clknet_1_1__leaf_net155 net158 net1001
+ VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__mux4_2
Xc398 net182 net911 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__or2_2
XANTENNA_input14_X net910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c330_D_N net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge820 net104 net208 net1098 net110 clknet_1_1__leaf_net828 net832 VGND VGND VPWR
+ VPWR net692 sky130_fd_sc_hd__mux4_2
XANTENNA_merge889_Q net987 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge831 clknet_4_0_0_clk merge831/D net438 VGND VGND VPWR VPWR net704 net452 sky130_fd_sc_hd__dfrbp_1
Xmerge853 net502 net506 VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__and2_1
Xmerge842 net381 net379 VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__nand2_1
Xmerge864 net409 net401 VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__and2b_1
XFILLER_0_99_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge897 net609 net607 VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__and2_0
Xmerge886 net606 net516 VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__nand2b_4
Xs970 clknet_4_10_0_clk net503 VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__dlclkp_1
Xmerge875 net625 net508 VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__nor2b_2
Xs981 clknet_4_2_0_clk net594 VGND VGND VPWR VPWR net881 net880 sky130_fd_sc_hd__dfxbp_1
Xs992 net686 clknet_4_6_0_clk VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__dlxtn_1
Xrebuffer1 net833 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c392_A2 net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net375 clknet_0_net375 VGND VGND VPWR VPWR clknet_1_0__leaf_net375
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_net397 clknet_0_net397 VGND VGND VPWR VPWR clknet_1_0__leaf_net397
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c119_X net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c590_Q_N net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout132 net234 VGND VGND VPWR VPWR net1028 sky130_fd_sc_hd__buf_2
Xfanout143 net184 VGND VGND VPWR VPWR net1039 sky130_fd_sc_hd__clkbuf_2
XANTENNA_c123_C_N net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c758_A1 net463 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_45_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c612_S1 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc162 clknet_4_7_0_clk net89 net1082 net90 net1031 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__sdfrtp_2
Xc151 net70 net77 net75 net1030 net775 net826 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__mux4_1
Xc140 net68 net903 net904 net920 net899 net957 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__mux4_2
Xc195 net913 net123 net1023 net1029 clknet_1_0__leaf_net107 net1040 VGND VGND VPWR
+ VPWR net125 sky130_fd_sc_hd__mux4_2
Xc184 net749 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__inv_6
Xc173 net91 net101 net100 net90 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__or4bb_1
XANTENNA_merge789_A2 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c114_C_N net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c353_C_N net1048 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c243_Y net1005 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_2_0__f_net310 clknet_0_net310 VGND VGND VPWR VPWR clknet_2_0__leaf_net310
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_93_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout151_X net1047 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c760_A2 clknet_1_1__leaf_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net318 clknet_0_net318 VGND VGND VPWR VPWR clknet_1_1__leaf_net318
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net329 clknet_0_net329 VGND VGND VPWR VPWR clknet_1_1__leaf_net329
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c623_S0 clknet_1_0__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c488_A1 net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_94_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c583_C_N net463 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_0__f_net303_X clknet_1_0__leaf_net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net519 net519 VGND VGND VPWR VPWR clknet_0_net519 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_63_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s950_CLK clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c574_C_N net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s960_Q net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge923_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c108_Q net973 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c295_SCE net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c618_S0 net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input41_A in45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net159 clknet_0_net159 VGND VGND VPWR VPWR clknet_1_1__leaf_net159
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c499_B1 net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge914_CLK clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net349 net349 VGND VGND VPWR VPWR clknet_0_net349 sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_60_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc717 clknet_1_1__leaf_net583 clknet_1_0__leaf_net560 net935 net587 net1033 net786
+ VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__mux4_2
Xc706 clknet_4_2_0_clk net84 net571 net562 net567 VGND VGND VPWR VPWR net574 net573
+ sky130_fd_sc_hd__sdfsbp_2
Xc728 net596 net865 net866 net873 net878 VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__o2111ai_4
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc739 net527 clknet_1_0__leaf_net598 net801 net879 net883 net885 VGND VGND VPWR VPWR
+ net611 sky130_fd_sc_hd__mux4_4
XANTENNA_c438_S0 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c470_X net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c87_A3 net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input44_X net940 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c710_C_N net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer11 net749 VGND VGND VPWR VPWR net1065 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c368_B net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_1_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c156_Y net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s977_GATE_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c528_A net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge769_D_N net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net168 net168 VGND VGND VPWR VPWR clknet_0_net168 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc503 clknet_1_1__leaf_net406 net403 net46 clknet_1_1__leaf_net397 net1021 net783
+ VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__mux4_2
XANTENNA_c107_A0 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc536 net418 net312 VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__nand2_1
Xc569 net441 net453 clknet_1_1__leaf_net318 clknet_1_0__leaf_net345 net704 net858
+ VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__mux4_4
Xc558 net797 VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__buf_1
Xc547 clknet_1_0__leaf_net204 net1038 net430 net958 net415 net737 VGND VGND VPWR VPWR
+ net431 sky130_fd_sc_hd__mux4_2
XFILLER_0_99_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c615_S1 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c350_S1 net845 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_467 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput109 net1005 VGND VGND VPWR VPWR out51 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput80 net976 VGND VGND VPWR VPWR out25 sky130_fd_sc_hd__buf_2
XANTENNA_c553_A_N net1041 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput91 net987 VGND VGND VPWR VPWR out35 sky130_fd_sc_hd__buf_2
XFILLER_0_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c716_S0 net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c747_A3 net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge868_GATE clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c763_A2 net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c69_B net917 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc311 net1044 net84 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__nor2_4
XFILLER_0_32_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc300 net85 net67 net770 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_75_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc344 clknet_4_12_0_clk net262 net1037 net265 net1070 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__sdfstp_2
Xc322 net771 VGND VGND VPWR VPWR net979 sky130_fd_sc_hd__inv_2
Xc333 net130 net1028 net250 net937 net1033 net1036 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__mux4_4
XANTENNA_c279_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc366 net1040 clknet_1_1__leaf_net155 clknet_1_1__leaf_net283 net831 clknet_1_1__leaf_net847
+ VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__a2111oi_4
Xc355 net1029 clknet_1_1__leaf_net204 clknet_1_1__leaf_net155 clknet_1_1__leaf_net275
+ net839 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__a2111o_4
XANTENNA_c626_S0 net1043 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc399 clknet_1_0__leaf_net767 VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_c292_Q net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c361_S0 net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge821 clknet_1_1__leaf_net529 net551 clknet_1_1__leaf_net545 net1045 net712 net871
+ VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__mux4_2
Xmerge810 net370 net376 clknet_1_0__leaf_net204 net252 net377 clknet_1_0__leaf_net352
+ VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__mux4_4
XFILLER_0_83_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge832 net490 net492 VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__nor2_1
Xmerge854 net328 net344 VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__nor2b_2
Xmerge843 net1097 net398 VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__nor2b_2
Xmerge865 net476 net617 VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__nand2b_1
Xmerge876 net721 net521 VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__nor2_4
Xs960 net431 clknet_4_1_0_clk VGND VGND VPWR VPWR net856 sky130_fd_sc_hd__dlxtn_2
Xmerge887 clknet_4_9_0_clk net683 net685 VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__sdlclkp_2
XFILLER_0_99_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge898 clknet_4_13_0_clk net679 net691 VGND VGND VPWR VPWR net779 net778 sky130_fd_sc_hd__dfsbp_2
XFILLER_0_70_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xs993 net702 clknet_4_0_0_clk VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__dlxtn_1
Xs982 clknet_4_2_0_clk net595 VGND VGND VPWR VPWR net883 net882 sky130_fd_sc_hd__dfxbp_1
XTAP_TAPCELL_ROW_11_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs971 clknet_4_10_0_clk net510 VGND VGND VPWR VPWR net971 sky130_fd_sc_hd__dlclkp_2
XFILLER_0_55_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer2 net137 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_79_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_88_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c219_D1 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c400_B net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c595_A net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout133 net108 VGND VGND VPWR VPWR net1029 sky130_fd_sc_hd__clkbuf_4
Xfanout144 net93 VGND VGND VPWR VPWR net1040 sky130_fd_sc_hd__buf_6
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc130 net53 net980 net1004 net1013 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__or4bb_1
Xc163 net933 net92 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__or2b_2
Xc152 net72 net70 net1030 net722 net826 clknet_1_0__leaf_net827 VGND VGND VPWR VPWR
+ net82 sky130_fd_sc_hd__mux4_1
Xc141 net898 net71 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__and2_2
Xc185 net755 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__buf_1
Xc196 net771 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__inv_1
Xc174 net775 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c190_C net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c295_D net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_hold15_X net1069 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c356_CLK_N clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c713_S1 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c448_B net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout144_X net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c623_S1 net784 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c488_A2 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_587 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_s953_Q net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge785_A net64 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c755_A3 net463 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c490_A3 net962 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input34_A in39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc90 net744 VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__buf_6
XFILLER_0_97_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge850_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net339 net339 VGND VGND VPWR VPWR clknet_0_net339 sky130_fd_sc_hd__clkbuf_16
XANTENNA_c313_B net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_15_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xc707 clknet_4_2_0_clk net958 net935 net1011 net542 net553 VGND VGND VPWR VPWR net576
+ net575 sky130_fd_sc_hd__sdfbbp_1
Xc729 net527 clknet_2_2__leaf_net310 net1040 net813 net874 net880 VGND VGND VPWR VPWR
+ net601 sky130_fd_sc_hd__mux4_4
Xc718 net574 clknet_1_1__leaf_net583 net121 net587 net1033 net575 VGND VGND VPWR VPWR
+ net589 sky130_fd_sc_hd__mux4_1
XANTENNA_c591_A2 net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge797_SCD net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_68_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_33_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input37_X net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_42_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c676_A2 net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge899_CLK clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c708_CLK_N clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_60_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer12 net1065 VGND VGND VPWR VPWR net1066 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c430_B net926 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c528_B net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_91_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c107_A1 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_9_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc537 net420 net418 VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__and2_0
Xc504 net404 net940 clknet_2_3__leaf_net310 net1047 clknet_1_1__leaf_net965 clknet_1_1__leaf_net406
+ VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__mux4_4
Xc548 net430 net420 VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__and2_2
Xc559 clknet_4_1_0_clk net1091 net414 clknet_1_1__leaf_net318 net227 VGND VGND VPWR
+ VPWR net445 net444 sky130_fd_sc_hd__sdfrbp_2
XFILLER_0_99_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c502_Q net967 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput70 net966 VGND VGND VPWR VPWR out16 sky130_fd_sc_hd__buf_2
Xoutput81 net977 VGND VGND VPWR VPWR out26 sky130_fd_sc_hd__clkbuf_4
XANTENNA_merge869_GATE_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput92 clknet_1_1__leaf_net988 VGND VGND VPWR VPWR out36 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c314_C1 clknet_1_0__leaf_net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge866_RESET_B net678 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net547 clknet_0_net547 VGND VGND VPWR VPWR clknet_1_0__leaf_net547
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c266_Y net184 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_96_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c426_X net332 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c480_A_N net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc312 net231 net1016 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__or2b_1
XFILLER_0_20_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc301 clknet_4_5_0_clk net217 net218 net207 net208 VGND VGND VPWR VPWR net223 net222
+ sky130_fd_sc_hd__sdfsbp_2
XTAP_TAPCELL_ROW_75_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc345 net144 net265 net266 net925 net793 net840 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__mux4_1
Xc334 clknet_4_12_0_clk net228 net925 net23 net1036 net1024 VGND VGND VPWR VPWR net255
+ net254 sky130_fd_sc_hd__sdfbbp_1
Xc323 net241 net1036 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__nor2_1
Xc356 clknet_4_14_0_clk net955 net1012 net1064 net1029 clknet_1_1__leaf_net275 VGND
+ VGND VPWR VPWR net278 net277 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc367 net279 net264 net148 clknet_1_0__leaf_net283 net211 VGND VGND VPWR VPWR net288
+ sky130_fd_sc_hd__a2111oi_0
XANTENNA_c626_S1 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output103_A net999 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c361_S1 net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge800 clknet_1_1__leaf_net309 net322 net417 net413 VGND VGND VPWR VPWR net672
+ sky130_fd_sc_hd__or4bb_2
Xmerge811 net238 net218 net374 clknet_1_0__leaf_net963 clknet_1_0__leaf_net384 net834
+ VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__mux4_1
Xmerge844 clknet_4_15_0_clk net41 net640 VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__dfrtp_1
Xmerge822 net207 net190 net208 net8 net92 net16 VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__mux4_1
XFILLER_0_23_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge855 net599 net603 VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__nor2_1
Xmerge833 clknet_4_4_0_clk net311 net315 VGND VGND VPWR VPWR net707 net706 sky130_fd_sc_hd__dfrbp_1
XFILLER_0_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmerge877 net664 clknet_4_7_0_clk net667 VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__dlrtp_1
Xmerge866 net298 clknet_4_14_0_clk net678 VGND VGND VPWR VPWR net998 net744 sky130_fd_sc_hd__dlrbp_1
Xs961 net433 clknet_4_1_0_clk VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__dlxtn_1
Xmerge888 clknet_4_4_0_clk net641 net697 VGND VGND VPWR VPWR net767 sky130_fd_sc_hd__sdlclkp_4
Xs950 clknet_4_12_0_clk net269 VGND VGND VPWR VPWR net972 net843 sky130_fd_sc_hd__dfxbp_2
Xmerge899 clknet_4_5_0_clk net684 net695 VGND VGND VPWR VPWR net781 net780 sky130_fd_sc_hd__dfsbp_2
XTAP_TAPCELL_ROW_11_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xs983 clknet_4_8_0_clk net602 VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__dfxtp_1
Xs972 clknet_4_10_0_clk net512 VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__dlclkp_4
Xrebuffer3 net154 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_97_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f_net333 clknet_0_net333 VGND VGND VPWR VPWR clknet_1_0__leaf_net333
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_19_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f_net366 clknet_0_net366 VGND VGND VPWR VPWR clknet_1_0__leaf_net366
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_80_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c219_C1 net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout134_A net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_0_net204_X clknet_0_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout145 net86 VGND VGND VPWR VPWR net1041 sky130_fd_sc_hd__buf_4
Xfanout134 net1031 VGND VGND VPWR VPWR net1030 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc120 net32 net950 net49 net44 net977 VGND VGND VPWR VPWR net1007 sky130_fd_sc_hd__a2111oi_1
XFILLER_0_33_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc131 clknet_4_15_0_clk net63 net1078 net977 net19 VGND VGND VPWR VPWR net1006 sky130_fd_sc_hd__sdfrtp_2
Xc153 net72 net65 net64 net723 clknet_1_0__leaf_net827 clknet_1_0__leaf_net828 VGND
+ VGND VPWR VPWR net83 sky130_fd_sc_hd__mux4_4
Xc142 net703 net65 net910 net911 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__or4bb_4
Xc186 net1 net916 net112 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__nand3b_1
Xc164 net88 net92 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__nor2_1
Xc175 net755 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__inv_1
Xc197 net126 net123 net75 net1023 net109 net111 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__mux4_4
XFILLER_0_87_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_99_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c360_CLK clknet_4_14_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout137_X net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_72_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c457_S0 clknet_1_0__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net309 clknet_0_net309 VGND VGND VPWR VPWR clknet_1_1__leaf_net309
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c231_SCD net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c84_Y net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c590_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_499 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_94_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c306_A0 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge907_Q net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_net887 clknet_0_net887 VGND VGND VPWR VPWR clknet_1_1__leaf_net887
+ sky130_fd_sc_hd__clkbuf_16
Xmax_cap1 net1096 VGND VGND VPWR VPWR net1095 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c581_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_6_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_86_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c179_Y net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c724_S1 net860 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c589_A2 net320 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c740_S0 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge785_B net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s946_Q net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input27_A in32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net139 clknet_0_net139 VGND VGND VPWR VPWR clknet_1_1__leaf_net139
+ sky130_fd_sc_hd__clkbuf_16
Xc91 net0 net27 net1086 VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__or3_1
Xc80 net4 net17 net16 net710 VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__or4bb_2
XFILLER_0_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0_net318 net318 VGND VGND VPWR VPWR clknet_0_net318 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net329 net329 VGND VGND VPWR VPWR clknet_0_net329 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c201_A net814 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc719 net432 net587 net549 net576 net561 net871 VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__mux4_1
Xc708 clknet_4_2_0_clk net574 clknet_1_1__leaf_net564 net432 net570 net1073 VGND VGND
+ VPWR VPWR net578 net577 sky130_fd_sc_hd__sdfbbn_1
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_89_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_100_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_1 net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c416_SCD clknet_2_0__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer13 net749 VGND VGND VPWR VPWR net1067 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net470 clknet_0_net470 VGND VGND VPWR VPWR clknet_1_1__leaf_net470
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_37_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net481 clknet_0_net481 VGND VGND VPWR VPWR clknet_1_1__leaf_net481
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_65_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c423_B net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net159 net159 VGND VGND VPWR VPWR clknet_0_net159 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc505 clknet_1_1__leaf_net384 clknet_1_0__leaf_net406 net403 net408 net42 net975 VGND
+ VGND VPWR VPWR net411 sky130_fd_sc_hd__mux4_1
Xc549 net419 net432 net71 net420 net430 net855 VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__mux4_1
Xc538 net412 net414 clknet_1_0__leaf_net318 net413 net958 VGND VGND VPWR VPWR net422
+ sky130_fd_sc_hd__a2111o_4
XFILLER_0_94_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_14_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c148_D1 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput71 net967 VGND VGND VPWR VPWR out17 sky130_fd_sc_hd__buf_2
Xoutput82 net978 VGND VGND VPWR VPWR out27 sky130_fd_sc_hd__clkbuf_1
Xoutput93 net989 VGND VGND VPWR VPWR out37 sky130_fd_sc_hd__buf_2
XANTENNA_c314_B1 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c485_D net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c199_A net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_355 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c321_X net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc302 net747 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__inv_4
Xc335 net724 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_75_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc313 net117 net1029 net101 net1028 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__or4bb_1
XFILLER_0_32_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c493_SET_B clknet_1_1__leaf_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc324 net896 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__inv_2
Xc368 net281 net282 net772 net792 VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__or4bb_2
Xc346 net265 net955 net267 net263 net266 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__a2111o_1
Xc357 net148 net1037 net1033 net1001 net842 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__o2111a_1
XFILLER_0_87_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge812 net206 net207 net934 net100 net222 clknet_1_0__leaf_net828 VGND VGND VPWR
+ VPWR net684 sky130_fd_sc_hd__mux4_4
XFILLER_0_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge801 net193 net194 net905 net196 VGND VGND VPWR VPWR net673 sky130_fd_sc_hd__or4bb_1
XFILLER_0_95_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge834 net572 net584 VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__and2_0
Xmerge823 net187 net186 net182 net1030 net100 net857 VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__mux4_1
Xmerge845 net229 net214 VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__nor2b_1
Xmerge856 net147 net150 VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__or2b_1
Xs940 clknet_4_5_0_clk net83 VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__dlclkp_4
Xmerge878 net454 clknet_4_3_0_clk net741 VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__dlrtp_2
Xmerge867 net514 net407 VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__and2_4
Xs951 clknet_4_14_0_clk net270 VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__dfxtp_2
Xs984 clknet_4_8_0_clk net608 VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__dfxtp_1
Xs973 net522 clknet_4_10_0_clk VGND VGND VPWR VPWR net870 net869 sky130_fd_sc_hd__dlxbn_2
Xs962 net446 clknet_4_1_0_clk VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__dlxtn_2
Xmerge889 clknet_4_4_0_clk net740 net673 VGND VGND VPWR VPWR net987 net768 sky130_fd_sc_hd__dfrbp_2
XFILLER_0_82_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer4 net154 VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_97_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c554_D_N clknet_2_1__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f_net345 clknet_0_net345 VGND VGND VPWR VPWR clknet_1_0__leaf_net345
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_80_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c121_B net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout146 net824 VGND VGND VPWR VPWR net1042 sky130_fd_sc_hd__clkbuf_4
Xfanout135 net1032 VGND VGND VPWR VPWR net1031 sky130_fd_sc_hd__buf_2
XANTENNA_input1_A in0 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c543_Y net427 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s971_CLK clknet_4_10_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c67_A net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc110 net656 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c595_C_N net791 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc154 net918 net957 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__nand2_8
Xc121 net37 net19 VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__nor2_1
Xc132 net920 net905 net910 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__and3b_2
Xc143 net953 net66 net905 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__nand3_4
XANTENNA_merge774_S1 net832 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc187 net724 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__clkbuf_1
Xc165 net775 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input57_A in6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc176 net985 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__buf_6
Xc198 net751 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__inv_1
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_2_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_93_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f_net164 clknet_0_net164 VGND VGND VPWR VPWR clknet_1_0__leaf_net164
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c336_B net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge814_A0 net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_1_1__f_net848_X clknet_1_1__leaf_net848 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input4_X net900 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c473_S0 net996 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c312_B_N net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_merge926_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1__f_net888 clknet_0_net888 VGND VGND VPWR VPWR clknet_1_1__leaf_net888
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge917_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s935_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge791_C_N net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c213_SCE net16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_1_1__f_net965_X clknet_1_1__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge782_C_N net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1__f_net107 clknet_0_net107 VGND VGND VPWR VPWR clknet_1_1__leaf_net107
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_7_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc70 net938 net0 net944 net927 net1043 VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__o2111a_2
Xc92 net9 net947 net823 VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__or3_2
Xc81 net644 VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_6
XFILLER_0_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c131_SCD net977 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc709 net567 net565 clknet_1_0__leaf_net470 net576 net573 clknet_1_0__leaf_net455
+ VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__mux4_2
XFILLER_0_31_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge811_A1 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c289_Y net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_rebuffer2_X net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer12_A net1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_10_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_5_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_2 net633 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s943_GATE clknet_4_12_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c416_SCE net1069 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c571_S0 net756 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_37_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net471 clknet_0_net471 VGND VGND VPWR VPWR clknet_1_1__leaf_net471
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net482 clknet_0_net482 VGND VGND VPWR VPWR clknet_1_1__leaf_net482
+ sky130_fd_sc_hd__clkbuf_16
Xrebuffer14 net105 VGND VGND VPWR VPWR net1068 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_65_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xc528 net75 net193 VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_9_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc539 net736 VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__clkbuf_1
XANTENNA_c746_S0 net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge793_X net665 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c97_A net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c148_C1 net906 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput94 net990 VGND VGND VPWR VPWR out38 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput72 clknet_1_1__leaf_net968 VGND VGND VPWR VPWR out18 sky130_fd_sc_hd__clkbuf_1
Xoutput83 net1037 VGND VGND VPWR VPWR out28 sky130_fd_sc_hd__buf_2
XANTENNA_c314_A1 net1046 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_62_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c334_SCD net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_70_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge891_CLK_N clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c566_S0 net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c285_S1 clknet_1_0__leaf_net829 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c240_B1 net1024 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c359_A net1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c559_RESET_B net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c154_Y net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c147_X net1011 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge817_B1 net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c249_D1 net837 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge929_Q_N net814 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xc303 clknet_4_6_0_clk net207 net224 net222 net211 net103 VGND VGND VPWR VPWR net1016
+ net225 sky130_fd_sc_hd__sdfbbn_2
Xc336 net132 net1036 net955 net215 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__or4bb_2
Xc325 clknet_1_0__leaf_net243 net244 net1036 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__and3_2
XFILLER_0_32_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc314 net1046 net215 net120 clknet_1_0__leaf_net829 net835 VGND VGND VPWR VPWR net236
+ sky130_fd_sc_hd__a2111oi_2
Xc358 net151 net999 net225 net158 net751 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__o2111ai_4
Xc347 net268 net254 net252 net266 net262 clknet_1_0__leaf_net829 VGND VGND VPWR VPWR
+ net269 sky130_fd_sc_hd__mux4_4
Xc369 clknet_4_14_0_clk net266 clknet_1_1__leaf_net283 net279 net264 clknet_1_1__leaf_net847
+ VGND VGND VPWR VPWR net291 net290 sky130_fd_sc_hd__sdfbbp_1
XANTENNA_c195_S1 net1040 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge806_X net678 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_86_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge802 net426 net528 net524 net530 VGND VGND VPWR VPWR net674 sky130_fd_sc_hd__or4bb_1
XFILLER_0_67_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge824 net101 net915 clknet_1_0__leaf_net1000 net12 net21 net17 VGND VGND VPWR
+ VPWR net696 sky130_fd_sc_hd__mux4_1
Xmerge835 net272 net259 VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__nor2b_1
Xmerge846 net457 net472 VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__and2b_1
XANTENNA_merge788_S0 net812 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge813 net373 net1021 net306 clknet_1_1__leaf_net375 clknet_1_0__leaf_net963 clknet_1_0__leaf_net384
+ VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__mux4_2
Xmerge857 net177 net637 VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__nor2b_4
Xs941 net99 clknet_4_7_0_clk VGND VGND VPWR VPWR net831 net830 sky130_fd_sc_hd__dlxbn_2
XFILLER_0_82_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge868 net687 clknet_4_7_0_clk net696 VGND VGND VPWR VPWR net747 net746 sky130_fd_sc_hd__dlrbp_1
Xs952 clknet_4_12_0_clk net271 VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__dfxtp_1
Xmerge879 net605 net520 VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__nor2_1
XFILLER_0_55_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs985 clknet_4_8_0_clk net610 VGND VGND VPWR VPWR net886 sky130_fd_sc_hd__dfxtp_2
Xs974 net535 clknet_4_0_0_clk VGND VGND VPWR VPWR net872 net871 sky130_fd_sc_hd__dlxbn_2
XFILLER_0_36_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs963 net449 clknet_4_1_0_clk VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__dlxtp_1
XANTENNA_c231_CLK_N clknet_4_13_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer5 clknet_0_net155 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_11_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_97_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output70_A net966 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_1_1__f_net204_A clknet_0_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net313 clknet_0_net313 VGND VGND VPWR VPWR clknet_1_0__leaf_net313
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_58_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c226_D net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout147 net5 VGND VGND VPWR VPWR net1043 sky130_fd_sc_hd__buf_4
Xfanout136 net1033 VGND VGND VPWR VPWR net1032 sky130_fd_sc_hd__clkbuf_4
Xfanout125 net1015 VGND VGND VPWR VPWR net1021 sky130_fd_sc_hd__clkbuf_4
XANTENNA_c271_Y net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c743_S1 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_s969_Q net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c529_X net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c67_B net919 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xc100 net34 net37 net7 VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__and3b_1
Xc111 net656 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__inv_4
Xc122 net48 net977 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__and2_0
Xc144 net723 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__inv_4
Xc133 net942 net905 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__nand2_4
XFILLER_0_20_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xc177 net725 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dlygate4sd1_1
Xc166 net90 net95 net957 net92 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__or4bb_1
Xc155 net957 net84 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__nand2b_4
Xc188 net106 net112 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__nor2b_2
Xc199 net751 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c169_C net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c343_D net131 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_0__f_net965_X clknet_1_0__leaf_net965 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c738_S1 net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_72_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c754_S0 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c473_S1 net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_83_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c303_Q net1016 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c306_A2 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_net889 clknet_0_net889 VGND VGND VPWR VPWR clknet_1_1__leaf_net889
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_net867 clknet_0_net867 VGND VGND VPWR VPWR clknet_1_1__leaf_net867
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_s989_GATE_N clknet_4_8_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c174_A net775 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c684_D_N net860 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge809_A1 net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c341_A net189 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout142_X net1038 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_merge844_CLK clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc93 net718 VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_1
Xc71 net949 net941 net939 VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__and3b_1
Xc82 net710 VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_1
XFILLER_0_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_net309 net309 VGND VGND VPWR VPWR clknet_0_net309 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_84_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c131_SCE net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c184_Y net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c177_X net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_c556_A net325 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c751_S1 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_s951_Q net844 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c370_SCE net148 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge858_GATE_N clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_net887 net887 VGND VGND VPWR VPWR clknet_0_net887 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_62_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c153_A0 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input32_A in37 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c370_Q net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_11_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output119_A net1015 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_20_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_3 net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c571_S1 net858 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_37_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net139 net139 VGND VGND VPWR VPWR clknet_0_net139 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_72_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c311_B net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c299_S0 net1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_77_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xc529 net931 net1030 VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__or2_4
XFILLER_0_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c148_B1 net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput84 net980 VGND VGND VPWR VPWR out29 sky130_fd_sc_hd__clkbuf_4
Xoutput73 net969 VGND VGND VPWR VPWR out19 sky130_fd_sc_hd__buf_2
XFILLER_0_37_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c314_A2 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput95 net991 VGND VGND VPWR VPWR out39 sky130_fd_sc_hd__clkbuf_1
XANTENNA_input35_X net931 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c180_D1 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_0__f_net204_A clknet_0_net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c339_C1 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c334_SCE net1036 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c355_D1 net839 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_hold40_A net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c359_B net825 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c254_A net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c465_A_N net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge817_A1 net526 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc315 net67 net230 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__or2_1
Xc326 net239 clknet_1_0__leaf_net245 clknet_1_1__leaf_net243 net221 net943 net727
+ VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__mux4_4
XFILLER_0_20_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc304 net224 net223 net1047 net770 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__or4bb_2
Xc359 net1029 net825 net831 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__nand3_1
Xc337 net16 net256 net254 net250 net131 net841 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__mux4_1
Xc348 net255 net187 net266 clknet_1_1__leaf_net1000 net265 net793 VGND VGND VPWR VPWR
+ net270 sky130_fd_sc_hd__mux4_4
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_99_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmerge803 net448 net335 net209 net322 net300 net859 VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__mux4_1
XFILLER_0_67_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmerge836 clknet_4_13_0_clk net670 net15 VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__dfrtn_1
XFILLER_0_95_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge788_S1 net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmerge825 clknet_1_0__leaf_net337 net335 net330 net932 net215 net208 VGND VGND VPWR
+ VPWR net697 sky130_fd_sc_hd__mux4_2
Xmerge814 net325 clknet_1_1__leaf_net329 net1028 net238 net1036 net838 VGND VGND VPWR
+ VPWR net686 sky130_fd_sc_hd__mux4_1
Xmerge869 net167 clknet_4_13_0_clk net698 VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__dlrtn_1
XFILLER_0_82_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmerge858 net160 clknet_4_15_0_clk net165 VGND VGND VPWR VPWR net735 net734 sky130_fd_sc_hd__dlrbn_1
Xs942 net125 clknet_4_12_0_clk VGND VGND VPWR VPWR net833 net832 sky130_fd_sc_hd__dlxbn_2
Xmerge847 net636 net620 VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__nand2b_2
XFILLER_0_55_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xs986 clknet_4_8_0_clk net611 VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__dlclkp_1
Xs975 net563 clknet_4_2_0_clk VGND VGND VPWR VPWR net874 net873 sky130_fd_sc_hd__dlxbp_1
Xs964 net456 clknet_4_3_0_clk VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__lpflow_inputisolatch_1
XFILLER_0_36_552 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xs953 clknet_4_11_0_clk net273 VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_11_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_net470 net470 VGND VGND VPWR VPWR clknet_0_net470 sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_net481 net481 VGND VGND VPWR VPWR clknet_0_net481 sky130_fd_sc_hd__clkbuf_16
Xrebuffer6 net985 VGND VGND VPWR VPWR net1010 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_63_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net303 clknet_0_net303 VGND VGND VPWR VPWR clknet_1_0__leaf_net303
+ sky130_fd_sc_hd__clkbuf_16
XANTENNA_c555_SCE net856 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_net347 clknet_0_net347 VGND VGND VPWR VPWR clknet_1_0__leaf_net347
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_c219_A2 net956 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout137 net1014 VGND VGND VPWR VPWR net1033 sky130_fd_sc_hd__buf_6
XANTENNA_c469_A net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c424_X net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc101 net779 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_16
XFILLER_0_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xc123 net56 net49 net977 net52 VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__or4bb_1
Xc112 net1048 net903 VGND VGND VPWR VPWR net1013 sky130_fd_sc_hd__nor2_1
Xc145 net723 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__inv_6
Xc134 net911 net1048 net920 VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__and3b_2
XFILLER_0_60_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc167 clknet_1_1__leaf_net94 net917 net84 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__or3_1
Xc156 net922 net64 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__nand2_2
Xc178 net85 clknet_1_1__leaf_net827 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__nor2b_2
Xc189 net954 net943 net910 net2 net929 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__a2111o_1
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc690 net543 net546 net860 VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__and3b_1
XANTENNA_s979_GATE clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_3_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_net155 clknet_0_net155 VGND VGND VPWR VPWR clknet_1_0__leaf_net155
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_74_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c584_CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge814_A2 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c292_CLK_N clknet_4_5_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c586_A net800 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input62_A in9 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_76_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_net868 clknet_0_net868 VGND VGND VPWR VPWR clknet_1_1__leaf_net868
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_61_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_merge809_A2 net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_c538_D1 net958 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout135_X net1031 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c749_S1 net886 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_100_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xc72 net7 net951 VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__nand2_1
Xc94 net919 net821 VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__and2b_1
Xc83 clknet_4_13_0_clk net1025 net20 net16 net710 VGND VGND VPWR VPWR net22 net21
+ sky130_fd_sc_hd__sdfrbp_1
XFILLER_0_93_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire121 net658 VGND VGND VPWR VPWR net1017 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_40_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c394_S1 net972 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c333_A1 net1028 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c358_D1 net751 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c569_S1 net858 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_60_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge811_A3 clknet_1_0__leaf_net963 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c106_D_N net1042 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_583 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge776_A net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0_net888 net888 VGND VGND VPWR VPWR clknet_0_net888 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c715_C1 clknet_2_0__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_91_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c495_S0 net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge829_X net701 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_101_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold40 net825 VGND VGND VPWR VPWR net1094 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_input25_A in30 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_4 net801 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c336_D_N net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_1__f_net473 clknet_0_net473 VGND VGND VPWR VPWR clknet_1_1__leaf_net473
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_88_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_net107 net107 VGND VGND VPWR VPWR clknet_0_net107 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_57_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_merge806_A3 net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c137_B net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_c416_D net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_c409_C clknet_2_1__leaf_net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_merge822_A2 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_c673_B net872 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_merge908_D net776 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_c310_C_N net935 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_94_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput63 net959 VGND VGND VPWR VPWR out1 sky130_fd_sc_hd__buf_2
Xoutput85 clknet_1_0__leaf_net981 VGND VGND VPWR VPWR out3 sky130_fd_sc_hd__clkbuf_1
Xoutput74 net970 VGND VGND VPWR VPWR out2 sky130_fd_sc_hd__buf_2
XANTENNA_c578_Q net462 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput96 net992 VGND VGND VPWR VPWR out4 sky130_fd_sc_hd__buf_2
XFILLER_0_37_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input28_X net924 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c180_C1 net826 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_c672_S1 net193 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_merge932_GATE clknet_4_15_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0__f_net529 clknet_0_net529 VGND VGND VPWR VPWR clknet_1_0__leaf_net529
+ sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_62_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_merge773_D1 net860 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_42_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_c371_D1 net792 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
.ends
